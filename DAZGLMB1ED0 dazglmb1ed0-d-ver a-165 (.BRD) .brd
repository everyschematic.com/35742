# Allegro board DAZGLMB1ED0 dazglmb1ed0-d-ver a-165 (.BRD) .brd (continued)
## Library data of the parts (continued)
L4234-L4237 PJ9020 PJ9027 PR7 PR9-PR16 PR18 PR23 PR28 PR29 PR31 PR33 PR39-PR41 PR43 PR44 PR49 PR51 PR59 PR83 PR84 PR86 PR97 PR98 PR101 PR106 PR111 PR112 PR114-PR116 PR118-PR120 PR124 PR126 PR138 PR139 PR146 PR161 PR167 PR168 PR177 PR178 PR181-PR186 PR188-PR190 PR204-PR207 PR211 PR255 PR263 PR265 PR267 PR268 PR287 PR298 PR305-PR308 PR311 PR416 PR417 PR701 PR702 PR705 PR2016 PR2019 PR2021-PR2023 PR2025 PR2027 PR2029 PR2031-PR2033 PR3020 PR3021 PR9001-PR9007 PR9010 PR9012-PR9021 PR9023-PR9027 PR9029-PR9032 PR9034-PR9037 PR9039 PR9040 PR9043 PR9045 PR9046 PR9048-PR9050 PR9052 PR9053 PR9058-PR9064 PR9066-PR9068 PR9072 PR9073 PR9119 PR9121-PR9124 PR9126 PR9128 PR9129 PR9131 PR9132 PR9136 PR9139-PR9142 PR9145 PR9147 PR9165 PR9208-PR9210 PR9215 PR9224 PR9227 PR9229 PR9231-PR9233 PR9235-PR9240 PR9242-PR9245 PR66832 PR66838 PR66840 PR66842 PR66851 PR66852 PR66855 PR66857 PR66858 PR66860 PR66862-PR66869 PR66875 PR66876 PR66878 PR66880 PR66882 PR66884 PR66885 PR66888 PR66890 PR66891 PR66896-PR66898 PR66902 PR66907 PR66912 PR66917 PR66922 PR66927 PR66931 PR66932 PR66938 PR66968-PR66972 PR66981-PR66986 PR66996 PR66998 PR67000 PR67002 PR67003 PR67009 PR67171-PR67174 PR67194 PR67217 PR67220 PR67223 PR67224 PR67226 PR67229-PR67235 PR67239 PR67240 R116 R124 R126 R129 R145 R178-R181 R184 R191-R195 R202 R204 R205 R222 R223 R229 R230 R381 R538 R539 R541 R542 R544 R545 R547 R549 R552 R559 R560 R563 R564 R566 R571 R578 R2708 R2709 R17808 R20751-R20757 R20761-R20768 R20811-R20815 R20818-R20820 R20824 R20848 R20881 R20912-R20918 R20923-R20925 R20929-R20932 R20934-R20936 R20938-R20949 R20951 R20955-R20957 R20959-R20964 R20966 R20967 R20970 R20972 R20985-R20988 R20994 R21010-R21013 R21016 R21018 R21026 R21032 R21039 R21049 R21052-R21054 R21056-R21061 R21063-R21068 R21076-R21090 R21092 R21093 R21095 R21096 R21098-R21105 R21107-R21112 R21114 R21116 R21118-R21121 R21124 R21126 R21128 R21130-R21134 R21136-R21140 R21142-R21144 R21146-R21151 R21153 R21157 R21159 R21164 R21165 R21170-R21174 R21176-R21178 R21187-R21190 R21192-R21196 R21198 R21200-R21205 R21207 R21210 R21212 R21214-R21236 R21238 R21240-R21254 R21256 R21258 R21259 R21261 R21270-R21272 R21274 R21276 R21277 R21279 R21281 R21283-R21298 R21300 R21301 R21303-R21305 R21309 R21311-R21313 R21316-R21319 R21324 R21326-R21329 R21360 R21387 R21389-R21412 R21414 R21416-R21436 R21438-R21441 R21446 R21449 R21450 R21453 R21456-R21459 R21462 R21466 R21469 R21475 R21478 R21482 R21484 R21486 R21490-R21492 R21494 R21495 R21502-R21504 R21506 R21509-R21513 R21522 R21523 R21528-R21573 R21575-R21606 R21608-R21620 R21679 R21685-R21687 R21689-R21695 R21702 R21703 R21705 R21707-R21710 R21714-R21720 R21725 R21734-R21736 R21738-R21755 R21769 R21789 R21797 R21801 R21802 R21859-R21870 R21872-R21877 R21879-R21883 R21885-R21977 R21979 R21981 R21982 R21984 R21986 R21988 R21992-R22003 R22005 R22007 R22010-R22025 R22029 R22048 R22050 R22060 R22063 R22066-R22070 R22083 R22084 R22087 R22089 R22091-R22093 R22097 R22100 R22101 R22118-R22125 R22128-R22135 R22137-R22141 R22143 R22147 R22148 R22150 R22154 R22164 R22166-R22168 R22185 R22187 R22188 R22194 R22195 R22198 R22199 R22202 R22203 R22208-R22214 R67012-R67015 R67018 R67019 R67022-R67025 R67027-R67031 R67035 R67050 R67072 R67112 R67115 R67116 R67118 R67119 R67121-R67128 R67131-R67134 R67136 R67139 R67140 R67144-R67148 R67163 R67167-R67173 R67176 R67179 R67180 R67185-R67188 R67190 R67191 R67195 R67197 R67199-R67205 R67212 R67214-R67217 R67220 R67221 R67223-R67243 R67245-R67251 R67257 R67260-R67263 R67265-R67270 R67273 R67274 R67276 R67278 R67280 R67285 R67290 R67299 R67300 R67302-R67304 R67308-R67311 R67321 R67323 R67325 R67328 R67331 R67337 R67338 R67340 R67342 R67351-R67353 R67358 R67359 R67362-R67365 R67369 R67370 R67373 R67374 R67376-R67380 R67386 R67388 R67389 R67393 R67398 R67401-R67408 = RES_BGM
L4247-L4249 L4251-L4257 = BW_BGM
LED1 LED2 = LED_4P_RGB_BGM
MR1 = HALL_IC_3P_BGM
PD1 PD9007 = SV1040_3P_BGM
PD2-PD4 = ZENER_DIODE_BGM
PD9003 = DIODE_BGM
PJ1 = Header_8P_BGM
PJ2 = DCJACK_11P_BGM
PJ9024 PJ9025 PR3 PR209 R67349 R67350 = R_Current_SEN_BGM
PJ9028 = Header_10P_2fix_BGM
PQ1 PQ2 = MOS-N_8P_ESD_BGM
PQ6 PQ12 PQ14 PQ19 PQ41 PQ147 PQ9000 PQ9001 PQ9010 PQ9011 PQ9021 PQ9031 PQ9032 PQ9034 PQ9050 PQ9054 PQ9059 PQ9080 PQ9082 PQ9084 PQ9086 PQ9089 Q20 Q32 Q44 Q7819 Q7820 Q7822 Q7823 Q7827 Q7828 Q7831 Q7832 Q7840 Q7843 Q7847-Q7849 Q7851-Q7857 Q7859 Q7861 Q7863-Q7867 Q7874-Q7880 Q7886 Q7888-Q7891 Q7901 Q7917 Q7927 Q7931-Q7934 Q7939 Q7941 Q7943-Q7945 Q7948 = MOS-N_3P_ESD_BGM
PQ8 PQ16 PQ9081 PQ9083 Q7821 Q7824 Q7844 Q7846 Q7937 Q7938 = DTC144EU_BGM
PQ9 PQ40 PQ9055 Q7845 = MOS-N_3P_BGM
PQ17 = MOS-P_3P_ESD_BGM
PQ21 PQ22 PQ9053 = MOS-N-Dual_9P_BGM
PQ29 PQ30 PQ9009 PQ9013 PQ9051 PQ9056 PQ9057 = MOS-N_8P_BGM
PQ9020 Q16 Q23 Q7834 Q7842 Q7902 Q7935 = NPN_BGM
PQ9049 PQ9052 PQ9058 = MOS-N_8P_SCH_BGM
PQ9087 PQ9088 Q7838 = MOS-P_3P_BGM
PR9000 = Thermistor_BGM
PR66871 PR66887 PR66895 = RES_B_BGM
PU1 = BQ24780SRUYR_BGM
PU5 PU8 PU9004 U13158 U13159 = AOZ1331DI_BGM
PU9 = TPS51225RUKR_BGM
PU12 = HPA01113AIRGVR_BGM
PU19 = G5719CTB1U_BGM
PU37 = MP2949AGQKT-0070-Z_BGM
PU38 PU39 PU44-PU46 = MP86903-CGLT-Z_BGM
PU43 = MP86901-AGQT_13P_BGM
PU2001 = RT8231BGQW_BGM
PU3002 = TMP708_BGM
PU8006 = TPS61087DRCR_BGM
PU9001 = UP9511QQKI_BGM
PU9005 = G9336ADJTP1U_BGM
PU9009 = RT8816AGQW_BGM
PU9010 = M5671RE1U_BGM
PU9011-PU9014 = FDMF3035_BGM
PU9015 = RT8237CZQW_2_BGM
Q34 Q35 Q42 Q7858 Q7860 Q7892 Q7896 Q7903 Q7904 Q7909 Q7911 Q7915 Q7916 Q7923 Q7926 Q7930 Q7947 Q7949 = MOS-N_Dual_6P_ESD_BGM
Q7833 Q7924 = AP2331SA-7-01_BGM
R251 R379 R382 R388 R395-R397 R400 R402 R403 R454 R618 R807 R812 R813 R815-R817 R823 R966 R20689 R20690 R20693 R20694 R20825-R20829 R20831 R20833-R20842 R20844-R20847 R20849 R20850 R20852-R20855 R20857-R20868 R20887 R20889-R20898 R20900-R20905 R22031 R22032 R22035 R22071 R22145 R22146 R22155 R22156 R22163 R22169-R22171 R22192 R22193 R67016 R67017 R67039 R67041-R67049 R67051 R67053-R67056 R67149-R67154 R67157 R67158 R67175 R67192 R67193 R67206 R67207 R67281 R67291 R67293-R67295 R67312 R67314 R67319 R67332 R67333 R67335 R67341 R67366 R67381 R67382 R67391 R67392 R67396 R67397 = RES_S_BGM
RP1 = RES_10P8R_BGM
SPAD1 = 3x2_0.1
SW1 = SW_4P_BGM
SW3 = SW_6
T3 T4 T7-T33 T56-T64 T71 T72 T76-T78 T91-T93 T96 T9005-T9025 T9028-T9036 TP1 TP13075 TP13076 TP13078 TP13083-TP13091 TP13093 TP13094 TP13100-TP13123 TP13125-TP13129 TP13137-TP13151 = TP_BGM
TP61-TP72 TP13152-TP13179 = PAD
U3 = PI6CEQ20200LIEX_20P_BGM
U21 = DSL6540_337P_BGM
U41 = CPU_SKL_H_1440P_BGM
U49 = IT8987E/CX_BGM
U53 U13098 U13102 U13115 U13120 = Logic_AND_BGM
U13025 U13079 = TUSB546I_BGM
U13064 = 74AUP1G07GW_BGM
U13076 = W25Q80BWSSIG_BGM
U13080 = SY6288C20AAC_BGM
U13081 = G5245AT11U_BGM
U13092 = G781_BGM
U13093 U13152 = TLC59116IRHBR_32P_BGM
U13103 = SPI_WND_8P_BGM
U13108 = ALC299-CG_48P_BGM
U13112 = NS892407_BGM
U13113 = SKY_H_PCH_BGA837_BGM
U13114 = GPU_N17E_2152P_BGM
U13116 = W25Q80DVSNIG_8P_BGM
U13117 = SPI_W25Q80EWSSIG_BGM
U13118 U13119 = NL17SZ32DFT2G_BGM
U13121 U13125 = G524B2T11U_BGM
U13122 U13123 U13127 = AZ1065-06F.R7G_10P-BGM
U13124 = PTN36242LBS_BGM
U13128 = TPS2544RTER_BGM_0
U13135 U13137 U13139 U13141 = GDDR5_MF1_190P_BGM
U13136 U13138 U13140 U13142 = GDDR5_MF0_190P_BGM
U13143 = E2500-R1V1-RL_BGM
U13146-U13149 = PS8559BQFN40GTR-A0_BGM
U13150 = SV3H715
U13151 = SV3S700A
U13155 = TPS65982ABZQZR_BGM
U13156 = MAX2659ELT+T_BGM
U13157 = ALC1006-VB-CGT_48P_BGM
U13161 = YB1253ST25X330_5P_BGM
Y3 Y1002-Y1004 = CRYSTAL_4P_BGM
Y1001 = CRYSTAL_2P_BGM

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
8P4R
  rect 0.406x1.092 smd: 1(-1.194,-0.8) 2(-1.194,0.8) 3(-0.406,-0.8) 4(-0.406,0.8) 5(0.406,-0.8) 6(0.406,0.8) 7(1.194,-0.8) 8(1.194,0.8)
10P8R
  rect 0.305x1.092 smd: 1(-1.27,-0.85) 2(-0.635,-0.85) 3(0,-0.85) 4(0.635,-0.85) 5(1.27,-0.85) 6(1.27,0.85) 7(0.635,0.85) 8(0,0.85) 9(-0.635,0.85) 10(-1.27,0.85)
50273-0040N-V09-4P-L
  rect 0.787x1.6 smd: 1(-1.875,2.9) 2(-0.625,2.9) 3(0.625,2.9) 4(1.875,2.9)
  rect 2.108x2.997 smd: 5(-4.425,0) 6(4.425,0)
50273-0060N-V09-6P-L
  rect 0.787x1.6 smd: 1(-3.125,2.9) 2(-1.875,2.9) 3(-0.625,2.9) 4(0.625,2.9) 5(1.875,2.9) 6(3.125,2.9)
  rect 2.108x2.997 smd: 7(-5.675,0) 8(5.675,0)
50278-006T1-001-6P-L
  rect 0.787x1.905 smd: 1(-3.125,4.925) 2(-1.875,4.925) 3(-0.625,4.925) 4(0.625,4.925) 5(1.875,4.925) 6(3.125,4.925)
  rect 1.295x3.353 smd: 7(-5.975,0) 8(5.975,0)
50281-00401-001-4P-L
  rect 0.787x2.007 smd: 1(-1.875,4.05) 2(-0.625,4.05) 3(0.625,4.05) 4(1.875,4.05)
  rect 2.007x2.489 smd: 5(-4.075,0) 6(4.075,0)
50458-00801-V02-8P-L
  rect 0.559x1.295 smd: 1(-7,5.025) 2(-5,5.025) 3(-3,5.025) 4(-1,5.025) 5(1,5.025) 6(3,5.025) 7(5,5.025) 8(7,5.025)
  rect 1.295x2.057 smd: 9(-10.1,0) 10(10.1,0)
50458-01001-V02-10P-L
  rect 0.559x1.295 smd: 1(-9,5.025) 2(-7,5.025) 3(-5,5.025) 4(-3,5.025) 5(-1,5.025) 6(1,5.025) 7(3,5.025) 8(5,5.025) 9(7,5.025) 10(9,5.025)
  rect 1.295x2.057 smd: 11(-12.1,0) 12(12.1,0)
50591-02601-V01-26P-L
  rect 0.61x1.092 smd: 1(-12.5,2.15) 2(-11.5,2.15) 3(-10.5,2.15) 4(-9.5,2.15) 5(-8.5,2.15) 6(-7.5,2.15) 7(-6.5,2.15) 8(-5.5,2.15) 9(-4.5,2.15) 10(-3.5,2.15) 11(-2.5,2.15) 12(-1.5,2.15) 13(-0.5,2.15) 14(0.5,2.15) 15(1.5,2.15) 16(2.5,2.15) 17(3.5,2.15) 18(4.5,2.15) 19(5.5,2.15) 20(6.5,2.15) 21(7.5,2.15) 22(8.5,2.15) 23(9.5,2.15) 24(10.5,2.15) 25(11.5,2.15) 26(12.5,2.15)
  rect 2.21x3.2 smd: 27(-15,0) 28(15,0)
51619-0080N-001-8P-L
  rect 0.305x1.295 smd: 1(-1.75,2.8) 2(-1.25,2.8) 3(-0.75,2.8) 4(-0.25,2.8) 5(0.25,2.8) 6(0.75,2.8) 7(1.25,2.8) 8(1.75,2.8)
  rect 1.803x1.397 smd: 9(-3.4,0) 10(3.4,0)
51619-0140N-001-14P-L
  rect 0.305x1.295 smd: 1(-3.25,2.8) 2(-2.75,2.8) 3(-2.25,2.8) 4(-1.75,2.8) 5(-1.25,2.8) 6(-0.75,2.8) 7(-0.25,2.8) 8(0.25,2.8) 9(0.75,2.8) 10(1.25,2.8) 11(1.75,2.8) 12(2.25,2.8) 13(2.75,2.8) 14(3.25,2.8)
  rect 1.803x1.397 smd: 15(-4.9,0) 16(4.9,0)
51619-0200N-V03-20P-L
  rect 0.305x1.295 smd: 1(-4.75,2.8) 2(-4.25,2.8) 3(-3.75,2.8) 4(-3.25,2.8) 5(-2.75,2.8) 6(-2.25,2.8) 7(-1.75,2.8) 8(-1.25,2.8) 9(-0.75,2.8) 10(-0.25,2.8) 11(0.25,2.8) 12(0.75,2.8) 13(1.25,2.8) 14(1.75,2.8) 15(2.25,2.8) 16(2.75,2.8) 17(3.25,2.8) 18(3.75,2.8) 19(4.25,2.8) 20(4.75,2.8)
  rect 1.803x1.397 smd: 21(-6.4,0) 22(6.4,0)
51653-0040N-V01-4P-L
  rect 0.305x1.295 smd: 1(-1.5,2.65) 2(-0.5,2.65) 3(0.5,2.65) 4(1.5,2.65)
  rect 1.803x1.397 smd: 5(-3.65,0) 6(3.65,0)
87212-0600-6P-L
  rect 0.61x1.549 smd: 1(-2.5,2.525) 2(-1.5,2.525) 3(-0.5,2.525) 4(0.5,2.525) 5(1.5,2.525) 6(2.5,2.525)
  rect 1.194x1.803 smd: 7(-3.8,0) 8(3.8,0)
196195-10021-10P-L
  rect 0.61x1.295 smd: 1(-4.5,2.925) 2(-3.5,2.925) 3(-2.5,2.925) 4(-1.5,2.925) 5(-0.5,2.925) 6(0.5,2.925) 7(1.5,2.925) 8(2.5,2.925) 9(3.5,2.925) 10(4.5,2.925)
  rect 1.803x1.397 smd: 11(-6.65,0.275) 12(6.65,0.275)
BGA96-TEXAS-TPS65982
  round 0.254 smd: A1(-2.5,-2.5) A2(-2.5,-2) A3(-2.5,-1.5) A4(-2.5,-1) A5(-2.5,-0.5) A6(-2.5,0) A7(-2.5,0.5) A8(-2.5,1) A9(-2.5,1.5) A10(-2.5,2) A11(-2.5,2.5) B1(-2,-2.5) B2(-2,-2) B3(-2,-1.5) B4(-2,-1) B5(-2,-0.5) B6(-2,0) B7(-2,0.5) B8(-2,1) B9(-2,1.5) B10(-2,2) B11(-2,2.5) C1(-1.5,-2.5) C2(-1.5,-2) C10(-1.5,2) C11(-1.5,2.5) D1(-1,-2.5) D2(-1,-2) D5(-1,-0.5) D6(-1,0) D7(-1,0.5) D8(-1,1) D10(-1,2) D11(-1,2.5) E1(-0.5,-2.5) E2(-0.5,-2) E4(-0.5,-1) E5(-0.5,-0.5) E6(-0.5,0) E7(-0.5,0.5) E8(-0.5,1) E10(-0.5,2) E11(-0.5,2.5) F1(0,-2.5) F2(0,-2) F4(0,-1) F5(0,-0.5) F6(0,0) F7(0,0.5) F8(0,1) F10(0,2) F11(0,2.5) G1(0.5,-2.5) G2(0.5,-2) G4(0.5,-1) G5(0.5,-0.5) G6(0.5,0) G7(0.5,0.5) G8(0.5,1) G10(0.5,2) G11(0.5,2.5) H1(1,-2.5) H2(1,-2) H4(1,-1) H5(1,-0.5) H6(1,0) H7(1,0.5) H8(1,1) H10(1,2) H11(1,2.5) J1(1.5,-2.5) J2(1.5,-2) J10(1.5,2) J11(1.5,2.5) K1(2,-2.5) K2(2,-2) K3(2,-1.5) K4(2,-1) K5(2,-0.5) K6(2,0) K7(2,0.5) K8(2,1) K9(2,1.5) K10(2,2) K11(2,2.5) L1(2.5,-2.5) L2(2.5,-2) L3(2.5,-1.5) L4(2.5,-1) L5(2.5,-0.5) L6(2.5,0) L7(2.5,0.5) L8(2.5,1) L9(2.5,1.5) L10(2.5,2) L11(2.5,2.5)
BGA190-MICRON-MT58K256M32
  round 0.305 smd: A1(-5.85,-4.225) A2(-5.85,-3.575) A3(-5.85,-2.925) A4(-5.85,-2.275) A5(-5.85,-1.625) A10(-5.85,1.625) A11(-5.85,2.275) A12(-5.85,2.925) A13(-5.85,3.575) A14(-5.85,4.225) B1(-5.2,-4.225) B2(-5.2,-3.575) B3(-5.2,-2.925) B4(-5.2,-2.275) B5(-5.2,-1.625) B10(-5.2,1.625) B11(-5.2,2.275) B12(-5.2,2.925) B13(-5.2,3.575) B14(-5.2,4.225) C1(-4.55,-4.225) C2(-4.55,-3.575) C3(-4.55,-2.925) C4(-4.55,-2.275) C5(-4.55,-1.625) C10(-4.55,1.625) C11(-4.55,2.275) C12(-4.55,2.925) C13(-4.55,3.575) C14(-4.55,4.225) D1(-3.9,-4.225) D2(-3.9,-3.575) D3(-3.9,-2.925) D4(-3.9,-2.275) D5(-3.9,-1.625) D10(-3.9,1.625) D11(-3.9,2.275) D12(-3.9,2.925) D13(-3.9,3.575) D14(-3.9,4.225) E1(-3.25,-4.225) E2(-3.25,-3.575) E3(-3.25,-2.925) E4(-3.25,-2.275) E5(-3.25,-1.625) E10(-3.25,1.625) E11(-3.25,2.275) E12(-3.25,2.925) E13(-3.25,3.575) E14(-3.25,4.225) F1(-2.6,-4.225) F2(-2.6,-3.575) F3(-2.6,-2.925) F4(-2.6,-2.275) F5(-2.6,-1.625) F10(-2.6,1.625) F11(-2.6,2.275) F12(-2.6,2.925) F13(-2.6,3.575) F14(-2.6,4.225) G1(-1.95,-4.225) G2(-1.95,-3.575) G3(-1.95,-2.925) G4(-1.95,-2.275) G5(-1.95,-1.625) G10(-1.95,1.625) G11(-1.95,2.275) G12(-1.95,2.925) G13(-1.95,3.575) G14(-1.95,4.225) H1(-1.3,-4.225) H2(-1.3,-3.575) H3(-1.3,-2.925) H4(-1.3,-2.275) H5(-1.3,-1.625) H10(-1.3,1.625) H11(-1.3,2.275) H12(-1.3,2.925) H13(-1.3,3.575) H14(-1.3,4.225) J1(-0.65,-4.225) J2(-0.65,-3.575) J3(-0.65,-2.925) J4(-0.65,-2.275) J5(-0.65,-1.625) J10(-0.65,1.625) J11(-0.65,2.275) J12(-0.65,2.925) J13(-0.65,3.575) J14(-0.65,4.225) K1(0,-4.225) K2(0,-3.575) K3(0,-2.925) K4(0,-2.275) K5(0,-1.625) K10(0,1.625) K11(0,2.275) K12(0,2.925) K13(0,3.575) K14(0,4.225) L1(0.65,-4.225) L2(0.65,-3.575) L3(0.65,-2.925) L4(0.65,-2.275) L5(0.65,-1.625) L10(0.65,1.625) L11(0.65,2.275) L12(0.65,2.925) L13(0.65,3.575) L14(0.65,4.225) M1(1.3,-4.225) M2(1.3,-3.575) M3(1.3,-2.925) M4(1.3,-2.275) M5(1.3,-1.625) M10(1.3,1.625) M11(1.3,2.275) M12(1.3,2.925) M13(1.3,3.575) M14(1.3,4.225) N1(1.95,-4.225) N2(1.95,-3.575) N3(1.95,-2.925) N4(1.95,-2.275) N5(1.95,-1.625) N10(1.95,1.625) N11(1.95,2.275) N12(1.95,2.925) N13(1.95,3.575) N14(1.95,4.225) P1(2.6,-4.225) P2(2.6,-3.575) P3(2.6,-2.925) P4(2.6,-2.275) P5(2.6,-1.625) P10(2.6,1.625) P11(2.6,2.275) P12(2.6,2.925) P13(2.6,3.575) P14(2.6,4.225) R1(3.25,-4.225) R2(3.25,-3.575) R3(3.25,-2.925) R4(3.25,-2.275) R5(3.25,-1.625) R10(3.25,1.625) R11(3.25,2.275) R12(3.25,2.925) R13(3.25,3.575) R14(3.25,4.225) T1(3.9,-4.225) T2(3.9,-3.575) T3(3.9,-2.925) T4(3.9,-2.275) T5(3.9,-1.625) T10(3.9,1.625) T11(3.9,2.275) T12(3.9,2.925) T13(3.9,3.575) T14(3.9,4.225) U1(4.55,-4.225) U2(4.55,-3.575) U3(4.55,-2.925) U4(4.55,-2.275) U5(4.55,-1.625) U10(4.55,1.625) U11(4.55,2.275) U12(4.55,2.925) U13(4.55,3.575) U14(4.55,4.225) V1(5.2,-4.225) V2(5.2,-3.575) V3(5.2,-2.925) V4(5.2,-2.275) V5(5.2,-1.625) V10(5.2,1.625) V11(5.2,2.275) V12(5.2,2.925) V13(5.2,3.575) V14(5.2,4.225) W1(5.85,-4.225) W2(5.85,-3.575) W3(5.85,-2.925) W4(5.85,-2.275) W5(5.85,-1.625) W10(5.85,1.625) W11(5.85,2.275) W12(5.85,2.925) W13(5.85,3.575) W14(5.85,4.225)
BGA337-INTEL-DSL6540
  round 0.254 smd: A1(-5.06,-5.06) A23(-5.06,5.06) AA2(4.14,-4.6) AA22(4.14,4.6) AB2(4.6,-4.6) AB3(4.6,-4.14) AB4(4.6,-3.68) AB5(4.6,-3.22) AB6(4.6,-2.76) AB7(4.6,-2.3) AB8(4.6,-1.84) AB9(4.6,-1.38) AB10(4.6,-0.92) AB11(4.6,-0.46) AB12(4.6,0) AB13(4.6,0.46) AB14(4.6,0.92) AB15(4.6,1.38) AB16(4.6,1.84) AB17(4.6,2.3) AB18(4.6,2.76) AB19(4.6,3.22) AB20(4.6,3.68) AB21(4.6,4.14) AB22(4.6,4.6) AC1(5.06,-5.06) AC23(5.06,5.06) B2(-4.6,-4.6) B3(-4.6,-4.14) B4(-4.6,-3.68) B5(-4.6,-3.22) B6(-4.6,-2.76) B7(-4.6,-2.3) B8(-4.6,-1.84) B9(-4.6,-1.38) B10(-4.6,-0.92) B11(-4.6,-0.46) B12(-4.6,0) B13(-4.6,0.46) B14(-4.6,0.92) B15(-4.6,1.38) B16(-4.6,1.84) B17(-4.6,2.3) B18(-4.6,2.76) B19(-4.6,3.22) B20(-4.6,3.68) B21(-4.6,4.14) B22(-4.6,4.6) C2(-4.14,-4.6) C22(-4.14,4.6) D2(-3.68,-4.6) D4(-3.9,-3.9) D5(-3.9,-3.25) D6(-3.9,-2.6) D8(-3.9,-1.95) D9(-3.9,-1.3) D11(-3.9,-0.65) D12(-3.9,0) D13(-3.9,0.65) D15(-3.9,1.3) D16(-3.9,1.95) D18(-3.9,2.6) D19(-3.9,3.25) D20(-3.9,3.9) D22(-3.68,4.6) E2(-3.22,-4.6) E4(-3.25,-3.9) E5(-3.25,-3.25) E6(-3.25,-2.6) E8(-3.25,-1.95) E9(-3.25,-1.3) E11(-3.25,-0.65) E12(-3.25,0) E13(-3.25,0.65) E15(-3.25,1.3) E16(-3.25,1.95) E18(-3.25,2.6) E19(-3.25,3.25) E20(-3.25,3.9) E22(-3.22,4.6) F2(-2.76,-4.6) F4(-2.6,-3.9) F5(-2.6,-3.25) F6(-2.6,-2.6) F8(-2.6,-1.95) F9(-2.6,-1.3) F11(-2.6,-0.65) F12(-2.6,0) F13(-2.6,0.65) F15(-2.6,1.3) F16(-2.6,1.95) F18(-2.6,2.6) F19(-2.6,3.25) F20(-2.6,3.9) F22(-2.76,4.6) G2(-2.3,-4.6) G22(-2.3,4.6) H2(-1.84,-4.6) H4(-1.95,-3.9) H5(-1.95,-3.25) H6(-1.95,-2.6) H8(-1.95,-1.95) H9(-1.95,-1.3) H11(-1.95,-0.65) H12(-1.95,0) H13(-1.95,0.65) H15(-1.95,1.3) H16(-1.95,1.95) H18(-1.95,2.6) H19(-1.95,3.25) H20(-1.95,3.9) H22(-1.84,4.6) J2(-1.38,-4.6) J4(-1.3,-3.9) J5(-1.3,-3.25) J6(-1.3,-2.6) J8(-1.3,-1.95) J9(-1.3,-1.3) J11(-1.3,-0.65) J12(-1.3,0) J13(-1.3,0.65) J15(-1.3,1.3) J16(-1.3,1.95) J18(-1.3,2.6) J19(-1.3,3.25) J20(-1.3,3.9) J22(-1.38,4.6) K2(-0.92,-4.6) K22(-0.92,4.6) L2(-0.46,-4.6) L4(-0.65,-3.9) L5(-0.65,-3.25) L6(-0.65,-2.6) L8(-0.65,-1.95) L9(-0.65,-1.3) L11(-0.65,-0.65) L12(-0.65,0) L13(-0.65,0.65) L15(-0.65,1.3) L16(-0.65,1.95) L18(-0.65,2.6) L19(-0.65,3.25) L20(-0.65,3.9) L22(-0.46,4.6) M2(0,-4.6) M4(0,-3.9) M5(0,-3.25) M6(0,-2.6) M8(0,-1.95) M9(0,-1.3) M11(0,-0.65) M12(0,0) M13(0,0.65) M15(0,1.3) M16(0,1.95) M18(0,2.6) M19(0,3.25) M20(0,3.9) M22(0,4.6) N2(0.46,-4.6) N4(0.65,-3.9) N5(0.65,-3.25) N6(0.65,-2.6) N8(0.65,-1.95) N9(0.65,-1.3) N11(0.65,-0.65) N12(0.65,0) N13(0.65,0.65) N15(0.65,1.3) N16(0.65,1.95) N18(0.65,2.6) N19(0.65,3.25) N20(0.65,3.9) N22(0.46,4.6) P2(0.92,-4.6) P22(0.92,4.6) R2(1.38,-4.6) R4(1.3,-3.9) R5(1.3,-3.25) R6(1.3,-2.6) R8(1.3,-1.95) R9(1.3,-1.3) R11(1.3,-0.65) R12(1.3,0) R13(1.3,0.65) R15(1.3,1.3) R16(1.3,1.95) R18(1.3,2.6) R19(1.3,3.25) R20(1.3,3.9) R22(1.38,4.6) T2(1.84,-4.6) T4(1.95,-3.9) T5(1.95,-3.25) T6(1.95,-2.6) T8(1.95,-1.95) T9(1.95,-1.3) T11(1.95,-0.65) T12(1.95,0) T13(1.95,0.65) T15(1.95,1.3) T16(1.95,1.95) T18(1.95,2.6) T19(1.95,3.25) T20(1.95,3.9) T22(1.84,4.6) U2(2.3,-4.6) U22(2.3,4.6) V2(2.76,-4.6) V4(2.6,-3.9) V5(2.6,-3.25) V6(2.6,-2.6) V8(2.6,-1.95) V9(2.6,-1.3) V11(2.6,-0.65) V12(2.6,0) V13(2.6,0.65) V15(2.6,1.3) V16(2.6,1.95) V18(2.6,2.6) V19(2.6,3.25) V20(2.6,3.9) V22(2.76,4.6) W2(3.22,-4.6) W4(3.25,-3.9) W5(3.25,-3.25) W6(3.25,-2.6) W8(3.25,-1.95) W9(3.25,-1.3) W11(3.25,-0.65) W12(3.25,0) W13(3.25,0.65) W15(3.25,1.3) W16(3.25,1.95) W18(3.25,2.6) W19(3.25,3.25) W20(3.25,3.9) W22(3.22,4.6) Y2(3.68,-4.6) Y4(3.9,-3.9) Y5(3.9,-3.25) Y6(3.9,-2.6) Y8(3.9,-1.95) Y9(3.9,-1.3) Y11(3.9,-0.65) Y12(3.9,0) Y13(3.9,0.65) Y15(3.9,1.3) Y16(3.9,1.95) Y18(3.9,2.6) Y19(3.9,3.25) Y20(3.9,3.9) Y22(3.68,4.6)
  oval 0.33x0.178 smd: A2(-5.06,-4.6) A3(-5.06,-4.14) A4(-5.06,-3.68) A5(-5.06,-3.22) A6(-5.06,-2.76) A7(-5.06,-2.3) A8(-5.06,-1.84) A9(-5.06,-1.38) A10(-5.06,-0.92) A11(-5.06,-0.46) A12(-5.06,0) A13(-5.06,0.46) A14(-5.06,0.92) A15(-5.06,1.38) A16(-5.06,1.84) A17(-5.06,2.3) A18(-5.06,2.76) A19(-5.06,3.22) A20(-5.06,3.68) A21(-5.06,4.14) A22(-5.06,4.6) AC2(5.06,-4.6) AC3(5.06,-4.14) AC4(5.06,-3.68) AC5(5.06,-3.22) AC6(5.06,-2.76) AC7(5.06,-2.3) AC8(5.06,-1.84) AC9(5.06,-1.38) AC10(5.06,-0.92) AC11(5.06,-0.46) AC12(5.06,0) AC13(5.06,0.46) AC14(5.06,0.92) AC15(5.06,1.38) AC16(5.06,1.84) AC17(5.06,2.3) AC18(5.06,2.76) AC19(5.06,3.22) AC20(5.06,3.68) AC21(5.06,4.14) AC22(5.06,4.6)
  oval 0.178x0.33 smd: AA1(4.14,-5.06) AA23(4.14,5.06) AB1(4.6,-5.06) AB23(4.6,5.06) B1(-4.6,-5.06) B23(-4.6,5.06) C1(-4.14,-5.06) C23(-4.14,5.06) D1(-3.68,-5.06) D23(-3.68,5.06) E1(-3.22,-5.06) E23(-3.22,5.06) F1(-2.76,-5.06) F23(-2.76,5.06) G1(-2.3,-5.06) G23(-2.3,5.06) H1(-1.84,-5.06) H23(-1.84,5.06) J1(-1.38,-5.06) J23(-1.38,5.06) K1(-0.92,-5.06) K23(-0.92,5.06) L1(-0.46,-5.06) L23(-0.46,5.06) M1(0,-5.06) M23(0,5.06) N1(0.46,-5.06) N23(0.46,5.06) P1(0.92,-5.06) P23(0.92,5.06) R1(1.38,-5.06) R23(1.38,5.06) T1(1.84,-5.06) T23(1.84,5.06) U1(2.3,-5.06) U23(2.3,5.06) V1(2.76,-5.06) V23(2.76,5.06) W1(3.22,-5.06) W23(3.22,5.06) Y1(3.68,-5.06) Y23(3.68,5.06)
BGA837-INTEL-SKYLAKE-PCH
  round 0.305 smd: A2(-10.814,-10.46) A3(-10.814,-9.959) A4(-10.814,-9.459) A42(-10.814,9.459) A43(-10.814,9.959) A44(-10.814,10.46) AA17(-0.775,-3.099) AA18(-0.775,-2.324) AA20(-0.775,-1.549) AA21(-0.775,-0.775) AA23(-0.775,0) AA25(-0.775,0.775) AA26(-0.775,1.549) AA28(-0.775,2.324) AA29(-0.775,3.099) AB7(-0.667,-8.175) AB8(-0.667,-7.413) AB10(-0.667,-6.651) AB11(-0.667,-5.889) AB13(-0.667,-5.127) AB14(-0.667,-4.365) AB15(-0.667,-3.807) AB31(-0.667,3.807) AB32(-0.667,4.365) AB33(-0.667,5.127) AB35(-0.667,5.889) AB36(-0.667,6.651) AB38(-0.667,7.413) AB39(-0.667,8.175) AC17(0,-3.099) AC18(0,-2.324) AC20(0,-1.549) AC21(0,-0.775) AC23(0,0) AC25(0,0.775) AC26(0,1.549) AC28(0,2.324) AC29(0,3.099) AD7(0.667,-8.175) AD8(0.667,-7.413) AD10(0.667,-6.651) AD11(0.667,-5.889) AD13(0.667,-5.127) AD14(0.667,-4.365) AD15(0.667,-3.807) AD31(0.667,3.807) AD32(0.667,4.365) AD33(0.667,5.127) AD35(0.667,5.889) AD36(0.667,6.651) AD38(0.667,7.413) AD39(0.667,8.175) AE17(0.775,-3.099) AE18(0.775,-2.324) AE20(0.775,-1.549) AE21(0.775,-0.775) AE23(0.775,0) AE25(0.775,0.775) AE26(0.775,1.549) AE28(0.775,2.324) AE29(0.775,3.099) AF17(1.549,-3.099) AF18(1.549,-2.324) AF20(1.549,-1.549) AF21(1.549,-0.775) AF23(1.549,0) AF25(1.549,0.775) AF26(1.549,1.549) AF28(1.549,2.324) AF29(1.549,3.099) AG7(1.772,-8.175) AG8(1.772,-7.413) AG10(1.772,-6.651) AG11(1.772,-5.889) AG13(1.772,-5.127) AG14(1.772,-4.365) AG15(1.772,-3.807) AG31(1.772,3.807) AG32(1.772,4.365) AG33(1.772,5.127) AG35(1.772,5.889) AG36(1.772,6.651) AG38(1.772,7.413) AG39(1.772,8.175) AH17(2.324,-3.099) AH18(2.324,-2.324) AH20(2.324,-1.549) AH21(2.324,-0.775) AH23(2.324,0) AH25(2.324,0.775) AH26(2.324,1.549) AH28(2.324,2.324) AH29(2.324,3.099) AJ7(2.953,-8.074) AJ8(2.953,-7.312) AJ10(2.953,-6.55) AJ11(2.953,-5.788) AJ13(2.953,-5.026) AJ14(2.953,-4.315) AJ15(2.953,-3.807) AJ17(3.099,-3.099) AJ18(3.099,-2.324) AJ20(3.099,-1.549) AJ21(3.099,-0.775) AJ23(3.099,0) AJ25(3.099,0.775) AJ26(3.099,1.549) AJ28(3.099,2.324) AJ29(3.099,3.099) AJ31(2.953,3.807) AJ32(2.953,4.365) AJ33(2.953,5.127) AJ35(2.953,5.889) AJ36(2.953,6.651) AJ38(2.953,7.413) AJ39(2.953,8.175) AL7(4.071,-8.074) AL8(4.071,-7.312) AL10(4.071,-6.55) AL11(4.071,-5.788) AL13(4.071,-5.026) AL17(3.807,-2.953) AL19(3.807,-1.772) AL22(3.807,-0.667) AL24(3.807,0.667) AL27(3.807,1.772) AL29(3.807,2.953) AL32(4.096,4.34) AL33(4.096,5.102) AL35(4.096,5.864) AL36(4.096,6.626) AL38(4.096,7.388) AL39(4.096,8.15) AM15(4.34,-4.096) AM17(4.365,-2.953) AM19(4.365,-1.772) AM22(4.365,-0.667) AM24(4.365,0.667) AM27(4.365,1.772) AM29(4.315,2.953) AN7(5.036,-8.023) AN8(4.985,-7.261) AN10(4.985,-6.499) AN11(5.026,-5.753) AN15(5.102,-4.096) AN17(5.127,-2.953) AN19(5.127,-1.772) AN22(5.127,-0.667) AN24(5.127,0.667) AN27(5.127,1.772) AN29(5.026,2.953) AN31(5.026,4.071) AN36(5.087,6.47) AN38(5.087,7.232) AN39(5.087,7.994) AP11(5.551,-6.04) AR7(6.037,-7.999) AR9(6.077,-7.084) AR15(5.864,-4.096) AR17(5.889,-2.953) AR19(5.889,-1.772) AR22(5.889,-0.667) AR24(5.889,0.667) AR27(5.889,1.772) AR29(5.788,2.953) AR31(5.788,4.071) AR33(5.753,5.026) AR34(6.04,5.551) AR38(6.068,7.396) AR39(6.068,8.158) AT9(6.713,-6.938) AT10(6.663,-6.311) AT13(6.47,-5.087) AT15(6.626,-4.096) AT17(6.651,-2.953) AT19(6.651,-1.772) AT22(6.651,-0.667) AT24(6.651,0.667) AT27(6.651,1.772) AT29(6.55,2.953) AT31(6.55,4.071) AT33(6.499,4.985) AT36(6.311,6.663) AU7(6.994,-7.936) AU35(7.084,6.077) AU36(6.938,6.713) AU39(7.141,7.991) AV6(7.645,-8.237) AV11(7.396,-6.068) AV13(7.232,-5.087) AV15(7.388,-4.096) AV17(7.413,-2.953) AV19(7.413,-1.772) AV22(7.413,-0.667) AV24(7.413,0.667) AV27(7.413,1.772) AV29(7.312,2.953) AV31(7.312,4.071) AV33(7.261,4.985) AW9(7.991,-7.141) AW11(8.158,-6.068) AW13(7.994,-5.087) AW15(8.15,-4.096) AW17(8.175,-2.953) AW19(8.175,-1.772) AW22(8.175,-0.667) AW24(8.175,0.667) AW27(8.175,1.772) AW29(8.074,2.953) AW31(8.074,4.071) AW33(8.023,5.036) AW35(7.999,6.037) AW37(7.936,6.994) AY5(8.585,-8.764) AY38(8.237,7.645) B1(-10.46,-10.814) B2(-10.33,-10.33) B3(-10.326,-9.824) B43(-10.304,9.8) B44(-10.33,10.33) B45(-10.46,10.814) BA40(8.764,8.585) BB1(9.459,-10.814) BB45(9.459,10.814) BC1(9.959,-10.814) BC2(9.824,-10.326) BC44(9.8,10.304) BC45(9.959,10.814) BD1(10.46,-10.814) BD2(10.33,-10.33) BD3(10.304,-9.8) BD43(10.326,9.824) BD44(10.33,10.33) BD45(10.46,10.814) BE2(10.814,-10.46) BE3(10.814,-9.959) BE4(10.814,-9.459) BE42(10.814,9.459) BE43(10.814,9.959) BE44(10.814,10.46) C1(-9.959,-10.814) C2(-9.8,-10.304) C42(-9.86,9.288) C44(-9.824,10.326) C45(-9.959,10.814) D1(-9.459,-10.814) D45(-9.459,10.814) F8(-8.237,-7.645) G9(-7.936,-6.994) G11(-7.999,-6.037) G13(-8.023,-5.036) G15(-8.074,-4.071) G17(-8.074,-2.953) G19(-8.175,-1.772) G22(-8.175,-0.667) G24(-8.175,0.667) G27(-8.175,1.772) G29(-8.175,2.953) G31(-8.15,4.096) G33(-7.994,5.087) G35(-8.158,6.068) G37(-7.991,7.141) H13(-7.261,-4.985) H15(-7.312,-4.071) H17(-7.312,-2.953) H19(-7.413,-1.772) H22(-7.413,-0.667) H24(-7.413,0.667) H27(-7.413,1.772) H29(-7.413,2.953) H31(-7.388,4.096) H33(-7.232,5.087) H35(-7.396,6.068) J7(-7.141,-7.991) J10(-6.938,-6.713) J11(-7.084,-6.077) J39(-6.994,7.936) K10(-6.311,-6.663) K13(-6.499,-4.985) K15(-6.55,-4.071) K17(-6.55,-2.953) K19(-6.651,-1.772) K22(-6.651,-0.667) K24(-6.651,0.667) K27(-6.651,1.772) K29(-6.651,2.953) K31(-6.626,4.096) K33(-6.47,5.087) K36(-6.663,6.311) K37(-6.713,6.938) L7(-6.068,-8.158) L8(-6.068,-7.396) L12(-6.04,-5.551) L13(-5.753,-5.026) L15(-5.788,-4.071) L17(-5.788,-2.953) L19(-5.889,-1.772) L22(-5.889,-0.667) L24(-5.889,0.667) L27(-5.889,1.772) L29(-5.889,2.953) L31(-5.864,4.096) L37(-6.077,7.084) L39(-6.037,7.999) M35(-5.551,6.04) N7(-5.087,-7.994) N8(-5.087,-7.232) N10(-5.087,-6.47) N15(-5.026,-4.071) N17(-5.026,-2.953) N19(-5.127,-1.772) N22(-5.127,-0.667) N24(-5.127,0.667) N27(-5.127,1.772) N29(-5.127,2.953) N31(-5.102,4.096) N35(-5.026,5.753) N36(-4.985,6.499) N38(-4.985,7.261) N39(-5.036,8.023) P17(-4.315,-2.953) P19(-4.365,-1.772) P22(-4.365,-0.667) P24(-4.365,0.667) P27(-4.365,1.772) P29(-4.365,2.953) P31(-4.34,4.096) R7(-4.096,-8.15) R8(-4.096,-7.388) R10(-4.096,-6.626) R11(-4.096,-5.864) R13(-4.096,-5.102) R14(-4.096,-4.34) R17(-3.807,-2.953) R19(-3.807,-1.772) R22(-3.807,-0.667) R24(-3.807,0.667) R27(-3.807,1.772) R29(-3.807,2.953) R33(-4.071,5.026) R35(-4.071,5.788) R36(-4.071,6.55) R38(-4.071,7.312) R39(-4.071,8.074) U7(-2.953,-8.175) U8(-2.953,-7.413) U10(-2.953,-6.651) U11(-2.953,-5.889) U13(-2.953,-5.127) U14(-2.953,-4.365) U15(-2.953,-3.807) U17(-3.099,-3.099) U18(-3.099,-2.324) U20(-3.099,-1.549) U21(-3.099,-0.775) U23(-3.099,0) U25(-3.099,0.775) U26(-3.099,1.549) U28(-3.099,2.324) U29(-3.099,3.099) U31(-2.953,3.807) U32(-2.953,4.315) U33(-2.953,5.026) U35(-2.953,5.788) U36(-2.953,6.55) U38(-2.953,7.312) U39(-2.953,8.074) V17(-2.324,-3.099) V18(-2.324,-2.324) V20(-2.324,-1.549) V21(-2.324,-0.775) V23(-2.324,0) V25(-2.324,0.775) V26(-2.324,1.549) V28(-2.324,2.324) V29(-2.324,3.099) W7(-1.772,-8.175) W8(-1.772,-7.413) W10(-1.772,-6.651) W11(-1.772,-5.889) W13(-1.772,-5.127) W14(-1.772,-4.365) W15(-1.772,-3.807) W31(-1.772,3.807) W32(-1.772,4.365) W33(-1.772,5.127) W35(-1.772,5.889) W36(-1.772,6.651) W38(-1.772,7.413) W39(-1.772,8.175) Y17(-1.549,-3.099) Y18(-1.549,-2.324) Y20(-1.549,-1.549) Y21(-1.549,-0.775) Y23(-1.549,0) Y25(-1.549,0.775) Y26(-1.549,1.549) Y28(-1.549,2.324) Y29(-1.549,3.099)
  round 0.279 smd: A5(-10.814,-8.959) A41(-10.814,8.959) BA1(8.959,-10.814) BA45(8.959,10.814) BE5(10.814,-8.959) BE41(10.814,8.959) E1(-8.959,-10.814) E45(-8.959,10.814)
  round 0.254 smd: A6(-10.814,-8.458) A25(-10.814,1.225) A40(-10.814,8.458) AB3(-0.609,-9.888) AB4(-0.482,-9.403) AB5(-0.667,-8.937) AB41(-0.667,8.937) AB42(-0.509,9.421) AC3(-0.096,-9.727) AD3(0.484,-9.929) AD4(0.509,-9.421) AD5(0.667,-8.937) AD41(0.667,8.937) AD42(0.482,9.403) AF3(1.664,-9.888) AF5(1.721,-8.885) AF41(1.721,8.887) AG3(2.178,-9.727) AG4(1.791,-9.403) AG42(1.764,9.421) AJ4(2.783,-9.421) AJ5(2.953,-8.836) AJ41(2.953,8.937) AJ42(2.756,9.403) AL3(3.937,-9.888) AL4(4.064,-9.403) AL5(4.071,-8.836) AL41(4.096,8.887) AL42(4.037,9.421) AM3(4.451,-9.727) AN3(5.03,-9.929) AN4(5.056,-9.421) AN5(5.163,-8.785) AN41(5.087,8.756) AN42(5.029,9.403) AR5(6.182,-8.886) AR41(6.068,8.92) AT4(6.338,-9.403) AT42(6.311,9.421) AU41(7.09,9.038) AU43(6.915,9.727) AV3(7.355,-9.929) AV4(7.321,-9.229) AV43(7.391,9.888) AW4(8.204,-9.434) AW42(7.816,9.24) AY1(8.458,-10.814) AY45(8.458,10.814) B6(-10.296,-8.45) B10(-10.235,-6.724) B25(-10.306,1.225) B40(-10.355,8.701) BA4(9.12,-9.602) BA5(9.095,-8.767) BA9(9.038,-7.09) BA11(8.92,-6.068) BA13(8.756,-5.087) BA15(8.887,-4.096) BA17(8.937,-2.953) BA20(8.887,-1.721) BA22(8.937,-0.667) BA24(8.937,0.667) BA26(8.885,1.721) BA29(8.836,2.953) BA31(8.836,4.071) BA33(8.785,5.163) BA35(8.886,6.182) BA41(8.767,9.095) BB3(9.344,-10.162) BB7(9.24,-7.816) BB10(9.421,-6.311) BB13(9.403,-5.029) BB15(9.421,-4.037) BB17(9.403,-2.756) BB19(9.421,-1.764) BB22(9.403,-0.482) BB24(9.421,0.509) BB27(9.403,1.791) BB29(9.421,2.783) BB31(9.403,4.064) BB33(9.421,5.056) BB36(9.403,6.338) BB38(9.229,7.321) BB39(9.434,8.204) BB41(9.602,9.12) BB43(9.288,9.86) BC4(9.86,-9.288) BC9(9.727,-6.915) BC42(10.162,9.344) BE6(10.814,-8.458) BE40(10.814,8.458) C8(-9.929,-7.355) C10(-9.727,-6.724) C11(-9.888,-6.211) C14(-9.727,-4.451) C15(-9.888,-3.937) C17(-9.929,-2.757) C19(-9.727,-2.178) C20(-9.888,-1.664) C23(-9.727,0.096) C24(-9.888,0.609) C27(-9.929,1.789) C28(-9.727,2.369) C29(-9.888,2.883) C31(-9.929,4.063) C32(-9.727,4.642) C33(-9.888,5.156) C36(-9.929,6.336) C37(-9.727,6.915) C38(-9.888,7.391) D3(-9.288,-9.86) D5(-9.602,-9.12) D7(-9.434,-8.204) D8(-9.229,-7.321) D10(-9.403,-6.338) D13(-9.421,-5.056) D15(-9.403,-4.064) D17(-9.421,-2.783) D19(-9.403,-1.791) D22(-9.421,-0.509) D24(-9.403,0.482) D27(-9.421,1.764) D29(-9.403,2.756) D31(-9.421,4.037) D33(-9.403,5.029) D36(-9.421,6.311) D39(-9.24,7.816) D43(-9.344,10.162) E5(-8.767,-9.095) E6(-8.764,-8.585) E11(-8.886,-6.182) E13(-8.785,-5.163) E15(-8.836,-4.071) E17(-8.836,-2.953) E20(-8.885,-1.721) E22(-8.937,-0.667) E24(-8.937,0.667) E26(-8.887,1.721) E29(-8.937,2.953) E31(-8.887,4.096) E33(-8.756,5.087) E35(-8.92,6.068) E37(-9.038,7.09) E41(-9.095,8.767) E42(-9.12,9.602) F1(-8.458,-10.814) F41(-8.585,8.764) F44(-8.45,10.296) F45(-8.458,10.814) G4(-7.816,-9.24) G42(-8.204,9.434) H2(-7.391,-10.396) H3(-7.391,-9.888) H40(-7.645,8.237) H42(-7.321,9.229) H43(-7.355,9.929) J2(-6.915,-10.235) J3(-6.915,-9.727) J5(-7.09,-9.038) K2(-6.432,-10.428) K3(-6.336,-9.929) K4(-6.311,-9.421) K42(-6.338,9.403) K43(-6.724,9.727) L5(-6.068,-8.92) L41(-6.182,8.886) L43(-6.211,9.888) N3(-5.156,-9.888) N4(-5.029,-9.403) N5(-5.087,-8.756) N41(-5.163,8.785) N42(-5.056,9.421) P3(-4.642,-9.727) R4(-4.037,-9.421) R5(-4.096,-8.887) R41(-4.071,8.836) R42(-4.064,9.403) U3(-2.883,-9.888) U4(-2.756,-9.403) U5(-2.953,-8.937) U41(-2.953,8.836) U42(-2.783,9.421) V3(-2.369,-9.727) W3(-1.789,-9.929) W4(-1.764,-9.421) W42(-1.791,9.403) Y5(-1.721,-8.887) Y41(-1.721,8.885)
  oval 0.254x0.203 smd: A7(-10.814,-7.893) A9(-10.814,-6.852) A37(-10.814,6.839) A39(-10.814,7.893) B7(-10.306,-7.944) B39(-10.306,7.944) BC8(9.888,-7.391) BD6(10.355,-8.701) BD7(10.306,-7.944) BD36(10.235,6.724) BD39(10.306,7.944) BE7(10.814,-7.893) BE9(10.814,-6.839) BE37(10.814,6.852) BE39(10.814,7.893)
  oval 0.254x0.152 smd: A12(-10.814,-5.595) A14(-10.814,-4.553) A16(-10.814,-3.321) A18(-10.814,-2.28) A21(-10.814,-1.048) A23(-10.814,-0.007) A28(-10.814,2.267) A32(-10.814,4.54) B8(-10.428,-7.258) B11(-10.396,-6.211) B13(-10.428,-4.934) B15(-10.396,-3.937) B18(-10.428,-2.661) B19(-10.235,-2.178) B20(-10.396,-1.664) B22(-10.428,-0.388) B24(-10.396,0.609) B27(-10.428,1.886) B33(-10.396,5.156) B36(-10.428,6.432) BD10(10.428,-6.432) BD13(10.396,-5.156) BD14(10.235,-4.642) BD15(10.428,-4.159) BD17(10.396,-2.883) BD18(10.235,-2.369) BD19(10.428,-1.886) BD22(10.396,-0.609) BD23(10.235,-0.096) BD24(10.428,0.388) BD26(10.396,1.664) BD27(10.235,2.178) BD28(10.428,2.661) BD31(10.396,3.937) BD32(10.235,4.451) BD33(10.428,4.934) BD35(10.396,6.211) BD38(10.428,7.258) BE11(10.814,-5.772) BE14(10.814,-4.54) BE16(10.814,-3.499) BE18(10.814,-2.267) BE21(10.814,-1.225) BE23(10.814,0.007) BE25(10.814,1.048) BE28(10.814,2.28) BE30(10.814,3.321) BE32(10.814,4.553) BE34(10.814,5.595)
  custom 0.051x0.051 smd: A30(-10.814,3.499) A35(-10.814,5.772) AA2(-1.225,-10.306) AA44(-1.048,10.306) AB43(-0.484,9.929) AD43(0.609,9.888) AE2(1.048,-10.306) AE44(1.225,10.306) AG43(1.789,9.929) AJ3(2.757,-9.929) AJ43(2.883,9.888) AK2(3.321,-10.306) AK44(3.499,10.306) AL43(4.063,9.929) AM2(4.451,-10.235) AN43(5.156,9.888) AP2(5.595,-10.306) AR3(6.211,-9.888) AR44(5.772,10.306) AT43(6.336,9.929) AU44(6.915,10.235) AV44(7.391,10.396) B12(-10.306,-5.595) B14(-10.235,-4.451) B16(-10.306,-3.321) B21(-10.306,-1.048) B23(-10.235,0.096) B29(-10.396,2.883) B30(-10.306,3.499) B31(-10.428,4.159) B32(-10.235,4.642) B35(-10.306,5.772) B37(-10.235,6.915) B38(-10.396,7.391) BC10(9.929,-6.336) BC13(9.888,-5.156) BC15(9.929,-4.063) BC17(9.888,-2.883) BC19(9.929,-1.789) BC22(9.888,-0.609) BC24(9.929,0.484) BC26(9.888,1.664) BC29(9.929,2.757) BC31(9.888,3.937) BC33(9.929,5.03) BC35(9.888,6.211) BC38(9.929,7.355) BD8(10.396,-7.391) BD9(10.235,-6.915) BD11(10.306,-5.772) BD16(10.306,-3.499) BD21(10.306,-1.225) BD25(10.306,1.048) BD30(10.306,3.321) BD34(10.306,5.595) C13(-9.929,-5.03) C22(-9.929,-0.484) L2(-5.772,-10.306) M44(-5.595,10.306) N43(-5.03,9.929) P2(-4.642,-10.235) R2(-4.159,-10.428) R3(-4.063,-9.929) R43(-3.937,9.888) T1(-3.499,-10.814) T2(-3.499,-10.306) T44(-3.321,10.306) U2(-2.883,-10.396) U43(-2.757,9.929) V2(-2.369,-10.235) Y43(-1.664,9.888)
  oval 0.152x0.254 smd: AA1(-1.225,-10.814) AA45(-1.048,10.814) AB2(-0.609,-10.396) AB44(-0.388,10.428) AC1(0.007,-10.814) AC2(-0.096,-10.235) AC44(0.096,10.235) AC45(-0.007,10.814) AD2(0.388,-10.428) AD44(0.609,10.396) AE1(1.048,-10.814) AE45(1.225,10.814) AF2(1.664,-10.396) AG2(2.178,-10.235) AG44(1.886,10.428) AH1(2.28,-10.814) AH2(2.661,-10.428) AH44(2.369,10.235) AH45(2.267,10.814) AJ44(2.883,10.396) AK1(3.321,-10.814) AK45(3.499,10.814) AL2(3.937,-10.396) AL44(4.159,10.428) AM1(4.553,-10.814) AM44(4.642,10.235) AM45(4.54,10.814) AN2(4.934,-10.428) AN44(5.156,10.396) AP1(5.595,-10.814) AR2(6.211,-10.396) AR45(5.772,10.814) AT44(6.432,10.428) AV2(7.258,-10.428) L1(-5.772,-10.814) L44(-6.211,10.396) M45(-5.595,10.814) N2(-5.156,-10.396) N44(-4.934,10.428) P1(-4.54,-10.814) P44(-4.451,10.235) P45(-4.553,10.814) R44(-3.937,10.396) T45(-3.321,10.814) V1(-2.267,-10.814) V44(-2.661,10.428) V45(-2.28,10.814) W2(-1.886,-10.428) W44(-2.178,10.235) Y44(-1.664,10.396)
  round 0.368 smd: AA4(-1.225,-9.326) AA42(-1.048,9.324) AE4(1.048,-9.324) AE42(1.225,9.326) AK4(3.321,-9.324) AK42(3.499,9.327) AP4(5.595,-9.324) AR42(5.772,9.327) AY2(8.45,-10.296) BB11(9.326,-5.772) BB16(9.326,-3.498) BB21(9.326,-1.225) BB25(9.324,1.048) BB30(9.324,3.321) BB34(9.324,5.595) BD40(10.296,8.45) C4(-10.162,-9.344) D12(-9.324,-5.595) D16(-9.324,-3.321) D21(-9.324,-1.048) D25(-9.326,1.225) D30(-9.326,3.499) D35(-9.326,5.772) L4(-5.772,-9.326) M42(-5.595,9.324) T4(-3.499,-9.326) T42(-3.321,9.324)
  custom 0.057x0.057 smd: AC43(0.096,9.727) AH43(2.369,9.727) AM43(4.642,9.727) AT3(6.724,-9.727) B28(-10.235,2.369) BC14(9.727,-4.642) BC18(9.727,-2.369) BC23(9.727,-0.096) BC27(9.727,2.178) BC32(9.727,4.451) BC36(9.727,6.724) P43(-4.451,9.727) W43(-2.178,9.727)
  oval 0.203x0.254 smd: AT2(6.724,-10.235) AU1(6.852,-10.814) AU45(6.839,10.814) AW1(7.893,-10.814) AW2(7.944,-10.306) AW44(7.944,10.306) AW45(7.893,10.814) AY44(8.701,10.355) F2(-8.701,-10.355) G1(-7.893,-10.814) G2(-7.944,-10.306) G44(-7.944,10.306) G45(-7.893,10.814) H44(-7.258,10.428) J1(-6.839,-10.814) J45(-6.852,10.814) K44(-6.724,10.235)
BGA1440-INTEL-SKYLAKE-H
  round 0.406 smd: A3(-20.314,-12.06) A37(-20.314,12.739) B2(-19.654,-12.654) B38(-19.761,13.314) BR1(19.748,-13.314) BR38(19.722,13.314) BT2(20.314,-12.743) BT37(20.314,12.722) C1(-19.047,-13.314)
  round 0.381 smd: A4(-20.314,-11.343) A34(-20.314,11.146) A36(-20.314,11.958) AA13(-5.766,-5.502) AA14(-5.766,-4.851) AA29(-5.899,7.411) AA30(-5.899,8.061) AB29(-5.111,7.411) AB30(-5.111,8.061) AC13(-4.852,-5.502) AC14(-4.852,-4.851) AC29(-4.324,7.411) AC30(-4.324,8.061) AD13(-3.937,-5.502) AD14(-3.937,-4.851) AD29(-3.537,7.411) AD30(-3.537,8.061) AE13(-3.023,-5.502) AE14(-3.023,-4.851) AE29(-2.749,7.411) AE30(-2.749,8.061) AF13(-2.108,-5.502) AF14(-2.108,-4.851) AF29(-1.962,7.411) AF30(-1.962,8.061) AG13(-1.194,-5.502) AG14(-1.194,-4.851) AG29(-1.174,7.411) AG30(-1.174,8.061) AH13(-0.28,-5.502) AH14(-0.28,-4.851) AH29(-0.387,7.411) AH30(-0.387,8.061) AJ13(0.635,-5.502) AJ14(0.635,-4.851) AJ29(0.4,7.411) AJ30(0.4,8.061) AK29(1.188,7.411) AK30(1.188,8.061) AL13(1.549,-5.502) AL14(1.549,-4.851) AL29(1.975,7.411) AL30(1.975,8.061) AM13(2.464,-5.502) AM14(2.464,-4.851) AM29(2.763,7.411) AM30(2.763,8.061) AN13(3.378,-5.502) AN14(3.378,-4.851) AN29(3.55,7.411) AN30(3.55,8.061) AP13(4.292,-5.502) AP14(4.292,-4.851) AP29(4.337,7.411) AP30(4.337,8.061) AR13(5.207,-5.502) AR14(5.207,-4.851) AR29(5.125,7.411) AR30(5.125,8.061) AT13(6.121,-5.502) AT14(6.121,-4.851) AT29(5.912,7.411) AT30(5.912,8.061) AU13(7.036,-5.502) AU14(7.036,-4.851) AU29(6.7,7.411) AU30(6.7,8.061) AV29(7.487,7.411) AV30(7.487,8.061) AW13(7.95,-5.502) AW14(7.95,-4.851) AW29(8.274,7.411) AW30(8.274,8.061) AY13(8.864,-5.502) AY14(8.864,-4.851) AY29(9.062,7.411) AY30(9.062,8.061) B3(-19.616,-11.933) B37(-19.612,12.595) BA13(9.779,-5.502) BA14(9.779,-4.851) BA29(9.849,7.411) BA30(9.849,8.061) BB13(10.693,-5.502) BB14(10.693,-4.851) BB29(10.637,7.411) BB30(10.637,8.061) BC13(11.608,-5.502) BC14(11.608,-4.851) BC29(11.424,7.411) BC30(11.424,8.061) BD13(12.522,-5.502) BD14(12.522,-4.851) BD29(12.211,7.411) BD30(12.211,8.061) BE29(12.999,7.411) BE30(12.999,8.061) BF13(13.436,-5.502) BF14(13.436,-4.851) BF29(13.786,7.411) BF30(13.786,8.061) BG13(14.351,-5.502) BG14(14.351,-4.851) BG29(14.574,7.411) BG30(14.574,8.061) BH13(15.265,-5.502) BH14(15.227,-4.851) BH29(15.234,7.411) BH30(15.361,8.061) BJ13(15.812,-5.144) BJ14(15.762,-4.463) BJ15(15.762,-3.713) BJ16(15.762,-2.926) BJ17(15.762,-2.139) BJ18(15.762,-1.351) BJ19(15.762,-0.564) BJ20(15.762,0.224) BJ21(15.762,1.011) BJ22(15.762,1.798) BJ23(15.762,2.586) BJ24(15.762,3.373) BJ25(15.762,4.161) BJ26(15.762,4.948) BJ27(15.762,5.735) BJ28(15.762,6.523) BJ29(15.844,7.183) BJ30(16.015,8.039) BK14(16.413,-4.501) BK15(16.413,-3.713) BK16(16.413,-2.926) BK17(16.413,-2.139) BK18(16.413,-1.351) BK19(16.413,-0.564) BK20(16.413,0.224) BK21(16.413,1.011) BK22(16.413,1.798) BK23(16.413,2.586) BK24(16.413,3.373) BK25(16.413,4.161) BK26(16.413,4.948) BK27(16.413,5.735) BK28(16.413,6.523) BK29(16.421,7.518) BN1(18.3,-13.314) BN38(18.285,13.314) BP1(19.024,-13.314) BP38(18.996,13.314) BR2(19.619,-12.596) BR37(19.613,12.59) BT3(20.314,-12.019) BT4(20.314,-11.295) BT35(20.314,11.184) BT36(20.314,11.996) C2(-18.953,-12.616) C38(-18.98,13.314) D1(-18.323,-13.314) D38(-18.218,13.314) H13(-15.712,-5.059) H14(-15.712,-4.272) H15(-15.712,-3.484) H16(-15.712,-2.697) H17(-15.712,-1.91) H18(-15.712,-1.122) H19(-15.712,-0.335) H20(-15.712,0.453) H21(-15.712,1.24) H22(-15.712,2.027) H23(-15.712,2.815) H24(-15.712,3.602) H25(-15.712,4.39) H26(-15.712,5.177) H27(-15.712,5.964) H28(-15.712,6.752) H29(-15.762,7.539) J14(-15.061,-4.272) J15(-15.061,-3.484) J16(-15.061,-2.697) J17(-15.061,-1.91) J18(-15.061,-1.122) J19(-15.061,-0.335) J20(-15.061,0.453) J21(-15.061,1.24) J22(-15.061,2.027) J23(-15.061,2.815) J24(-15.061,3.602) J25(-15.061,4.39) J26(-15.061,5.177) J27(-15.061,5.964) J28(-15.061,6.752) J30(-15.146,7.747) K13(-15.138,-5.436) K14(-14.656,-4.851) K29(-14.56,7.411) K30(-14.56,8.061) L13(-13.996,-5.502) L14(-13.996,-4.851) L29(-13.773,7.411) L30(-13.773,8.061) M13(-13.081,-5.502) M14(-13.081,-4.851) M29(-12.985,7.411) M30(-12.985,8.061) N13(-12.167,-5.502) N14(-12.167,-4.851) N29(-12.198,7.411) N30(-12.198,8.061) P13(-11.252,-5.502) P14(-11.252,-4.851) P29(-11.411,7.411) P30(-11.411,8.061) R13(-10.338,-5.502) R14(-10.338,-4.851) R29(-10.623,7.411) R30(-10.623,8.061) T13(-9.424,-5.502) T14(-9.424,-4.851) T29(-9.836,7.411) T30(-9.836,8.061) U29(-9.048,7.411) U30(-9.048,8.061) V13(-8.509,-5.502) V14(-8.509,-4.851) V29(-8.261,7.411) V30(-8.261,8.061) W13(-7.595,-5.502) W14(-7.595,-4.851) W29(-7.474,7.411) W30(-7.474,8.061) Y13(-6.68,-5.502) Y14(-6.68,-4.851) Y29(-6.686,7.411) Y30(-6.686,8.061)
  round 0.356 smd: A5(-20.314,-10.543) A33(-20.314,10.345) B4(-19.344,-11.283) B36(-19.613,11.884) BM1(17.5,-13.314) BM38(17.573,13.314) BP2(18.965,-12.486) BP37(18.943,12.374) BR3(19.664,-11.927) BR36(19.657,11.879) BT5(20.314,-10.495) BT34(20.314,10.384) C37(-18.912,12.594) D3(-18.492,-12.081) E1(-17.536,-13.314) E38(-17.418,13.314)
  round 0.33 smd: A6(-20.314,-9.768) A32(-20.314,9.558) AA11(-5.766,-6.802) AA12(-5.766,-6.152) AC11(-4.852,-6.802) AC12(-4.852,-6.152) AD11(-3.937,-6.802) AD12(-3.937,-6.152) AE11(-3.023,-6.802) AE12(-3.023,-6.152) AF11(-2.108,-6.802) AF12(-2.108,-6.152) AG11(-1.194,-6.802) AG12(-1.194,-6.152) AH11(-0.28,-6.802) AH12(-0.28,-6.152) AJ11(0.635,-6.802) AJ12(0.635,-6.152) AL11(1.549,-6.802) AL12(1.549,-6.152) AM11(2.464,-6.802) AM12(2.464,-6.152) AN11(3.378,-6.802) AN12(3.378,-6.152) AP11(4.292,-6.802) AP12(4.292,-6.152) AR11(5.207,-6.802) AR12(5.207,-6.152) AT11(6.121,-6.802) AT12(6.121,-6.152) AU11(7.036,-6.802) AU12(7.036,-6.152) AW11(7.95,-6.802) AW12(7.95,-6.152) AY11(8.864,-6.802) AY12(8.864,-6.152) B5(-19.664,-10.571) B34(-19.645,11.129) BA11(9.779,-6.802) BA12(9.779,-6.152) BB11(10.693,-6.802) BB12(10.693,-6.152) BC11(11.608,-6.802) BC12(11.608,-6.152) BD11(12.522,-6.802) BD12(12.522,-6.152) BF11(13.436,-6.802) BF12(13.436,-6.152) BG11(14.351,-6.802) BG12(14.351,-6.152) BH11(15.265,-6.802) BH12(15.265,-6.152) BJ11(16.18,-6.802) BJ12(16.091,-6.032) BK1(16.722,-13.314) BK13(16.413,-5.415) BL38(16.862,13.314) BN2(18.328,-12.664) BN37(18.35,12.651) BR5(19.67,-11.148) BR35(19.664,11.222) BT6(20.314,-9.721) BT32(20.314,9.609) D37(-18.329,12.289) E2(-17.84,-12.664) G1(-16.733,-13.314) G38(-16.643,13.314) K11(-14.834,-6.802) K12(-14.834,-6.152) L11(-13.996,-6.802) L12(-13.996,-6.152) M11(-13.081,-6.802) M12(-13.081,-6.152) N11(-12.167,-6.802) N12(-12.167,-6.152) P11(-11.252,-6.802) P12(-11.252,-6.152) R11(-10.338,-6.802) R12(-10.338,-6.152) T11(-9.424,-6.802) T12(-9.424,-6.152) V11(-8.509,-6.802) V12(-8.509,-6.152) W11(-7.595,-6.802) W12(-7.595,-6.152) Y11(-6.68,-6.802) Y12(-6.68,-6.152)
  round 0.305 smd: A8(-20.314,-8.996) A9(-20.314,-8.209) A10(-20.314,-7.421) A11(-20.314,-6.634) A12(-20.314,-5.847) A13(-20.314,-5.059) A14(-20.314,-4.272) A15(-20.314,-3.484) A16(-20.314,-2.697) A17(-20.314,-1.91) A18(-20.314,-1.122) A19(-20.314,-0.335) A20(-20.314,0.453) A21(-20.314,1.24) A22(-20.314,2.027) A23(-20.314,2.815) A24(-20.314,3.602) A25(-20.314,4.39) A26(-20.314,5.177) A27(-20.314,5.964) A28(-20.314,6.752) A29(-20.314,7.539) A30(-20.314,8.53) AA1(-6.295,-13.314) AA2(-6.295,-12.664) AA3(-6.295,-12.014) AA4(-6.295,-11.363) AA5(-6.295,-10.713) AA6(-6.346,-10.063) AA7(-5.766,-9.403) AA8(-5.766,-8.753) AA9(-5.766,-8.103) AA10(-5.766,-7.452) AA31(-5.899,8.762) AA32(-5.899,9.413) AA33(-5.899,10.063) AA34(-5.899,10.713) AA35(-5.899,11.363) AA36(-5.899,12.014) AA37(-5.899,12.664) AA38(-5.899,13.314) AB1(-5.559,-13.314) AB2(-5.559,-12.664) AB3(-5.559,-12.014) AB4(-5.559,-11.363) AB5(-5.559,-10.713) AB6(-5.508,-10.063) AB31(-5.111,8.762) AB32(-5.111,9.413) AB33(-5.111,10.063) AB34(-5.111,10.713) AB35(-5.111,11.363) AB36(-5.111,12.014) AB37(-5.111,12.664) AB38(-5.111,13.314) AC1(-4.67,-13.314) AC2(-4.67,-12.664) AC3(-4.67,-12.014) AC4(-4.67,-11.363) AC5(-4.67,-10.713) AC6(-4.67,-10.063) AC7(-4.852,-9.403) AC8(-4.852,-8.753) AC9(-4.852,-8.103) AC10(-4.852,-7.452) AC31(-4.324,8.762) AC32(-4.324,9.413) AC33(-4.324,10.063) AC34(-4.324,10.713) AC35(-4.324,11.363) AC36(-4.324,12.014) AC37(-4.324,12.664) AC38(-4.324,13.314) AD1(-3.781,-13.314) AD2(-3.781,-12.664) AD3(-3.781,-12.014) AD4(-3.781,-11.363) AD5(-3.781,-10.713) AD6(-3.831,-10.063) AD7(-3.937,-9.403) AD8(-3.937,-8.753) AD9(-3.937,-8.103) AD10(-3.937,-7.452) AD31(-3.537,8.762) AD32(-3.537,9.413) AD33(-3.537,10.063) AD34(-3.537,10.713) AD35(-3.537,11.363) AD36(-3.537,12.014) AD37(-3.537,12.664) AD38(-3.537,13.314) AE1(-3.044,-13.314) AE2(-3.044,-12.664) AE3(-3.044,-12.014) AE4(-3.044,-11.363) AE5(-3.044,-10.713) AE6(-2.993,-10.063) AE7(-3.023,-9.403) AE8(-3.023,-8.753) AE9(-3.023,-8.103) AE10(-3.023,-7.452) AE31(-2.749,8.762) AE32(-2.749,9.413) AE33(-2.749,10.063) AE34(-2.749,10.713) AE35(-2.749,11.363) AE36(-2.749,12.014) AE37(-2.749,12.664) AE38(-2.749,13.314) AF1(-2.155,-13.314) AF2(-2.155,-12.664) AF3(-2.155,-12.014) AF4(-2.155,-11.363) AF5(-2.155,-10.713) AF6(-2.155,-10.063) AF7(-2.108,-9.403) AF8(-2.108,-8.753) AF9(-2.108,-8.103) AF10(-2.108,-7.452) AF31(-1.962,8.762) AF32(-1.962,9.413) AF33(-1.962,10.063) AF34(-1.962,10.713) AF35(-1.962,11.363) AF36(-1.962,12.014) AF37(-1.962,12.664) AF38(-1.962,13.314) AG1(-1.266,-13.314) AG2(-1.266,-12.664) AG3(-1.266,-12.014) AG4(-1.266,-11.363) AG5(-1.266,-10.713) AG6(-1.317,-10.063) AG7(-1.194,-9.403) AG8(-1.194,-8.753) AG9(-1.194,-8.103) AG10(-1.194,-7.452) AG31(-1.174,8.762) AG32(-1.174,9.413) AG33(-1.174,10.063) AG34(-1.174,10.713) AG35(-1.174,11.363) AG36(-1.174,12.014) AG37(-1.174,12.664) AG38(-1.174,13.314) AH1(-0.529,-13.314) AH2(-0.529,-12.664) AH3(-0.529,-12.014) AH4(-0.529,-11.363) AH5(-0.529,-10.713) AH6(-0.479,-10.063) AH7(-0.28,-9.403) AH8(-0.28,-8.753) AH9(-0.28,-8.103) AH10(-0.28,-7.452) AH31(-0.387,8.762) AH32(-0.387,9.413) AH33(-0.387,10.063) AH34(-0.387,10.713) AH35(-0.387,11.363) AH36(-0.387,12.014) AH37(-0.387,12.664) AH38(-0.387,13.314) AJ1(0.36,-13.314) AJ2(0.36,-12.664) AJ3(0.36,-12.014) AJ4(0.36,-11.363) AJ5(0.36,-10.713) AJ6(0.36,-10.063) AJ7(0.635,-9.403) AJ8(0.635,-8.753) AJ9(0.635,-8.103) AJ10(0.635,-7.452) AJ31(0.4,8.762) AJ32(0.4,9.413) AJ33(0.4,10.063) AJ34(0.4,10.713) AJ35(0.4,11.363) AJ36(0.4,12.014) AJ37(0.4,12.664) AJ38(0.4,13.314) AK1(1.249,-13.314) AK2(1.249,-12.664) AK3(1.249,-12.014) AK4(1.249,-11.363) AK5(1.249,-10.713) AK6(1.198,-10.063) AK31(1.188,8.762) AK32(1.188,9.413) AK33(1.188,10.063) AK34(1.188,10.713) AK35(1.188,11.363) AK36(1.188,12.014) AK37(1.188,12.664) AK38(1.188,13.314) AL1(1.985,-13.314) AL2(1.985,-12.664) AL3(1.985,-12.014) AL4(1.985,-11.363) AL5(1.985,-10.713) AL6(2.036,-10.063) AL7(1.549,-9.403) AL8(1.549,-8.753) AL9(1.549,-8.103) AL10(1.549,-7.452) AL31(1.975,8.762) AL32(1.975,9.413) AL33(1.975,10.063) AL34(1.975,10.713) AL35(1.975,11.363) AL36(1.975,12.014) AL37(1.975,12.664) AL38(1.975,13.314) AM1(2.874,-13.314) AM2(2.874,-12.664) AM3(2.874,-12.014) AM4(2.874,-11.363) AM5(2.874,-10.713) AM6(2.874,-10.063) AM7(2.464,-9.403) AM8(2.464,-8.753) AM9(2.464,-8.103) AM10(2.464,-7.452) AM31(2.763,8.762) AM32(2.763,9.413) AM33(2.763,10.063) AM34(2.763,10.713) AM35(2.763,11.363) AM36(2.763,12.014) AM37(2.763,12.664) AM38(2.763,13.314) AN1(3.763,-13.314) AN2(3.763,-12.664) AN3(3.763,-12.014) AN4(3.763,-11.363) AN5(3.763,-10.713) AN6(3.712,-10.063) AN7(3.378,-9.403) AN8(3.378,-8.753) AN9(3.378,-8.103) AN10(3.378,-7.452) AN31(3.55,8.762) AN32(3.55,9.413) AN33(3.55,10.063) AN34(3.55,10.713) AN35(3.55,11.363) AN36(3.55,12.014) AN37(3.55,12.664) AN38(3.55,13.314) AP1(4.5,-13.314) AP2(4.5,-12.664) AP3(4.5,-12.014) AP4(4.5,-11.363) AP5(4.5,-10.713) AP6(4.551,-10.063) AP7(4.292,-9.403) AP8(4.292,-8.753) AP9(4.292,-8.103) AP10(4.292,-7.452) AP31(4.337,8.762) AP32(4.337,9.413) AP33(4.337,10.063) AP34(4.337,10.713) AP35(4.337,11.363) AP36(4.337,12.014) AP37(4.337,12.664) AP38(4.337,13.314) AR1(5.389,-13.314) AR2(5.389,-12.664) AR3(5.389,-12.014) AR4(5.389,-11.363) AR5(5.389,-10.713) AR6(5.389,-10.063) AR7(5.207,-9.403) AR8(5.207,-8.753) AR9(5.207,-8.103) AR10(5.207,-7.452) AR31(5.125,8.762) AR32(5.125,9.413) AR33(5.125,10.063) AR34(5.125,10.713) AR35(5.125,11.363) AR36(5.125,12.014) AR37(5.125,12.664) AR38(5.125,13.314) AT1(6.278,-13.314) AT2(6.278,-12.664) AT3(6.278,-12.014) AT4(6.278,-11.363) AT5(6.278,-10.713) AT6(6.227,-10.063) AT7(6.121,-9.403) AT8(6.121,-8.753) AT9(6.121,-8.103) AT10(6.121,-7.452) AT31(5.912,8.762) AT32(5.912,9.413) AT33(5.912,10.063) AT34(5.912,10.713) AT35(5.912,11.363) AT36(5.912,12.014) AT37(5.912,12.664) AT38(5.912,13.314) AU1(7.014,-13.314) AU2(7.014,-12.664) AU3(7.014,-12.014) AU4(7.014,-11.363) AU5(7.014,-10.713) AU6(7.065,-10.063) AU7(7.036,-9.403) AU8(7.036,-8.753) AU9(7.036,-8.103) AU10(7.036,-7.452) AU31(6.7,8.762) AU32(6.7,9.413) AU33(6.7,10.063) AU34(6.7,10.713) AU35(6.7,11.363) AU36(6.7,12.014) AU37(6.7,12.664) AU38(6.7,13.314) AV31(7.487,8.762) AV32(7.487,9.413) AV33(7.487,10.063) AV34(7.487,10.713) AV35(7.487,11.363) AV36(7.487,12.014) AV37(7.487,12.664) AV38(7.487,13.314) AW1(7.903,-13.314) AW2(7.903,-12.664) AW3(7.903,-12.014) AW4(7.903,-11.363) AW5(7.903,-10.713) AW6(7.903,-10.063) AW7(7.95,-9.403) AW8(7.95,-8.753) AW9(7.95,-8.103) AW10(7.95,-7.452) AW31(8.274,8.762) AW32(8.274,9.413) AW33(8.274,10.063) AW34(8.274,10.713) AW35(8.274,11.363) AW36(8.274,12.014) AW37(8.274,12.664) AW38(8.274,13.314) AY1(8.792,-13.314) AY2(8.792,-12.664) AY3(8.792,-12.014) AY4(8.792,-11.363) AY5(8.792,-10.713) AY6(8.742,-10.063) AY7(8.864,-9.403) AY8(8.864,-8.753) AY9(8.864,-8.103) AY10(8.864,-7.452) AY31(9.062,8.762) AY32(9.062,9.413) AY33(9.062,10.063) AY34(9.062,10.713) AY35(9.062,11.363) AY36(9.062,12.014) AY37(9.062,12.664) AY38(9.062,13.314) B6(-19.664,-9.784) B8(-19.664,-8.996) B9(-19.664,-8.209) B10(-19.664,-7.421) B11(-19.664,-6.634) B12(-19.664,-5.847) B13(-19.664,-5.059) B14(-19.664,-4.272) B15(-19.664,-3.484) B16(-19.664,-2.697) B17(-19.664,-1.91) B18(-19.664,-1.122) B19(-19.664,-0.335) B20(-19.664,0.453) B21(-19.664,1.24) B22(-19.664,2.027) B23(-19.664,2.815) B24(-19.664,3.602) B25(-19.664,4.39) B26(-19.664,5.177) B27(-19.664,5.964) B28(-19.664,6.752) B29(-19.664,7.539) B30(-19.664,8.327) B31(-19.664,9.114) B33(-19.664,9.901) BA1(9.529,-13.314) BA2(9.529,-12.664) BA3(9.529,-12.014) BA4(9.529,-11.363) BA5(9.529,-10.713) BA6(9.58,-10.063) BA7(9.779,-9.403) BA8(9.779,-8.753) BA9(9.779,-8.103) BA10(9.779,-7.452) BA31(9.849,8.762) BA32(9.849,9.413) BA33(9.849,10.063) BA34(9.849,10.713) BA35(9.849,11.363) BA36(9.849,12.014) BA37(9.849,12.664) BA38(9.849,13.314) BB1(10.418,-13.314) BB2(10.418,-12.664) BB3(10.418,-12.014) BB4(10.418,-11.363) BB5(10.418,-10.713) BB6(10.418,-10.063) BB7(10.693,-9.403) BB8(10.693,-8.753) BB9(10.693,-8.103) BB10(10.693,-7.452) BB31(10.637,8.762) BB32(10.637,9.413) BB33(10.637,10.063) BB34(10.637,10.713) BB35(10.637,11.363) BB36(10.637,12.014) BB37(10.637,12.664) BB38(10.637,13.314) BC1(11.307,-13.314) BC2(11.307,-12.664) BC3(11.307,-12.014) BC4(11.307,-11.363) BC5(11.307,-10.713) BC6(11.256,-10.063) BC7(11.608,-9.403) BC8(11.608,-8.753) BC9(11.608,-8.103) BC10(11.608,-7.452) BC31(11.424,8.762) BC32(11.424,9.413) BC33(11.424,10.063) BC34(11.424,10.713) BC35(11.424,11.363) BC36(11.424,12.014) BC37(11.424,12.664) BC38(11.424,13.314) BD1(12.044,-13.314) BD2(12.044,-12.664) BD3(12.044,-12.014) BD4(12.044,-11.363) BD5(12.044,-10.713) BD6(12.094,-10.063) BD7(12.522,-9.403) BD8(12.522,-8.753) BD9(12.522,-8.103) BD10(12.522,-7.452) BD31(12.211,8.762) BD32(12.211,9.413) BD33(12.211,10.063) BD34(12.211,10.713) BD35(12.211,11.363) BD36(12.211,12.014) BD37(12.211,12.664) BD38(12.211,13.314) BE1(12.933,-13.314) BE2(12.933,-12.664) BE3(12.933,-12.014) BE4(12.933,-11.363) BE5(12.933,-10.713) BE6(12.933,-10.063) BE31(12.999,8.762) BE32(12.999,9.413) BE33(12.999,10.063) BE34(12.999,10.713) BE35(12.999,11.363) BE36(12.999,12.014) BE37(12.999,12.664) BE38(12.999,13.314) BF1(13.822,-13.314) BF2(13.822,-12.664) BF3(13.822,-12.014) BF4(13.822,-11.363) BF5(13.822,-10.713) BF6(13.771,-10.063) BF7(13.436,-9.403) BF8(13.436,-8.753) BF9(13.436,-8.103) BF10(13.436,-7.452) BF31(13.786,8.762) BF32(13.786,9.413) BF33(13.786,10.063) BF34(13.786,10.713) BF35(13.786,11.363) BF36(13.786,12.014) BF37(13.786,12.664) BF38(13.786,13.314) BG1(14.558,-13.314) BG2(14.558,-12.664) BG3(14.558,-12.014) BG4(14.558,-11.363) BG5(14.558,-10.713) BG6(14.609,-10.063) BG7(14.351,-9.403) BG8(14.351,-8.753) BG9(14.351,-8.103) BG10(14.351,-7.452) BG31(14.574,8.762) BG32(14.574,9.413) BG33(14.574,10.063) BG34(14.574,10.713) BG35(14.574,11.363) BG36(14.574,12.014) BG37(14.574,12.664) BG38(14.574,13.314) BH1(15.701,-13.314) BH2(15.447,-12.664) BH3(15.447,-12.014) BH4(15.447,-11.363) BH5(15.447,-10.713) BH6(15.447,-10.063) BH7(15.265,-9.403) BH8(15.265,-8.753) BH9(15.265,-8.103) BH10(15.265,-7.452) BH31(15.361,8.762) BH32(15.361,9.413) BH33(15.361,10.063) BH34(15.361,10.713) BH35(15.361,11.363) BH36(15.361,12.014) BH37(15.361,12.664) BH38(15.361,13.314) BJ7(16.18,-9.403) BJ8(16.18,-8.753) BJ9(16.18,-8.103) BJ10(16.18,-7.452) BJ31(16.148,8.762) BJ32(16.148,9.413) BJ33(16.148,10.063) BJ34(16.148,10.713) BJ35(16.148,11.363) BJ36(16.148,12.014) BJ37(16.148,12.664) BJ38(16.098,13.314) BK2(16.285,-12.664) BK3(16.285,-12.014) BK4(16.285,-11.363) BK5(16.285,-10.713) BK6(16.285,-10.063) BL2(17.124,-12.664) BL3(17.073,-12.014) BL4(17.073,-11.363) BL5(17.073,-10.713) BL6(17.124,-10.063) BL7(17.069,-9.327) BL8(17.063,-8.438) BL9(17.063,-7.65) BL11(17.063,-6.863) BL12(17.063,-6.076) BL13(17.063,-5.288) BL14(17.063,-4.501) BL15(17.063,-3.713) BL16(17.063,-2.926) BL17(17.063,-2.139) BL18(17.063,-1.351) BL19(17.063,-0.564) BL20(17.063,0.224) BL21(17.063,1.011) BL22(17.063,1.798) BL23(17.063,2.586) BL24(17.063,3.373) BL25(17.063,4.161) BL26(17.063,4.948) BL27(17.063,5.735) BL28(17.063,6.523) BL29(17.063,7.31) BL30(16.936,8.112) BL31(16.936,8.762) BL32(16.936,9.413) BL33(16.936,10.063) BL34(16.936,10.713) BL35(16.936,11.363) BL36(16.936,12.014) BL37(16.936,12.664) BM2(17.738,-12.352) BM3(17.815,-11.701) BM5(17.815,-10.789) BM6(17.916,-10.145) BM7(17.713,-9.225) BM8(17.713,-8.438) BM9(17.713,-7.65) BM11(17.713,-6.863) BM12(17.713,-6.076) BM13(17.713,-5.288) BM14(17.713,-4.501) BM15(17.713,-3.713) BM16(17.713,-2.926) BM17(17.713,-2.139) BM18(17.713,-1.351) BM19(17.713,-0.564) BM20(17.713,0.224) BM21(17.713,1.011) BM22(17.713,1.798) BM23(17.713,2.586) BM24(17.713,3.373) BM25(17.713,4.161) BM26(17.713,4.948) BM27(17.713,5.735) BM28(17.713,6.523) BM29(17.713,7.31) BM30(17.713,8.098) BM31(17.713,8.885) BM33(17.713,9.672) BM34(17.713,10.46) BM35(17.713,11.247) BM36(17.672,12.014) BM37(17.672,12.664) BN3(18.387,-12.014) BN4(18.315,-11.209) BN5(18.479,-10.566) BN7(18.363,-9.225) BN8(18.363,-8.438) BN9(18.363,-7.65) BN11(18.363,-6.863) BN12(18.363,-6.076) BN13(18.363,-5.288) BN14(18.363,-4.501) BN15(18.363,-3.713) BN16(18.363,-2.926) BN17(18.363,-2.139) BN18(18.363,-1.351) BN19(18.363,-0.564) BN20(18.363,0.224) BN21(18.363,1.011) BN22(18.363,1.798) BN23(18.363,2.586) BN24(18.363,3.373) BN25(18.363,4.161) BN26(18.363,4.948) BN27(18.363,5.735) BN28(18.363,6.523) BN29(18.363,7.31) BN30(18.363,8.098) BN31(18.363,8.885) BN33(18.363,9.672) BN34(18.363,10.46) BN35(18.363,11.248) BN36(18.324,11.999) BP3(19.02,-11.831) BP5(19.037,-10.94) BP6(18.974,-10.02) BP7(19.014,-9.225) BP8(19.014,-8.438) BP9(19.014,-7.65) BP11(19.014,-6.863) BP12(19.014,-6.076) BP13(19.014,-5.288) BP14(19.014,-4.501) BP15(19.014,-3.713) BP16(19.014,-2.926) BP17(19.014,-2.139) BP18(19.014,-1.351) BP19(19.014,-0.564) BP20(19.014,0.224) BP21(19.014,1.011) BP22(19.014,1.798) BP23(19.014,2.586) BP24(19.014,3.373) BP25(19.014,4.161) BP26(19.014,4.948) BP27(19.014,5.735) BP28(19.014,6.523) BP29(19.014,7.31) BP30(19.014,8.098) BP31(19.014,8.885) BP33(19.014,9.672) BP34(19.014,10.46) BP35(19.014,11.247) BR6(19.647,-10.122) BR7(19.664,-9.225) BR8(19.664,-8.438) BR9(19.664,-7.65) BR11(19.664,-6.863) BR12(19.664,-6.076) BR13(19.664,-5.288) BR14(19.664,-4.501) BR15(19.664,-3.713) BR16(19.664,-2.926) BR17(19.664,-2.139) BR18(19.664,-1.351) BR19(19.664,-0.564) BR20(19.664,0.224) BR21(19.664,1.011) BR22(19.664,1.798) BR23(19.664,2.586) BR24(19.664,3.373) BR25(19.664,4.161) BR26(19.664,4.948) BR27(19.664,5.735) BR28(19.664,6.523) BR29(19.664,7.31) BR30(19.664,8.098) BR31(19.664,8.885) BR33(19.664,9.672) BR34(19.664,10.46) BT8(20.314,-8.666) BT9(20.314,-7.65) BT11(20.314,-6.863) BT12(20.314,-6.076) BT13(20.314,-5.288) BT14(20.314,-4.501) BT15(20.314,-3.713) BT16(20.314,-2.926) BT17(20.314,-2.139) BT18(20.314,-1.351) BT19(20.314,-0.564) BT20(20.314,0.224) BT21(20.314,1.011) BT22(20.314,1.798) BT23(20.314,2.586) BT24(20.314,3.373) BT25(20.314,4.161) BT26(20.314,4.948) BT27(20.314,5.735) BT28(20.314,6.523) BT29(20.314,7.31) BT30(20.314,8.098) BT31(20.314,8.86) C5(-19.014,-10.571) C6(-19.014,-9.784) C8(-19.014,-8.996) C9(-19.014,-8.209) C10(-19.014,-7.421) C11(-19.014,-6.634) C12(-19.014,-5.847) C13(-19.014,-5.059) C14(-19.014,-4.272) C15(-19.014,-3.484) C16(-19.014,-2.697) C17(-19.014,-1.91) C18(-19.014,-1.122) C19(-19.014,-0.335) C20(-19.014,0.453) C21(-19.014,1.24) C22(-19.014,2.027) C23(-19.014,2.815) C24(-19.014,3.602) C25(-19.014,4.39) C26(-19.014,5.177) C27(-19.014,5.964) C28(-19.014,6.752) C29(-19.014,7.539) C30(-19.014,8.327) C31(-19.014,9.114) C33(-19.014,9.901) C34(-19.025,10.697) C36(-18.926,11.831) D4(-18.66,-11.42) D5(-18.363,-10.571) D6(-18.363,-9.784) D8(-18.363,-8.996) D9(-18.363,-8.209) D10(-18.363,-7.421) D11(-18.363,-6.634) D12(-18.363,-5.847) D13(-18.363,-5.059) D14(-18.363,-4.272) D15(-18.363,-3.484) D16(-18.363,-2.697) D17(-18.363,-1.91) D18(-18.363,-1.122) D19(-18.363,-0.335) D20(-18.363,0.453) D21(-18.363,1.24) D22(-18.363,2.027) D23(-18.363,2.815) D24(-18.363,3.602) D25(-18.363,4.39) D26(-18.363,5.177) D27(-18.363,5.964) D28(-18.363,6.752) D29(-18.363,7.539) D30(-18.363,8.327) D31(-18.363,9.114) D33(-18.363,9.901) D34(-18.363,10.689) D35(-18.453,11.341) E3(-17.84,-12.014) E4(-17.739,-11.363) E5(-17.713,-10.571) E6(-17.713,-9.784) E8(-17.713,-8.996) E9(-17.713,-8.209) E10(-17.713,-7.421) E11(-17.713,-6.634) E12(-17.713,-5.847) E13(-17.713,-5.059) E14(-17.713,-4.272) E15(-17.713,-3.484) E16(-17.713,-2.697) E17(-17.713,-1.91) E18(-17.713,-1.122) E19(-17.713,-0.335) E20(-17.713,0.453) E21(-17.713,1.24) E22(-17.713,2.027) E23(-17.713,2.815) E24(-17.713,3.602) E25(-17.713,4.39) E26(-17.713,5.177) E27(-17.713,5.964) E28(-17.713,6.752) E29(-17.713,7.539) E30(-17.713,8.327) E31(-17.713,9.114) E33(-17.713,9.901) E34(-17.713,10.689) E35(-17.71,11.363) E36(-17.71,12.014) E37(-17.71,12.664) F2(-17.155,-12.664) F3(-17.155,-12.014) F4(-17.053,-11.363) F5(-17.041,-10.571) F6(-17.041,-9.784) F8(-17.063,-8.996) F9(-17.063,-8.209) F10(-17.063,-7.421) F11(-17.063,-6.634) F12(-17.063,-5.847) F13(-17.063,-5.059) F14(-17.063,-4.272) F15(-17.063,-3.484) F16(-17.063,-2.697) F17(-17.063,-1.91) F18(-17.063,-1.122) F19(-17.063,-0.335) F20(-17.063,0.453) F21(-17.063,1.24) F22(-17.063,2.027) F23(-17.063,2.815) F24(-17.063,3.602) F25(-17.063,4.39) F26(-17.063,5.177) F27(-17.063,5.964) F28(-17.063,6.752) F29(-17.063,7.539) F30(-17.063,8.327) F31(-17.063,9.114) F33(-17.063,9.901) F34(-16.922,10.713) F35(-16.922,11.363) F36(-16.922,12.014) F37(-16.922,12.664) G2(-16.367,-12.664) G3(-16.367,-12.014) G4(-16.367,-11.363) G5(-16.367,-10.713) G6(-16.367,-10.063) G8(-16.413,-8.996) G9(-16.413,-8.209) G10(-16.413,-7.421) G11(-16.413,-6.634) G12(-16.413,-5.847) G13(-16.413,-5.059) G14(-16.413,-4.272) G15(-16.413,-3.484) G16(-16.413,-2.697) G17(-16.413,-1.91) G18(-16.413,-1.122) G19(-16.413,-0.335) G20(-16.413,0.453) G21(-16.413,1.24) G22(-16.413,2.027) G23(-16.413,2.815) G24(-16.413,3.602) G25(-16.413,4.39) G26(-16.413,5.177) G27(-16.413,5.964) G28(-16.413,6.752) G29(-16.413,7.539) G30(-16.413,8.327) H1(-15.871,-13.314) H11(-15.762,-6.634) H12(-15.762,-5.847) H30(-15.762,8.289) H32(-16.135,9.413) H33(-16.135,10.063) H34(-16.135,10.713) H35(-16.135,11.363) H36(-16.135,12.014) H37(-16.135,12.664) J2(-15.566,-12.664) J3(-15.566,-12.014) J4(-15.566,-11.363) J5(-15.566,-10.713) J6(-15.566,-10.063) J7(-15.695,-9.421) J8(-15.598,-8.773) J9(-15.621,-8.103) J10(-15.686,-7.421) J31(-15.31,8.762) J32(-15.348,9.413) J33(-15.348,10.063) J34(-15.348,10.713) J35(-15.348,11.363) J36(-15.348,12.014) J37(-15.348,12.664) J38(-15.602,13.314) K1(-14.728,-13.314) K2(-14.728,-12.664) K3(-14.728,-12.014) K4(-14.728,-11.363) K5(-14.728,-10.713) K6(-14.728,-10.063) K7(-14.758,-9.403) K8(-14.834,-8.753) K9(-14.834,-8.103) K10(-14.834,-7.452) K31(-14.56,8.762) K32(-14.56,9.413) K33(-14.56,10.063) K34(-14.56,10.713) K35(-14.56,11.363) K36(-14.56,12.014) K37(-14.56,12.664) K38(-14.56,13.314) L1(-13.839,-13.314) L2(-13.839,-12.664) L3(-13.839,-12.014) L4(-13.839,-11.363) L5(-13.839,-10.713) L6(-13.89,-10.063) L7(-13.919,-9.403) L8(-13.97,-8.753) L9(-13.996,-8.103) L10(-13.996,-7.452) L31(-13.773,8.762) L32(-13.773,9.413) L33(-13.773,10.063) L34(-13.773,10.713) L35(-13.773,11.363) L36(-13.773,12.014) L37(-13.773,12.664) L38(-13.773,13.314) M1(-13.102,-13.314) M2(-13.102,-12.664) M3(-13.102,-12.014) M4(-13.102,-11.363) M5(-13.102,-10.713) M6(-13.052,-10.063) M7(-13.081,-9.403) M8(-13.081,-8.753) M9(-13.081,-8.103) M10(-13.081,-7.452) M31(-12.985,8.762) M32(-12.985,9.413) M33(-12.985,10.063) M34(-12.985,10.713) M35(-12.985,11.363) M36(-12.985,12.014) M37(-12.985,12.664) M38(-12.985,13.314) N1(-12.213,-13.314) N2(-12.213,-12.664) N3(-12.213,-12.014) N4(-12.213,-11.363) N5(-12.213,-10.713) N6(-12.213,-10.063) N7(-12.167,-9.403) N8(-12.167,-8.753) N9(-12.167,-8.103) N10(-12.167,-7.452) N31(-12.198,8.762) N32(-12.198,9.413) N33(-12.198,10.063) N34(-12.198,10.713) N35(-12.198,11.363) N36(-12.198,12.014) N37(-12.198,12.664) N38(-12.198,13.314) P1(-11.324,-13.314) P2(-11.324,-12.664) P3(-11.324,-12.014) P4(-11.324,-11.363) P5(-11.324,-10.713) P6(-11.375,-10.063) P7(-11.252,-9.403) P8(-11.252,-8.753) P9(-11.252,-8.103) P10(-11.252,-7.452) P31(-11.411,8.762) P32(-11.411,9.413) P33(-11.411,10.063) P34(-11.411,10.713) P35(-11.411,11.363) P36(-11.411,12.014) P37(-11.411,12.664) P38(-11.411,13.314) R1(-10.588,-13.314) R2(-10.588,-12.664) R3(-10.588,-12.014) R4(-10.588,-11.363) R5(-10.588,-10.713) R6(-10.537,-10.063) R7(-10.338,-9.403) R8(-10.338,-8.753) R9(-10.338,-8.103) R10(-10.338,-7.452) R31(-10.623,8.762) R32(-10.623,9.413) R33(-10.623,10.063) R34(-10.623,10.713) R35(-10.623,11.363) R36(-10.623,12.014) R37(-10.623,12.664) R38(-10.623,13.314) T1(-9.699,-13.314) T2(-9.699,-12.664) T3(-9.699,-12.014) T4(-9.699,-11.363) T5(-9.699,-10.713) T6(-9.699,-10.063) T7(-9.424,-9.403) T8(-9.424,-8.753) T9(-9.424,-8.103) T10(-9.424,-7.452) T31(-9.836,8.762) T32(-9.836,9.413) T33(-9.836,10.063) T34(-9.836,10.713) T35(-9.836,11.363) T36(-9.836,12.014) T37(-9.836,12.664) T38(-9.836,13.314) U1(-8.81,-13.314) U2(-8.81,-12.664) U3(-8.81,-12.014) U4(-8.81,-11.363) U5(-8.81,-10.713) U6(-8.861,-10.063) U31(-9.048,8.762) U32(-9.048,9.413) U33(-9.048,10.063) U34(-9.048,10.713) U35(-9.048,11.363) U36(-9.048,12.014) U37(-9.048,12.664) U38(-9.048,13.314) V1(-8.073,-13.314) V2(-8.073,-12.664) V3(-8.073,-12.014) V4(-8.073,-11.363) V5(-8.073,-10.713) V6(-8.022,-10.063) V7(-8.509,-9.403) V8(-8.509,-8.753) V9(-8.509,-8.103) V10(-8.509,-7.452) V31(-8.261,8.762) V32(-8.261,9.413) V33(-8.261,10.063) V34(-8.261,10.713) V35(-8.261,11.363) V36(-8.261,12.014) V37(-8.261,12.664) V38(-8.261,13.314) W1(-7.184,-13.314) W2(-7.184,-12.664) W3(-7.184,-12.014) W4(-7.184,-11.363) W5(-7.184,-10.713) W6(-7.184,-10.063) W7(-7.595,-9.403) W8(-7.595,-8.753) W9(-7.595,-8.103) W10(-7.595,-7.452) W31(-7.474,8.762) W32(-7.474,9.413) W33(-7.474,10.063) W34(-7.474,10.713) W35(-7.474,11.363) W36(-7.474,12.014) W37(-7.474,12.664) W38(-7.474,13.314) Y7(-6.68,-9.403) Y8(-6.68,-8.753) Y9(-6.68,-8.103) Y10(-6.68,-7.452) Y31(-6.686,8.762) Y32(-6.686,9.413) Y33(-6.686,10.063) Y34(-6.686,10.713) Y35(-6.686,11.363) Y36(-6.686,12.014) Y37(-6.686,12.664) Y38(-6.686,13.314)
