# Allegro board DAZGLMB1ED0 dazglmb1ed0-d-ver a-165 (.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_DQ22: length 55.8
  TOP w0.14: v1(258.98,104.03) 259.35,104.4 U41.BF1 ; v1(262.92,56.24) 262.97,56.24 263.93,55.28 CN2063.58
  IN1 w0.089: v1(258.98,104.03) 259.43,103.58 259.43,103.39 259.76,103.06 259.76,100.5 260.27,100 260.27,88.66 261.51,87.41 261.51,57.98 261.64,57.85 262.21,57.85 262.29,57.76 262.29,57.59 262.21,57.5 261.92,57.5 261.83,57.41 261.83,57.23 261.92,57.14 262.46,57.14 262.55,57.05 262.55,56.87 262.46,56.79 261.92,56.79 261.83,56.7 261.83,56.4 261.92,56.32 262.85,56.32 v1(262.92,56.24)
M_A_DQ23: length 55.8
  TOP w0.102: v1(259.03,103.37) 259.46,103.8 259.46,104.03 259.71,104.28 259.71,104.74 259.4,105.05 U41.BF2
  TOP w0.14: CN2063.62 262.93,54.91 v1(262.91,54.94)
  IN1 w0.089: v1(259.03,103.37) 259.47,102.93 259.47,100.38 259.97,99.88 259.97,88.54 261.21,87.3 261.21,57.62 261.54,57.29 261.54,56.07 261.64,55.97 262.44,55.97 262.56,55.85 262.56,55.72 262.44,55.59 261.64,55.59 261.54,55.49 261.54,55.36 261.71,55.19 262.66,55.19 v1(262.91,54.94)
M_A_DQ24: length 55.3
  TOP w0.14: U41.BD2 257.96,104.71 v1(258.02,104.71) ; CN2063.70 v1(260.93,54.96)
  IN1 w0.089: v1(258.02,104.71) 257.75,104.44 257.73,104.44 257.62,104.33 257.62,102.24 257.79,102.06 257.79,99.79 258.35,99.23 258.35,86.74 259.01,86.08 259.01,79.3 259.38,78.93 259.38,59.05 259.62,58.81 259.62,56.02 259.71,55.93 260.41,55.93 260.5,55.85 260.5,55.67 260.41,55.58 259.71,55.58 259.62,55.49 259.62,55.34 259.77,55.19 260.7,55.19 v1(260.93,54.96)
M_A_DQ25: length 55.3
  TOP w0.14: v1(260.94,56.3) 261.93,55.3 CN2063.66 ; v1(258.02,104.03) 257.64,104.4 U41.BD1
  IN1 w0.089: v1(260.94,56.3) 260.05,56.3 259.91,56.43 259.91,56.72 260,56.81 260.28,56.81 260.37,56.9 260.37,57.08 260.28,57.17 260,57.17 259.91,57.26 259.91,57.43 260,57.52 260.28,57.52 260.37,57.61 260.37,57.79 260.28,57.88 260,57.88 259.91,57.97 259.91,58.14 260,58.23 260.28,58.23 260.37,58.32 260.37,58.5 260.28,58.59 260,58.59 259.91,58.68 259.91,58.93 259.72,59.11 259.72,79 259.3,79.42 259.3,86.2 258.66,86.85 258.66,99.34 258.13,99.86 258.13,102.15 257.96,102.33 257.96,103.6 258.02,103.66 v1(258.02,104.03)
M_A_DQ26: length 55.7
  TOP w0.14: U41.BC4 256.79,106.35 v1(256.46,106.03) ; CN2063.80 258.44,55.5 v1(257.59,56.35)
  IN1 w0.089: v1(256.46,106.03) 256.35,106.14 256.18,106.14 255.79,105.75 255.79,103.95 255.62,103.77 255.62,99.41 256.15,98.88 256.15,78.39 256.56,77.98 256.56,56.39 256.98,55.97 257.22,55.97 v1(257.59,56.35)
M_A_DQ27: length 55.2
  TOP w0.14: CN2063.84 257.44,54.82 v1(257.58,54.96) ; U41.BC5 256.79,107.01 v1(256.46,106.67)
  IN1 w0.089: v1(256.46,106.67) 256.21,106.43 256.05,106.43 255.49,105.88 255.49,104.11 255.3,103.91 255.3,99.41 255.84,98.87 255.84,78.28 256.26,77.87 256.26,56.28 v1(257.58,54.96)
M_A_DQ28: length 55.7
  TOP w0.14: v1(258.03,106.65) 257.95,106.65 257.61,106.99 U41.BD5 ; CN2063.71 260.69,60.47 v1(260.73,60.42)
  IN1 w0.079: 258.58,103.57 258.58,103.57 258.58,106.12 258.04,106.65 v1(258.03,106.65)
  IN1 w0.089: 258.58,103.57 258.58,102.7 258.74,102.53 258.74,100.08 259.25,99.58 259.25,87.32 259.48,87.09 260.4,87.09 260.48,87 260.48,86.85 260.4,86.76 259.98,86.76 259.89,86.67 259.89,86.49 259.98,86.4 260.4,86.4 260.48,86.31 260.48,86.14 260.4,86.05 259.98,86.05 259.89,85.96 259.89,85.78 259.98,85.69 260.4,85.69 260.48,85.6 260.48,85.43 260.4,85.34 259.98,85.34 259.89,85.25 259.89,85.07 259.98,84.98 260.4,84.98 260.48,84.89 260.48,84.71 260.4,84.63 259.98,84.63 259.89,84.54 259.89,84.36 259.98,84.27 260.4,84.27 260.48,84.18 260.48,84 260.4,83.91 259.98,83.91 259.89,83.83 259.89,83.65 259.98,83.56 260.4,83.56 260.48,83.47 260.48,83.29 260.4,83.2 259.98,83.2 259.89,83.11 259.89,82.94 259.98,82.85 260.25,82.85 260.33,82.76 260.33,60.82 v1(260.73,60.42)
M_A_DQ29: length 55.4
  TOP w0.14: CN2063.67 261.69,59.91 v1(260.75,58.97) ; U41.BD4 257.61,106.35 257.96,106.01 v1(258.02,106.01)
  IN1 w0.079: 258.26,103.42 258.26,103.65 258.42,103.81 258.42,105.61 v1(258.02,106.01)
  IN1 w0.089: 258.26,103.42 258.26,102.53 258.44,102.35 258.44,99.97 258.96,99.45 258.96,86.96 259.6,86.32 259.6,82.57 259.7,82.47 259.94,82.47 260.03,82.38 260.03,82.2 259.94,82.11 259.7,82.11 259.61,82.02 259.61,81.84 259.7,81.75 259.94,81.75 260.03,81.67 260.03,81.49 259.94,81.4 259.7,81.4 259.61,81.31 259.61,81.13 259.7,81.04 259.94,81.04 260.03,80.95 260.03,80.78 259.94,80.69 259.7,80.69 259.61,80.6 259.61,80.42 259.7,80.33 259.94,80.33 260.03,80.24 260.03,80.07 259.94,79.98 259.7,79.98 259.61,79.89 259.61,79.71 259.7,79.62 259.94,79.62 260.03,79.53 260.03,60.08 260.12,59.99 260.27,59.99 260.36,59.9 260.36,59.72 260.27,59.64 260.12,59.64 260.03,59.55 260.03,59.25 260.31,58.97 v1(260.75,58.97)
M_A_DQ30: length 55.6
  TOP w0.14: CN2063.79 258.69,60.11 v1(257.63,59.05) ; v1(256.44,104) 256.84,104.4 U41.BC1
  IN1 w0.089: v1(256.44,104) 255.94,103.5 255.94,99.42 256.44,98.91 256.44,82.96 256.53,82.87 256.79,82.87 256.88,82.78 256.88,82.6 256.79,82.52 256.53,82.52 256.44,82.43 256.44,82.25 256.53,82.16 256.79,82.16 256.88,82.07 256.88,81.89 256.79,81.8 256.53,81.8 256.44,81.72 256.44,81.54 256.53,81.45 256.79,81.45 256.88,81.36 256.88,81.18 256.79,81.09 256.53,81.09 256.44,81 256.44,80.83 256.53,80.74 256.79,80.74 256.88,80.65 256.88,80.47 256.79,80.38 256.53,80.38 256.44,80.29 256.44,80.12 256.53,80.03 256.79,80.03 256.88,79.94 256.88,79.76 256.79,79.67 256.53,79.67 256.44,79.58 256.44,79.4 256.53,79.32 256.79,79.32 256.88,79.23 256.88,79.05 256.79,78.96 256.53,78.96 256.44,78.87 256.44,78.58 256.85,78.17 256.85,58.26 256.98,58.13 257.31,58.13 257.4,58.22 257.4,58.82 v1(257.63,59.05)
M_A_DQ31: length 55.6
  TOP w0.14: U41.BC2 257.01,105.05 257.25,104.82 257.25,104.17 v1(256.43,103.36) ; CN2063.83 257.69,60.58 v1(257.61,60.5)
  IN1 w0.089: v1(257.61,60.5) 257.17,60.94 257.17,61.23 257.26,61.32 257.31,61.32 257.4,61.41 257.4,61.58 257.31,61.67 257.26,61.67 257.17,61.76 257.17,61.94 257.26,62.03 257.31,62.03 257.4,62.12 257.4,62.3 257.31,62.38 257.26,62.38 257.17,62.47 257.17,66.21 257.26,66.3 257.31,66.3 257.4,66.39 257.4,66.57 257.31,66.66 257.26,66.66 257.17,66.74 257.17,66.92 257.26,67.01 257.31,67.01 257.4,67.1 257.4,67.28 257.31,67.37 257.26,67.37 257.17,67.46 257.17,69.72 257.26,69.81 257.31,69.81 257.4,69.9 257.4,70.08 257.31,70.17 257.26,70.17 257.17,70.26 257.17,70.43 257.26,70.52 257.31,70.52 257.4,70.61 257.4,70.79 257.31,70.88 257.26,70.88 257.17,70.97 257.17,71.15 257.26,71.23 257.31,71.23 257.4,71.32 257.4,71.5 257.31,71.59 257.26,71.59 257.17,71.68 257.17,73.88 257.26,73.97 257.31,73.97 257.4,74.06 257.4,74.23 257.31,74.32 257.26,74.32 257.17,74.41 257.17,74.59 257.26,74.68 257.31,74.68 257.4,74.77 257.4,74.94 257.31,75.03 257.26,75.03 257.17,75.12 257.17,75.3 257.26,75.39 257.31,75.39 257.4,75.48 257.4,75.66 257.31,75.74 257.26,75.74 257.17,75.83 257.17,76.01 257.26,76.1 257.31,76.1 257.4,76.19 257.4,76.37 257.31,76.46 257.26,76.46 257.17,76.54 257.17,76.72 257.26,76.81 257.31,76.81 257.4,76.9 257.4,77.08 257.31,77.17 257.26,77.17 257.17,77.26 257.17,77.43 257.26,77.52 257.31,77.52 257.4,77.61 257.4,77.79 257.31,77.88 257.26,77.88 257.17,77.97 257.17,78.14 257.26,78.23 257.31,78.23 257.4,78.32 257.4,78.5 257.31,78.59 257.19,78.59 257.1,78.68 257.1,78.86 257.19,78.94 257.31,78.94 257.4,79.03 257.4,79.21 257.31,79.3 257.21,79.3 257.12,79.39 257.12,79.57 257.21,79.66 257.31,79.66 257.4,79.75 257.4,79.92 257.31,80.01 257.21,80.01 257.12,80.1 257.12,80.28 257.21,80.37 257.31,80.37 257.4,80.46 257.4,80.63 257.31,80.72 257.21,80.72 257.12,80.81 257.12,80.99 257.21,81.08 257.31,81.08 257.4,81.17 257.4,81.35 257.31,81.43 257.21,81.43 257.12,81.52 257.12,81.7 257.21,81.79 257.31,81.79 257.4,81.88 257.4,82.06 257.31,82.15 257.26,82.15 257.17,82.23 257.17,82.9 256.74,83.34 256.74,83.63 256.82,83.72 257.31,83.72 257.4,83.81 257.4,83.99 257.31,84.07 256.82,84.07 256.74,84.16 256.74,84.34 256.82,84.43 257.31,84.43 257.4,84.52 257.4,84.7 257.31,84.79 256.82,84.79 256.74,84.87 256.74,85.05 256.82,85.14 257.31,85.14 257.4,85.23 257.4,85.41 257.31,85.5 256.82,85.5 256.74,85.59 256.74,98.94 256.23,99.45 256.23,103.16 v1(256.43,103.36)
M_A_DQ32: length 59.5
  TOP w0.14: CN2063.170 233.94,56.25 v1(232.61,57.57) ; U41.AB1 240.02,104.4 v1(240.41,104.01)
  IN1 w0.089: v1(240.41,104.01) 240.41,103.43 236.61,99.63 236.61,87.97 231.87,83.24 231.87,81.14 231.71,80.97 231.44,80.97 231.35,80.88 231.35,80.7 231.44,80.61 231.79,80.61 231.87,80.53 231.87,80.35 231.79,80.26 231.44,80.26 231.35,80.17 231.35,79.99 231.44,79.9 231.79,79.9 231.87,79.81 231.87,79.64 231.79,79.55 231.44,79.55 231.35,79.46 231.35,79.28 231.44,79.19 231.79,79.19 231.87,79.1 231.87,78.93 231.79,78.84 231.44,78.84 231.35,78.75 231.35,60.35 231.9,59.81 231.9,57.34 232.05,57.19 232.51,57.19 232.61,57.29 v1(232.61,57.57)
M_A_DQ33: length 59.3
  TOP w0.14: v1(232.56,55.88) 232.99,55.44 232.99,54.65 232.94,54.6 CN2063.174 ; v1(240.41,104.73) 240.08,105.05 U41.AB2
  IN1 w0.089: v1(240.41,104.73) 239.94,104.26 239.94,103.2 236.31,99.57 236.31,88.11 231.05,82.85 231.05,82.51 231.14,82.42 231.45,82.42 231.54,82.33 231.54,82.15 231.45,82.06 231.14,82.06 231.05,81.97 231.05,81.8 231.14,81.71 231.45,81.71 231.54,81.62 231.54,81.44 231.45,81.35 231.14,81.35 231.05,81.26 231.05,75.83 230.96,75.74 230.87,75.74 230.78,75.65 230.78,75.47 230.87,75.39 230.96,75.39 231.05,75.3 231.05,75.12 230.96,75.03 230.87,75.03 230.78,74.94 230.78,74.76 230.87,74.67 230.96,74.67 231.05,74.59 231.05,74.41 230.96,74.32 230.87,74.32 230.78,74.23 230.78,74.05 230.87,73.96 230.96,73.96 231.05,73.87 231.05,73.7 230.96,73.61 230.87,73.61 230.78,73.52 230.78,73.34 230.87,73.25 230.96,73.25 231.05,73.16 231.05,60.1 231.59,59.55 231.59,56.84 v1(232.56,55.88)
M_A_DQ34: length 59.4
  TOP w0.14: U41.AA4 239.21,106.35 v1(238.88,106.03) ; CN2063.182 230.94,56.48 v1(230.4,57.02)
  IN1 w0.079: v1(238.88,106.03) 238.48,105.63 238.48,104.28 238.33,104.13 238.33,103.69 237.99,103.35 237.99,102.84
  IN1 w0.089: 237.99,102.84 237.99,102.59 234.12,98.72 234.12,89.06 228.45,83.4 228.45,79.35 227.95,78.84 227.95,58.4 229.33,57.02 v1(230.4,57.02)
M_A_DQ35: length 59.6
  TOP w0.14: U41.AA5 239.21,107.01 v1(238.88,106.68) ; v1(230.37,55.52) 229.94,55.08 CN2063.186
  IN1 w0.079: 237.83,102.89 237.83,103.41 238.17,103.76 238.17,104.2 238.32,104.35 238.32,105.73 238.42,105.83 238.42,106.21 v1(238.88,106.68)
  IN1 w0.089: v1(230.37,55.52) 227.65,58.24 227.65,78.96 228.16,79.47 228.16,83.54 233.82,89.2 233.82,98.66 237.83,102.66 237.83,102.89
M_A_DQ36: length 59
  TOP w0.14: v1(240.4,106.68) 240.08,107.01 U41.AB5 ; v1(232.66,60.32) 233.18,60.85 CN2063.173
  IN1 w0.079: 240.43,102.97 240.96,103.5 240.96,106.13 v1(240.4,106.68)
  IN1 w0.089: 240.43,102.97 237.19,99.74 237.19,87.7 232.46,82.96 232.46,78.52 232.2,78.26 232.2,75.85 232.28,75.76 232.37,75.76 232.46,75.67 232.46,75.5 232.37,75.41 232.28,75.41 232.2,75.32 232.2,75.14 232.28,75.05 232.37,75.05 232.46,74.96 232.46,74.78 232.37,74.7 232.28,74.7 232.2,74.61 232.2,74.43 232.28,74.34 232.37,74.34 232.46,74.25 232.46,74.07 232.37,73.98 232.28,73.98 232.2,73.9 232.2,67.88 232.11,67.79 232.06,67.79 231.97,67.7 231.97,67.52 232.06,67.43 232.37,67.43 232.46,67.34 232.46,67.17 232.37,67.08 232.06,67.08 231.97,66.99 231.97,66.81 232.06,66.72 232.37,66.72 232.46,66.63 232.46,66.46 232.37,66.37 232.06,66.37 231.97,66.28 231.97,66.1 232.06,66.01 232.37,66.01 232.46,65.92 232.46,65.74 232.37,65.66 232.06,65.66 231.97,65.57 231.97,65.39 232.06,65.3 232.14,65.3 232.23,65.21 232.23,65.03 232.14,64.94 232.06,64.94 231.97,64.86 231.97,64.68 232.06,64.59 232.14,64.59 232.23,64.5 232.23,64.32 232.14,64.23 232.06,64.23 231.97,64.14 231.97,63.97 232.06,63.88 232.14,63.88 232.23,63.79 232.23,63.61 232.14,63.52 232.06,63.52 231.97,63.43 231.97,63.25 232.06,63.17 232.14,63.17 232.23,63.08 232.23,62.9 232.14,62.81 232.06,62.81 231.97,62.72 231.97,62.54 232.06,62.45 232.37,62.45 232.46,62.37 232.46,62.19 232.37,62.1 232.06,62.1 231.97,62.01 231.97,61.83 232.06,61.74 232.37,61.74 232.46,61.65 232.46,61.48 232.37,61.39 232.06,61.39 231.97,61.3 231.97,60.64 232.29,60.32 v1(232.66,60.32)
M_A_DQ37: length 59.8
  TOP w0.14: CN2063.169 234.18,60.53 v1(232.66,59) ; v1(240.41,106.03) 240.08,106.35 U41.AB4
  IN1 w0.079: 240.25,103.04 240.8,103.58 240.8,105.63 v1(240.41,106.03)
  IN1 w0.089: 240.25,103.04 236.9,99.68 236.9,87.83 232.17,83.1 232.17,78.71 231.65,78.18 231.65,77.78 231.73,77.7 231.81,77.7 231.9,77.61 231.9,77.43 231.81,77.34 231.73,77.34 231.65,77.25 231.65,77.07 231.73,76.98 231.81,76.98 231.9,76.9 231.9,76.72 231.81,76.63 231.73,76.63 231.65,76.54 231.65,76.36 231.73,76.27 231.81,76.27 231.9,76.18 231.9,76.01 231.81,75.92 231.73,75.92 231.65,75.83 231.65,75.65 231.73,75.56 231.81,75.56 231.9,75.47 231.9,75.3 231.81,75.21 231.73,75.21 231.65,75.12 231.65,74.94 231.73,74.85 231.81,74.85 231.9,74.76 231.9,74.58 231.81,74.5 231.73,74.5 231.65,74.41 231.65,74.23 231.73,74.14 231.81,74.14 231.9,74.05 231.9,73.87 231.81,73.78 231.73,73.78 231.65,73.7 231.65,73.52 231.73,73.43 231.81,73.43 231.9,73.34 231.9,73.16 231.81,73.07 231.73,73.07 231.65,72.98 231.65,72.81 231.73,72.72 231.81,72.72 231.9,72.63 231.9,72.45 231.81,72.36 231.73,72.36 231.65,72.27 231.65,72.1 231.73,72.01 231.81,72.01 231.9,71.92 231.9,71.74 231.81,71.65 231.73,71.65 231.65,71.56 231.65,71.38 231.73,71.3 231.81,71.3 231.9,71.21 231.9,71.03 231.81,70.94 231.73,70.94 231.65,70.85 231.65,70.67 231.73,70.58 231.81,70.58 231.9,70.5 231.9,70.32 231.81,70.23 231.73,70.23 231.65,70.14 231.65,69.96 231.73,69.87 231.81,69.87 231.9,69.78 231.9,69.61 231.81,69.52 231.73,69.52 231.65,69.43 231.65,69.25 231.73,69.16 231.81,69.16 231.9,69.07 231.9,68.89 231.81,68.81 231.73,68.81 231.65,68.72 231.65,68.54 231.73,68.45 231.81,68.45 231.9,68.36 231.9,68.18 231.81,68.09 231.73,68.09 231.65,68.01 231.65,60.56 232.2,60 232.2,59.15 232.35,59 v1(232.66,59)
M_A_DQ38: length 59.3
  TOP w0.14: U41.AA2 239.21,105.05 v1(238.88,104.72) ; v1(228.95,58.85) 229.43,59.33 229.43,59.68 230.69,60.93 CN2063.183
  IN1 w0.079: 238.22,102.99 238.22,103.36 238.49,103.63 238.49,104.07 238.88,104.46 v1(238.88,104.72)
  IN1 w0.089: v1(228.95,58.85) 228.62,58.51 228.37,58.51 228.24,58.64 228.24,78.72 228.33,78.81 229.04,78.81 229.13,78.9 229.13,79.19 229.04,79.28 228.84,79.28 228.75,79.37 228.75,79.55 228.84,79.63 229.04,79.63 229.13,79.72 229.13,79.9 229.04,79.99 228.84,79.99 228.75,80.08 228.75,80.26 228.84,80.35 229.04,80.35 229.13,80.43 229.13,80.61 229.04,80.7 228.84,80.7 228.75,80.79 228.75,80.97 228.84,81.06 229.04,81.06 229.13,81.15 229.13,81.32 229.04,81.41 228.84,81.41 228.75,81.5 228.75,81.68 228.84,81.77 229.04,81.77 229.13,81.86 229.13,82.04 229.04,82.12 228.84,82.12 228.75,82.21 228.75,82.39 228.84,82.48 229.04,82.48 229.13,82.57 229.13,82.75 229.04,82.84 228.84,82.84 228.75,82.92 228.75,83.1 228.84,83.19 229.04,83.19 229.13,83.28 229.13,83.64 234.41,88.92 234.41,98.77 238.22,102.58 238.22,102.99
M_A_DQ39: length 59.3
  TOP w0.14: CN2063.187 229.69,60.72 229.13,60.17 v1(228.95,60.17) ; v1(238.91,103.93) 239.28,104.3 U41.AA1
  IN1 w0.089: v1(238.91,103.93) 238.65,103.67 238.65,103.56 238.55,103.46 238.55,102.54 234.7,98.68 234.7,88.78 229.43,83.52 229.43,78.52 229.34,78.43 228.62,78.43 228.53,78.34 228.53,78.16 228.62,78.07 229.23,78.07 229.29,78.01 229.29,77.79 229.2,77.7 228.63,77.7 228.53,77.6 228.53,76.74 228.62,76.65 228.87,76.65 228.96,76.56 228.96,76.38 228.87,76.29 228.62,76.29 228.53,76.21 228.53,76.03 228.62,75.94 228.94,75.94 229.02,75.85 229.02,75.67 228.94,75.58 228.62,75.58 228.53,75.49 228.53,75.32 228.62,75.23 228.94,75.23 229.02,75.14 229.02,74.96 228.94,74.87 228.62,74.87 228.53,74.78 228.53,74.61 228.62,74.52 228.94,74.52 229.02,74.43 229.02,74.25 228.94,74.16 228.62,74.16 228.53,74.07 228.53,73.89 228.62,73.81 228.79,73.81 228.88,73.72 228.88,73.54 228.79,73.45 228.62,73.45 228.53,73.36 228.53,73.18 228.62,73.09 228.76,73.09 228.85,73.01 228.85,72.83 228.76,72.74 228.62,72.74 228.53,72.65 228.53,72.47 228.62,72.38 228.72,72.38 228.8,72.31 228.8,72.13 228.7,72.03 228.62,72.03 228.53,71.94 228.53,71.63 228.62,71.54 228.62,71.3 228.53,71.21 228.53,62.84 228.62,62.75 228.94,62.75 229.02,62.66 229.02,62.48 228.94,62.39 228.62,62.39 228.53,62.3 228.53,62.12 228.62,62.04 228.94,62.04 229.02,61.95 229.02,61.77 228.94,61.68 228.62,61.68 228.53,61.59 228.53,61.41 228.62,61.32 228.94,61.32 229.02,61.24 229.02,61.06 228.94,60.97 228.62,60.97 228.53,60.88 228.53,60.59 v1(228.95,60.17)
M_A_DQ40: length 60.4
  TOP w0.14: v1(227.22,55.82) 227.94,55.11 CN2063.194 ; U41.V5 237.5,106.99 237.84,106.64 v1(237.92,106.64)
  IN1 w0.089: v1(237.92,106.64) 237.15,105.88 237.15,104.54 237.04,104.43 237.04,102.83 232.22,98.01 232.22,90.37 225.72,83.88 225.72,59.25 226.22,58.75 226.22,55.85 226.5,55.57 226.97,55.57 v1(227.22,55.82)
M_A_DQ41: length 61
  TOP w0.14: v1(227.17,58.67) 227.91,59.4 227.91,60.12 228.69,60.9 CN2063.191 ; U41.V2 237.5,104.99 237.8,104.68 v1(237.92,104.68)
  IN1 w0.089: v1(237.92,104.68) 237.64,104.4 237.64,104.37 237.38,104.1 237.38,102.69 232.81,98.12 232.81,90.13 232.01,89.33 232.01,89.2 232.13,89.08 232.13,88.96 232,88.83 231.87,88.83 231.75,88.95 231.63,88.95 231.5,88.83 231.5,88.7 231.62,88.58 231.62,88.46 231.5,88.33 231.37,88.33 231.25,88.45 231.13,88.45 231,88.32 231,88.2 231.12,88.08 231.12,87.95 230.99,87.83 230.87,87.83 230.75,87.95 230.62,87.95 230.5,87.82 230.5,87.7 230.62,87.58 230.62,87.45 230.49,87.32 230.37,87.32 230.24,87.44 230.12,87.44 229.99,87.32 229.99,87.19 230.11,87.07 230.11,86.95 229.99,86.82 229.86,86.82 229.74,86.94 229.62,86.94 229.49,86.82 229.49,86.69 229.61,86.57 229.61,86.44 229.49,86.32 229.36,86.32 229.24,86.44 229.11,86.44 228.99,86.31 228.99,86.19 229.11,86.07 229.11,85.94 228.98,85.81 228.86,85.81 228.74,85.94 228.61,85.94 228.48,85.81 228.48,85.68 228.61,85.56 228.61,85.44 228.48,85.31 228.35,85.31 228.23,85.43 228.11,85.43 227.98,85.31 227.98,85.18 228.1,85.06 228.1,84.94 227.98,84.81 227.85,84.81 227.73,84.93 227.6,84.93 227.48,84.8 227.48,84.68 227.6,84.56 227.6,84.43 227.47,84.31 227.35,84.31 227.23,84.43 227.1,84.43 226.98,84.3 226.98,84.18 227.1,84.05 227.1,83.93 226.97,83.8 226.85,83.8 226.72,83.92 226.6,83.92 226.47,83.8 226.47,83.67 226.59,83.55 226.59,83.43 226.37,83.2 226.37,59.47 v1(227.17,58.67)
M_A_DQ42: length 61
  TOP w0.14: CN2063.204 225.43,55.52 224.58,56.38 224.58,56.66 224.18,57.06 v1(224.18,57.15) ; U41.U1 236.76,104.34 237.03,104.07 237.03,102.74 236.46,102.17 235.64,102.17 v1(234.94,102.86)
  IN1 w0.089: v1(224.18,57.15) 223.62,57.15 222.91,57.86 222.91,58.15 222.99,58.24 223.2,58.24 223.29,58.33 223.29,58.51 223.2,58.6 222.99,58.6 222.91,58.68 222.91,78.96 222.91,78.96 222.91,84.17 230.02,91.29 230.02,98.27 232.04,100.29 232.72,100.29 234.51,102.07 234.51,102.43 v1(234.94,102.86)
M_A_DQ43: length 61
  TOP w0.14: v1(224.2,58.85) 225.69,60.33 CN2063.203 ; v1(234.92,102.2) 235.29,101.83 236.6,101.83 237.37,102.6 237.37,103.36 237.33,103.39 237.33,104.11 237.13,104.31 237.13,104.69 U41.U2
  IN1 w0.089: v1(234.92,102.2) 232.83,100.12 232.25,100.12 230.32,98.18 230.32,91.17 223.21,84.06 223.21,83.85 223.3,83.76 223.45,83.76 223.54,83.67 223.54,83.49 223.45,83.4 223.3,83.4 223.21,83.31 223.21,83.13 223.3,83.05 223.45,83.05 223.54,82.96 223.54,82.78 223.45,82.69 223.3,82.69 223.21,82.6 223.21,60.75 223.3,60.66 223.5,60.66 223.59,60.57 223.59,60.39 223.5,60.3 223.3,60.3 223.21,60.21 223.21,60.03 223.3,59.95 223.71,59.95 223.79,59.86 223.79,59.68 223.71,59.59 223.3,59.59 223.21,59.5 223.21,59.15 223.34,59.02 224.03,59.02 v1(224.2,58.85)
M_A_DQ44: length 60.5
  TOP w0.14: U41.V1 237.78,104.13 v1(237.78,103.92) ; CN2063.195 227.69,60.68 v1(227.17,60.17)
  IN1 w0.089: v1(227.17,60.17) 226.79,60.17 226.67,60.28 226.67,60.67 226.76,60.76 226.84,60.76 226.93,60.85 226.93,61.03 226.84,61.12 226.76,61.12 226.67,61.21 226.67,61.39 226.76,61.47 226.84,61.47 226.93,61.56 226.93,61.74 226.84,61.83 226.76,61.83 226.67,61.92 226.67,62.1 226.76,62.19 226.84,62.19 226.93,62.27 226.93,62.45 226.84,62.54 226.76,62.54 226.67,62.63 226.67,65.8 226.76,65.88 226.84,65.88 226.93,65.97 226.93,66.15 226.84,66.24 226.76,66.24 226.67,66.33 226.67,66.51 226.76,66.6 226.84,66.6 226.93,66.68 226.93,66.86 226.84,66.95 226.76,66.95 226.67,67.04 226.67,67.22 226.76,67.31 226.84,67.31 226.93,67.4 226.93,67.57 226.84,67.66 226.76,67.66 226.67,67.75 226.67,67.93 226.76,68.02 226.84,68.02 226.93,68.11 226.93,68.29 226.84,68.37 226.76,68.37 226.67,68.46 226.67,73.68 226.76,73.77 226.84,73.77 226.93,73.86 226.93,74.03 226.84,74.12 226.76,74.12 226.67,74.21 226.67,74.39 226.76,74.48 226.84,74.48 226.93,74.57 226.93,74.75 226.84,74.83 226.76,74.83 226.67,74.92 226.67,75.1 226.76,75.19 226.84,75.19 226.93,75.28 226.93,75.46 226.84,75.55 226.76,75.55 226.67,75.63 226.67,78.17 226.76,78.26 226.84,78.26 226.93,78.35 226.93,78.53 226.84,78.62 226.76,78.62 226.67,78.71 226.67,78.89 226.76,78.97 226.84,78.97 226.93,79.06 226.93,79.26 227.44,79.77 227.44,80.06 227.35,80.15 226.75,80.15 226.66,80.24 226.66,80.42 226.75,80.51 227.35,80.51 227.44,80.6 227.44,80.77 227.35,80.86 226.75,80.86 226.66,80.95 226.66,81.13 226.75,81.22 227.35,81.22 227.44,81.31 227.44,81.48 227.35,81.57 226.8,81.57 226.72,81.66 226.72,81.84 226.8,81.93 227.35,81.93 227.44,82.02 227.44,82.2 227.35,82.28 226.93,82.28 226.84,82.37 226.84,82.55 226.93,82.64 227.35,82.64 227.44,82.73 227.44,82.91 227.35,83 226.93,83 226.84,83.08 226.84,83.26 226.93,83.35 227.35,83.35 227.44,83.44 227.44,83.84 233.1,89.5 233.1,98.17 237.66,102.73 237.66,103.8 v1(237.78,103.92)
M_A_DQ45: length 60.5
  TOP w0.14: CN2063.190 228.94,55.71 v1(227.27,57.37) ; U41.V4 237.55,106.35 v1(237.92,105.99)
  IN1 w0.089: v1(237.92,105.99) 237.5,105.57 237.5,104.55 237.21,104.26 237.21,102.76 232.52,98.06 232.52,90.25 226.03,83.77 226.03,59.4 226.51,58.92 226.51,58.4 226.6,58.31 226.84,58.31 226.93,58.22 226.93,58.04 226.84,57.95 226.6,57.95 226.51,57.87 226.51,57.27 226.72,57.07 226.97,57.07 v1(227.27,57.37)
M_A_DQ46: length 60.9
  TOP w0.14: U41.U5 236.76,107.03 236.49,107.3 236.35,107.3 v1(236.35,107.3) ; v1(224.2,60.37) 224.69,60.86 CN2063.207
  IN1 w0.079: v1(236.35,107.3) 236.34,107.3 236.96,106.68 236.96,105.07 235.35,103.46 235.35,103.06
  IN1 w0.089: v1(224.2,60.37) 223.51,61.06 223.51,73.47 223.6,73.56 223.78,73.56 223.87,73.65 223.87,73.83 223.78,73.92 223.6,73.92 223.51,74.01 223.51,74.19 223.6,74.27 223.78,74.27 223.87,74.36 223.87,74.54 223.78,74.63 223.6,74.63 223.51,74.72 223.51,74.9 223.6,74.99 223.78,74.99 223.87,75.07 223.87,75.25 223.78,75.34 223.6,75.34 223.51,75.43 223.51,77.25 223.6,77.34 223.78,77.34 223.87,77.43 223.87,77.72 223.78,77.81 223.59,77.81 223.5,77.9 223.5,78.08 223.59,78.17 223.78,78.17 223.87,78.25 223.87,78.43 223.78,78.52 223.59,78.52 223.5,78.61 223.5,78.79 223.59,78.88 223.78,78.88 223.87,78.97 223.87,79.14 223.78,79.23 223.59,79.23 223.5,79.32 223.5,79.5 223.59,79.59 223.78,79.59 223.87,79.68 223.87,79.85 223.78,79.94 223.59,79.94 223.5,80.03 223.5,80.21 223.59,80.3 223.78,80.3 223.87,80.39 223.87,80.57 223.78,80.65 223.59,80.65 223.5,80.74 223.5,80.92 223.59,81.01 223.78,81.01 223.87,81.1 223.87,81.28 223.78,81.37 223.59,81.37 223.5,81.46 223.5,81.63 223.59,81.72 223.78,81.72 223.87,81.81 223.87,81.99 223.78,82.08 223.59,82.08 223.5,82.17 223.5,82.34 223.59,82.43 223.78,82.43 223.87,82.52 223.87,84.3 230.61,91.04 230.61,98.09 232.43,99.91 232.99,99.91 234.28,101.21 234.49,101.21 235.35,102.06 235.35,103.06
M_A_DQ47: length 61.1
  TOP w0.14: U41.U4 236.64,106.35 v1(236.34,106.65) ; v1(224.12,55.72) 224.63,55.22 224.63,54.7 224.43,54.51 CN2063.208
  IN1 w0.079: 234.1,101.9 234.34,102.13 234.34,102.82 235.27,103.75 235.42,103.75 236.71,105.04 236.71,106.29 v1(236.34,106.65)
  IN1 w0.089: 234.1,101.9 232.66,100.45 231.83,100.45 229.73,98.36 229.73,91.41 222.6,84.28 222.6,57.75 222.91,57.45 222.91,56.94 v1(224.12,55.72)
M_A_DQ48: length 64.3
  TOP w0.14: v1(235.42,104.79) 235.25,104.79 U41.R2 ; v1(222.17,56.97) 223.43,55.7 CN2063.212
  IN1 w0.079: 233.68,102.19 233.83,102.34 233.83,103.01 235.42,104.6 v1(235.42,104.79)
  IN1 w0.089: 233.68,102.19 232.5,101.01 231.13,101.01 228.42,98.3 228.42,91.98 221.15,84.7 221.15,74.11 221.06,74.02 220.7,74.02 220.61,73.93 220.61,73.75 220.7,73.66 221.06,73.66 221.15,73.57 221.15,73.4 221.06,73.31 220.7,73.31 220.61,73.22 220.61,73.04 220.7,72.95 221.06,72.95 221.15,72.86 221.15,72.69 221.06,72.6 220.7,72.6 220.61,72.51 220.61,72.33 220.7,72.24 221.06,72.24 221.15,72.15 221.15,71.97 221.06,71.89 220.7,71.89 220.61,71.8 220.61,71.62 220.7,71.53 221.06,71.53 221.15,71.44 221.15,71.26 221.06,71.17 220.7,71.17 220.61,71.08 220.61,70.91 220.7,70.82 221.06,70.82 221.15,70.73 221.15,70.44 221.06,70.35 220.7,70.35 220.61,70.26 220.61,60.37 221.49,59.5 221.49,57.65 v1(222.17,56.97)
M_A_DQ49: length 64.7
  TOP w0.14: CN2063.211 223.69,59.96 v1(222.17,58.44) ; U41.P5 234.25,107.01 233.96,107.3 v1(233.83,107.3)
  IN1 w0.079: 233.85,102.12 233.99,102.26 233.99,102.94 235.18,104.13 235.36,104.13 235.82,104.6 235.82,105.67 235.44,106.06 235.1,106.06 233.85,107.3 v1(233.83,107.3)
  IN1 w0.089: 233.85,102.12 232.56,100.83 231.29,100.83 228.72,98.26 228.72,91.83 221.44,84.55 221.44,70.06 221.35,69.97 221,69.97 220.91,69.88 220.91,69.7 221,69.61 221.35,69.61 221.44,69.52 221.44,69.35 221.35,69.26 221,69.26 220.91,69.17 220.91,68.99 221,68.9 221.35,68.9 221.44,68.81 221.44,68.63 221.35,68.54 221,68.54 220.91,68.46 220.91,68.28 221,68.19 221.35,68.19 221.44,68.1 221.44,67.92 221.35,67.83 221,67.83 220.91,67.74 220.91,60.49 221.78,59.62 221.78,58.83 v1(222.17,58.44)
M_A_DQ50: length 64.4
  TOP w0.14: v1(219.83,55.52) 219.43,55.12 CN2063.228 ; U41.R4 234.98,106.35 234.66,106.68 233.86,106.68 v1(233.83,106.65)
  IN1 w0.079: 232.54,103.69 233.28,104.43 233.28,106.09 233.48,106.28 233.48,106.29 233.83,106.64 v1(233.83,106.65)
  IN1 w0.089: 232.54,103.69 231.21,102.35 230.45,102.35 228.57,100.47 226.77,100.47 224.65,98.35 224.65,92.33 217.44,85.13 217.44,74.7 216.79,74.04 216.79,60.74 217.11,60.42 217.11,58.89 219.12,56.89 219.12,56.23 v1(219.83,55.52)
M_A_DQ51: length 64
  TOP w0.14: v1(218.45,60.05) 219.18,60.79 CN2063.229 ; v1(233.83,106.01) 233.9,106.01 U41.P4
  IN1 w0.079: 233.11,103.83 233.11,104 233.44,104.32 233.44,105.8 233.65,106.01 v1(233.83,106.01)
  IN1 w0.089: 233.11,103.83 233.11,102.57 232.32,101.78 230.73,101.78 228.51,99.56 227.1,99.56 226.2,98.66 226.2,92.47 219.05,85.32 219.05,85.14 218.96,85.05 218.8,85.05 218.71,84.96 218.71,84.78 218.8,84.69 218.96,84.69 219.05,84.6 219.05,84.43 218.96,84.34 218.8,84.34 218.71,84.25 218.71,84.07 218.8,83.98 218.96,83.98 219.05,83.89 219.05,83.72 218.96,83.63 218.8,83.63 218.71,83.54 218.71,83.36 218.8,83.27 218.96,83.27 219.05,83.18 219.05,83 218.96,82.92 218.8,82.92 218.71,82.83 218.71,82.65 218.8,82.56 218.96,82.56 219.05,82.47 219.05,82.29 218.96,82.2 218.8,82.2 218.71,82.12 218.71,81.94 218.8,81.85 218.96,81.85 219.05,81.76 219.05,81.58 218.96,81.49 218.8,81.49 218.71,81.4 218.71,81.23 218.8,81.14 218.96,81.14 219.05,81.05 219.05,80.87 218.96,80.78 218.8,80.78 218.71,80.69 218.71,80.52 218.8,80.43 218.96,80.43 219.05,80.34 219.05,80.16 218.96,80.07 218.8,80.07 218.71,79.98 218.71,79.8 218.8,79.72 218.96,79.72 219.05,79.63 219.05,79.45 218.96,79.36 218.8,79.36 218.71,79.27 218.71,79.09 218.8,79 218.96,79 219.05,78.92 219.05,78.74 218.96,78.65 218.8,78.65 218.71,78.56 218.71,78.38 218.8,78.29 218.96,78.29 219.05,78.2 219.05,78.03 218.96,77.94 218.8,77.94 218.71,77.85 218.71,77.67 218.8,77.58 218.96,77.58 219.05,77.49 219.05,77.32 218.96,77.23 218.8,77.23 218.71,77.14 218.71,76.96 218.8,76.87 218.96,76.87 219.05,76.78 219.05,76.6 218.96,76.51 218.8,76.51 218.71,76.43 218.71,76.25 218.8,76.16 218.96,76.16 219.05,76.07 219.05,75.89 218.96,75.8 218.8,75.8 218.71,75.71 218.71,75.54 218.8,75.45 218.96,75.45 219.05,75.36 219.05,75.07 217.68,73.69 217.68,61.15 218.13,60.7 218.13,60.37 v1(218.45,60.05)
M_A_DQ52: length 64.2
  TOP w0.14: v1(222.17,59.79) 222.69,60.3 CN2063.215 ; U41.R5 235.34,106.65 v1(235.4,106.65)
  IN1 w0.079: v1(235.4,106.65) 235.39,106.65 235.39,106.33 235.99,105.73 235.99,104.54 235.42,103.97 235.26,103.97 234.15,102.86 234.15,102.18 233.81,101.84
  IN1 w0.089: 233.81,101.84 232.62,100.65 231.44,100.65 229.01,98.22 229.01,91.71 221.73,84.43 221.73,67.48 221.64,67.39 221.36,67.39 221.27,67.3 221.27,67.12 221.36,67.03 221.64,67.03 221.73,66.94 221.73,66.76 221.64,66.68 221.36,66.68 221.27,66.59 221.27,66.41 221.36,66.32 221.64,66.32 221.73,66.23 221.73,66.05 221.64,65.96 221.36,65.96 221.27,65.88 221.27,65.7 221.36,65.61 221.64,65.61 221.73,65.52 221.73,65.34 221.64,65.25 221.36,65.25 221.27,65.16 221.27,64.99 221.36,64.9 221.64,64.9 221.73,64.81 221.73,64.63 221.64,64.54 221.36,64.54 221.27,64.45 221.27,64.28 221.36,64.19 221.64,64.19 221.73,64.1 221.73,63.92 221.64,63.83 221.36,63.83 221.27,63.74 221.27,63.56 221.36,63.48 221.64,63.48 221.73,63.39 221.73,63.21 221.64,63.12 221.36,63.12 221.27,63.03 221.27,62.85 221.36,62.76 221.64,62.76 221.73,62.68 221.73,62.5 221.64,62.41 221.36,62.41 221.27,62.32 221.27,62.14 221.36,62.05 221.64,62.05 221.73,61.96 221.73,61.79 221.64,61.7 221.36,61.7 221.27,61.61 221.27,61.43 221.36,61.34 221.79,61.34 221.88,61.25 221.88,61.07 221.79,60.99 221.36,60.99 221.27,60.9 221.27,60.72 221.36,60.63 221.64,60.63 221.73,60.54 221.73,60.23 v1(222.17,59.79)
M_A_DQ53: length 64
  TOP w0.14: U41.P2 234.61,104.69 234.61,104.13 234.15,103.67 v1(233.91,103.67) ; CN2063.216 222.43,54.59 222.53,54.69 222.53,55.16 v1(222.14,55.55)
  IN1 w0.089: v1(233.91,103.67) 233.64,103.4 233.64,102.39 232.44,101.18 230.98,101.18 228.13,98.33 228.13,92.12 220.85,84.84 220.85,74.58 220.32,74.05 220.32,60.25 220.58,59.99 220.58,57.11 220.67,57.02 221.45,57.02 221.54,56.93 221.54,56.75 221.45,56.66 220.67,56.66 220.58,56.57 220.58,56.4 220.67,56.31 221.58,56.31 221.67,56.22 221.67,56.04 221.58,55.95 220.67,55.95 220.58,55.86 220.58,55.63 220.67,55.55 v1(222.14,55.55)
M_A_DQ54: length 64.4
  TOP w0.14: v1(219.86,56.94) 220.43,56.37 CN2063.224 ; U41.R1 234.98,103.84 233.77,102.63 v1(232.29,102.63)
  IN1 w0.089: v1(232.29,102.63) 231.81,102.15 230.62,102.15 228.64,100.17 226.88,100.17 224.98,98.27 224.98,92.25 218.13,85.4 218.13,84.65 218.03,84.55 217.83,84.55 217.74,84.46 217.74,84.23 217.83,84.14 218.04,84.14 218.13,84.05 218.13,83.88 218.04,83.79 217.83,83.79 217.74,83.7 217.74,83.52 217.83,83.43 218.04,83.43 218.13,83.34 218.13,83.17 218.04,83.08 217.83,83.08 217.74,82.99 217.74,82.81 217.83,82.72 218.04,82.72 218.13,82.63 218.13,82.45 218.04,82.37 217.83,82.37 217.74,82.28 217.74,75.11 217.85,75 217.85,74.69 217.08,73.92 217.08,60.88 217.47,60.5 217.47,58.97 219.5,56.94 v1(219.86,56.94)
M_A_DQ55: length 65.1
  TOP w0.14: v1(232.71,103.16) 232.71,103.16 233.64,104.09 233.94,104.09 U41.P1 ; CN2063.225 220.18,60.85 220.01,60.67 219.63,60.67 218.99,60.04 218.99,59.25 v1(218.48,58.73)
  IN1 w0.089: v1(218.48,58.73) 218.27,58.73 217.83,59.17 217.83,60.57 217.37,61.02 217.37,73.8 218.42,74.85 218.42,75.14 218.33,75.23 218.12,75.23 218.03,75.32 218.03,75.5 218.12,75.59 218.33,75.59 218.42,75.67 218.42,75.85 218.33,75.94 218.12,75.94 218.03,76.03 218.03,76.21 218.12,76.3 218.33,76.3 218.42,76.39 218.42,76.56 218.33,76.65 218.12,76.65 218.03,76.74 218.03,76.92 218.12,77.01 218.33,77.01 218.42,77.1 218.42,77.27 218.33,77.36 218.12,77.36 218.03,77.45 218.03,77.63 218.12,77.72 218.33,77.72 218.42,77.81 218.42,77.99 218.33,78.07 218.12,78.07 218.03,78.16 218.03,78.34 218.12,78.43 218.33,78.43 218.42,78.52 218.42,78.7 218.33,78.79 218.12,78.79 218.03,78.87 218.03,79.05 218.12,79.14 218.33,79.14 218.42,79.23 218.42,79.41 218.33,79.5 218.12,79.5 218.03,79.59 218.03,79.76 218.12,79.85 218.33,79.85 218.42,79.94 218.42,80.12 218.33,80.21 218.12,80.21 218.03,80.3 218.03,80.48 218.12,80.56 218.33,80.56 218.42,80.65 218.42,80.83 218.33,80.92 218.12,80.92 218.03,81.01 218.03,81.19 218.12,81.28 218.33,81.28 218.42,81.36 218.42,81.54 218.33,81.63 218.12,81.63 218.03,81.72 218.03,81.9 218.12,81.99 218.33,81.99 218.42,82.08 218.42,85.11 225.91,92.59 225.91,98.79 226.99,99.86 228.57,99.86 230.66,101.95 232.25,101.95 232.76,102.46 232.76,103.1 v1(232.71,103.16)
M_A_DQ56: length 66.4
  TOP w0.14: v1(218.48,56.78) 217.43,55.73 CN2063.236 ; v1(232.88,106) 232.53,106.35 U41.M4
  IN1 w0.089: v1(218.48,56.78) 218.21,56.78 216.7,58.28 216.19,58.28 215.18,59.29 215.18,75.06 215.27,75.15 215.45,75.15 215.54,75.24 215.54,75.41 215.45,75.5 215.27,75.5 215.18,75.59 215.18,75.77 215.27,75.86 215.45,75.86 215.54,75.95 215.54,76.12 215.45,76.21 215.27,76.21 215.18,76.3 215.18,76.48 215.27,76.57 215.45,76.57 215.54,76.66 215.54,76.84 215.45,76.92 215.27,76.92 215.18,77.01 215.18,77.19 215.27,77.28 215.45,77.28 215.55,77.38 215.55,85.09 222.79,92.33 222.79,98.45 226.16,101.82 228.54,101.82 229.23,102.51 229.51,102.51 229.94,102.93 231.06,102.93 232.25,104.13 232.25,105.37 v1(232.88,106)
M_A_DQ57: length 65.6
  TOP w0.14: CN2063.237 217.18,60.85 v1(216.35,60.02) ; U41.M1 232.77,104.7 v1(232.88,104.7)
  IN1 w0.089: v1(216.35,60.02) 215.76,60.6 215.76,70.71 215.85,70.8 215.95,70.8 216.04,70.89 216.04,71.07 215.95,71.15 215.85,71.15 215.76,71.24 215.76,73.63 215.85,73.72 215.98,73.72 216.07,73.81 216.07,73.98 215.98,74.07 215.85,74.07 215.76,74.16 215.76,74.45 216.17,74.86 216.59,74.86 216.72,75 216.72,75.29 216.63,75.38 216.22,75.38 216.14,75.47 216.14,75.65 216.22,75.73 216.63,75.73 216.72,75.82 216.72,78.26 216.63,78.34 216.26,78.34 216.17,78.43 216.17,78.61 216.26,78.7 216.63,78.7 216.72,78.79 216.72,78.97 216.63,79.06 216.26,79.06 216.17,79.14 216.17,79.32 216.26,79.41 216.63,79.41 216.72,79.5 216.72,79.68 216.63,79.77 216.26,79.77 216.17,79.86 216.17,80.03 216.26,80.12 216.63,80.12 216.72,80.21 216.72,85.43 223.38,92.09 223.38,92.55 223.47,92.64 223.84,92.64 223.93,92.73 223.93,92.91 223.84,92.99 223.47,92.99 223.38,93.08 223.38,93.26 223.47,93.35 223.84,93.35 223.93,93.44 223.93,93.62 223.84,93.71 223.47,93.71 223.38,93.79 223.38,93.97 223.47,94.06 223.84,94.06 223.93,94.15 223.93,94.33 223.84,94.42 223.47,94.42 223.38,94.51 223.38,94.68 223.47,94.77 223.84,94.77 223.93,94.86 223.93,95.04 223.84,95.13 223.47,95.13 223.38,95.22 223.38,95.39 223.47,95.48 223.84,95.48 223.93,95.57 223.93,95.75 223.84,95.84 223.47,95.84 223.38,95.93 223.38,98.18 226.42,101.21 228.8,101.21 229.45,101.86 229.62,101.86 230.32,102.56 231.15,102.56 232.66,104.06 232.66,104.48 v1(232.88,104.7)
M_A_DQ58: length 66
  TOP w0.14: v1(213.61,56.61) 214.94,55.29 CN2063.246
  TOP w0.216: U41.L4 231.45,106.64 v1(231.28,106.64)
  IN1 w0.089: v1(231.28,106.64) 231,106.36 231,106.36 230.84,106.2 230.84,105.21 230.53,104.89 227.99,104.89 227.43,104.34 225.1,104.34 220.2,99.44 220.2,93.82 212.58,86.19 212.58,85.75 212.67,85.66 212.97,85.66 213.06,85.57 213.06,85.39 212.97,85.3 212.67,85.3 212.58,85.21 212.58,58.89 213.18,58.29 213.18,57.04 v1(213.61,56.61)
M_A_DQ59: length 65.9
  TOP w0.14: v1(213.61,58.82) 215.18,60.4 CN2063.245 ; v1(231.28,104.68) 231.65,105.05 U41.L2
  IN1 w0.089: v1(213.61,58.82) 212.88,59.55 212.88,80.45 212.97,80.54 213.26,80.54 213.35,80.63 213.35,80.92 213.26,81.01 212.96,81.01 212.87,81.1 212.87,81.28 212.96,81.36 213.26,81.36 213.35,81.45 213.35,81.63 213.26,81.72 212.96,81.72 212.87,81.81 212.87,81.99 212.96,82.08 213.26,82.08 213.35,82.16 213.35,82.34 213.26,82.43 212.96,82.43 212.87,82.52 212.87,82.7 212.96,82.79 213.26,82.79 213.35,82.88 213.35,83.05 213.26,83.14 212.96,83.14 212.87,83.23 212.87,83.41 212.96,83.5 213.26,83.5 213.35,83.59 213.35,83.76 213.26,83.85 212.96,83.85 212.87,83.94 212.87,84.12 212.96,84.21 213.26,84.21 213.35,84.3 213.35,84.48 213.26,84.56 212.96,84.56 212.87,84.65 212.87,84.83 212.96,84.92 213.26,84.92 213.35,85.01 213.35,86.55 220.51,93.71 220.51,99.32 225.24,104.05 227.57,104.05 228.06,104.54 230.71,104.54 230.86,104.68 v1(231.28,104.68)
M_A_DQ60: length 65.6
  TOP w0.14: U41.M5 232.53,107.01 v1(232.88,106.65) ; v1(218.5,55.35) 218.43,55.29 CN2063.232
  IN1 w0.089: v1(218.5,55.35) 218.5,55.56 214.89,59.17 214.89,77.67 214.98,77.76 215.17,77.76 215.26,77.85 215.26,78.02 215.17,78.11 214.98,78.11 214.89,78.2 214.89,78.38 214.98,78.47 215.17,78.47 215.26,78.56 215.26,85.21 222.5,92.45 222.5,98.59 226.03,102.12 228.42,102.12 229.13,102.84 229.51,102.84 229.8,103.12 231.01,103.12 232.05,104.17 232.05,105.63 232.33,105.91 232.33,106.09 v1(232.88,106.65)
M_A_DQ61: length 66.5
  TOP w0.14: v1(216.35,58.67) 217.38,59.7 217.38,60.12 218.18,60.93 CN2063.233 ; v1(232.88,105.35) 232.75,105.35 232.47,105.07 U41.M2
  IN1 w0.089: v1(232.88,105.35) 232.43,104.9 232.43,104.07 231.1,102.74 230.12,102.74 229.54,102.17 229.32,102.17 228.67,101.52 226.29,101.52 223.09,98.31 223.09,92.21 215.84,84.96 215.84,84.5 215.93,84.41 216.34,84.41 216.43,84.33 216.43,84.15 216.34,84.06 215.93,84.06 215.84,83.97 215.84,83.79 215.93,83.7 216.34,83.7 216.43,83.61 216.43,83.44 216.34,83.35 215.93,83.35 215.84,83.26 215.84,83.08 215.93,82.99 216.34,82.99 216.43,82.9 216.43,82.73 216.34,82.64 215.93,82.64 215.84,82.55 215.84,82.37 215.93,82.28 216.34,82.28 216.43,82.19 216.43,82.01 216.34,81.93 215.93,81.93 215.84,81.84 215.84,81.66 215.93,81.57 216.34,81.57 216.43,81.48 216.43,81.3 216.34,81.21 215.93,81.21 215.84,81.13 215.84,80.95 215.93,80.86 216.34,80.86 216.43,80.77 216.43,80.59 216.34,80.5 215.93,80.5 215.84,80.41 215.84,74.95 215.47,74.57 215.47,59.55 v1(216.35,58.67)
M_A_DQ62: length 65.8
  TOP w0.14: v1(231.28,107.3) 231.57,107.01 U41.L5 ; v1(213.61,55.27) 213.94,54.94 CN2063.250
  IN1 w0.089: v1(213.61,55.27) 212.87,56.01 212.87,58.16 212.27,58.76 212.27,86.3 219.91,93.94 219.91,99.56 223.46,103.11 223.46,103.91 225.05,105.5 227.85,105.5 230.05,107.71 230.87,107.71 v1(231.28,107.3)
M_A_DQ63: length 65.9
  TOP w0.14: U41.L1 231.21,103.88 v1(230.73,103.88) ; CN2063.249 214.18,60.77 v1(213.61,60.19)
  IN1 w0.089: v1(230.73,103.88) 230.37,104.23 228.19,104.23 227.71,103.76 225.38,103.76 220.81,99.19 220.81,93.05 220.33,92.57 220.21,92.57 220.06,92.72 219.93,92.72 219.81,92.59 219.81,92.47 219.96,92.31 219.96,92.19 219.83,92.06 219.71,92.06 219.55,92.21 219.43,92.21 219.3,92.09 219.3,91.96 219.45,91.81 219.45,91.69 219.33,91.56 219.2,91.56 219.05,91.71 218.93,91.71 218.8,91.59 218.8,91.46 218.95,91.31 218.95,91.18 218.83,91.06 218.7,91.06 218.55,91.21 218.42,91.21 218.3,91.08 218.3,90.96 218.45,90.81 218.45,90.68 218.32,90.55 218.2,90.55 218.05,90.71 217.92,90.71 217.79,90.58 217.79,90.45 217.95,90.3 217.95,90.18 217.82,90.05 217.69,90.05 217.54,90.2 217.42,90.2 217.29,90.08 217.29,89.95 217.44,89.8 217.44,89.67 217.32,89.55 217.19,89.55 217.04,89.7 216.91,89.7 216.79,89.57 216.79,89.45 216.94,89.3 216.94,89.17 216.81,89.05 216.69,89.05 216.54,89.2 216.41,89.2 216.29,89.07 216.29,88.95 216.44,88.79 216.44,88.67 216.31,88.54 216.19,88.54 216.03,88.69 215.91,88.69 215.78,88.57 215.78,88.44 215.93,88.29 215.93,88.17 215.81,88.04 215.68,88.04 215.53,88.19 215.41,88.19 215.28,88.07 215.28,87.94 215.43,87.79 215.43,87.66 215.3,87.54 215.18,87.54 215.03,87.69 214.9,87.69 214.78,87.56 214.78,87.44 214.93,87.29 214.93,87.16 214.8,87.03 214.68,87.03 214.52,87.19 214.4,87.19 214.27,87.06 214.27,86.93 214.43,86.78 214.43,86.66 214.3,86.53 214.17,86.53 214.02,86.68 213.9,86.68 213.77,86.56 213.77,86.43 213.92,86.28 213.92,86.15 213.64,85.88 213.64,80.12 213.56,80.03 213.26,80.03 213.18,79.94 213.18,79.76 213.26,79.68 213.56,79.68 213.64,79.59 213.64,79.42 213.56,79.33 213.28,79.33 213.19,79.24 213.19,60.61 v1(213.61,60.19)
M_A_DQSN0: length 61.7
  TOP w0.102: v1(265.37,107.07) 265.24,106.94 U41.BR5
  TOP w0.14: v1(274.29,58.24) 274.88,58.83 275.3,58.83 275.58,59.12 275.58,60.6 275.68,60.7 CN2063.11
  IN1 w0.089: v1(265.37,107.07) 265.55,107.07 266.26,106.37 267.4,106.37 267.64,106.12 267.75,106.12 269.4,104.48 269.4,104.24 269.78,103.86 269.78,103.43 270.13,103.07 270.13,100.16 271.25,99.04 271.25,91.1 273.43,88.92 273.43,74.25 273.51,74.16 273.51,69.87 273.7,69.68 274.13,69.68 274.22,69.59 274.22,69.04 274.13,68.96 273.7,68.96 273.51,68.77 273.51,68.08 273.7,67.9 274.13,67.9 274.22,67.81 274.22,67.26 274.13,67.17 273.7,67.17 273.51,66.99 273.51,66.3 273.7,66.11 274.13,66.11 274.22,66.02 274.22,65.48 274.13,65.39 273.7,65.39 273.51,65.2 273.51,59.27 273.7,59.08 273.91,59.08 274.29,58.7 v1(274.29,58.24)
M_A_DQSN1: length 58.4
  TOP w0.14: v1(269.18,57.96) 269.18,57.35 269.32,57.21 269.91,57.21 270.34,56.78 270.34,54.69 270.44,54.59 CN2063.32 ; U41.BL3 262.59,105.7 v1(262.26,105.37)
  IN1 w0.089: v1(262.26,105.37) 262.04,105.37 261.92,105.25 261.92,104.86 262.06,104.73 262.62,104.73 262.98,104.38 264.22,104.38 265.99,102.61 265.99,90.81 268.57,88.22 268.57,58.62 268.26,58.31 268.26,58.12 268.68,57.71 268.93,57.71 v1(269.18,57.96)
M_A_DQSN2: length 56.6
  TOP w0.102: U41.BG3 260.25,105.58 260.38,105.58 260.7,105.26 260.7,104.92 260.95,104.66 260.95,104.28 261.03,104.21 261.03,103.67 261.52,103.19 261.52,102.73 261.54,102.71 261.54,102.7
  TOP w0.14: CN2063.53 265.19,60.82 265.13,60.76 265.13,59.61 265.42,59.32 265.42,58.61 264.53,57.72 v1(264.53,57.38) ; v1(260.82,101.34) 260.82,101.41 261.03,101.62 261.31,101.62 261.54,101.85 261.54,102.7
  IN1 w0.089: v1(260.82,101.34) 261.07,101.58 261.18,101.58 261.61,101.16 261.61,89.17 263.21,87.56 263.21,58.48 264.11,57.59 264.33,57.59 v1(264.53,57.38)
M_A_DQSN3: length 55.7
  TOP w0.14: U41.BD3 257.62,105.7 257.96,105.36 v1(258.03,105.36) ; CN2063.74 259.93,54.5 259.82,54.61 259.82,56.73 259.57,56.99 259.08,56.99 v1(258.9,57.17)
  IN1 w0.089: v1(258.9,57.17) 258.9,56.74 258.77,56.61 258.59,56.61 258.08,57.12 258.08,57.61 258.29,57.81 258.29,85.78 257.63,86.44 257.63,99.31 257.29,99.65 257.29,105.16 257.48,105.36 v1(258.03,105.36)
M_A_DQSN4: length 59.7
  TOP w0.14: U41.AA3 239.21,105.7 v1(238.88,105.38) ; CN2063.177 232.18,60.7 232.08,60.6 232.08,60.16 231.81,59.89 231.81,59.16 231.39,58.74 231.15,58.74 v1(230.65,58.24)
  IN1 w0.089: v1(230.65,58.24) 230.65,58.45 230.47,58.62 230.23,58.62 229.75,59.1 229.75,63.85 229.52,64.08 229.52,64.86 229.85,65.2 229.85,66.02 229.66,66.21 229.44,66.21 229.26,66.4 229.26,67.09 229.44,67.27 229.78,67.27 229.87,67.36 229.87,67.91 229.78,68 229.44,68 229.26,68.18 229.26,68.87 229.44,69.06 229.8,69.06 229.89,69.14 229.89,69.69 229.8,69.78 229.44,69.78 229.26,69.97 229.26,70.65 229.44,70.84 229.66,70.84 229.75,70.93 229.75,77.22 230.16,77.63 230.16,83.22 235.42,88.48 235.42,99.16 239.45,103.18 239.45,105.1 239.17,105.38 v1(238.88,105.38)
M_A_DQSN5: length 61.2
  TOP w0.102: U41.U3 236.64,105.58 236.51,105.58 236.21,105.28 236.21,104.31 235.92,104.02 235.92,103.68 236.15,103.44 236.31,103.44 v1(236.53,103.23)
  TOP w0.14: CN2063.198 226.94,54.54 226.76,54.71 226.76,55.02 226.59,55.19 226.59,57.07 226.32,57.33 225.98,57.33 v1(225.5,57.81)
  IN1 w0.089: v1(236.53,103.23) 235.94,103.23 235.76,103.05 235.76,102 232.88,99.12 232.65,99.12 231.5,97.97 231.5,90.67 224.76,83.93 224.76,67.96 225,67.72 225,67.02 224.75,66.77 224.56,66.77 224.41,66.62 224.41,65.98 224.76,65.62 224.76,63.03 224.41,62.68 224.41,61.43 224.99,60.85 224.99,58.49 224.76,58.26 224.76,57.83 225.09,57.5 225.37,57.5 225.5,57.62 v1(225.5,57.81)
M_A_DQSN6: length 64.6
  TOP w0.14: v1(219.86,58.26) 220.05,58.45 220.53,58.45 221.18,59.1 221.18,59.95 221.55,60.32 221.55,60.56 221.69,60.7 CN2063.219 ; U41.P3 234.19,105.7 233.84,105.36 v1(233.84,105.36)
  IN1 w0.089: v1(233.84,105.36) 234.43,105.36 234.52,105.26 234.52,104.62 234.13,104.24 233.67,104.24 233.3,103.87 233.3,102.53 232.3,101.52 230.72,101.52 228.38,99.18 227.74,99.18 226.92,98.36 226.92,92.17 219.96,85.21 219.96,74.95 218.59,73.58 218.59,66.95 218.78,66.77 218.98,66.77 219.07,66.68 219.07,66.13 218.98,66.04 218.78,66.04 218.59,65.86 218.59,65.17 218.78,64.98 219.24,64.98 219.33,64.9 219.33,64.35 219.24,64.26 218.78,64.26 218.59,64.07 218.59,63.39 218.78,63.2 219.24,63.2 219.33,63.11 219.33,62.57 219.24,62.48 218.78,62.48 218.59,62.29 218.59,61.43 218.9,61.12 218.9,59.36 219.51,58.75 219.74,58.75 219.86,58.64 v1(219.86,58.26)
M_A_DQSN7: length 66
  TOP w0.14: v1(231.28,105.33) 231.33,105.38 232.06,105.38 232.15,105.47 232.15,105.67 232.03,105.79 231.81,105.79 U41.L3 ; v1(216.38,54.86) 216.43,54.8 CN2063.240
  IN1 w0.089: v1(216.38,54.86) 216.38,55.58 216,55.96 215.82,55.96 215.74,55.88 215,55.88 214.63,56.24 214.63,57.43 214,58.07 214,78.75 214.37,79.12 214.37,85.58 221.54,92.75 221.54,98.89 225.68,103.03 228.03,103.03 228.48,103.48 230.89,103.48 231.69,104.28 231.69,105.49 231.6,105.59 231.38,105.59 231.28,105.49 v1(231.28,105.33)
M_A_DQSN8: length 6.6
  TOP w0.14: CN2063.95 254.69,60.15 253.26,58.72 v1(253.24,58.72)
  BOTTOM w0.14: R21400.2 253.49,60.65 253.72,60.42 253.72,59.2 v1(253.24,58.72)
M_A_DQSP0: length 61.6
  TOP w0.102: U41.BP5 264.61,107.07 v1(264.79,107.25)
  TOP w0.14: v1(274.3,59.51) 274.69,59.12 275.17,59.12 275.29,59.24 275.29,60.6 275.19,60.7 CN2063.13
  IN1 w0.089: v1(264.79,107.25) 265.02,107.48 265.63,107.48 265.81,107.31 265.81,107.06 266.33,106.53 267.47,106.53 267.71,106.29 267.82,106.29 269.56,104.55 269.56,104.31 269.95,103.93 269.95,103.5 270.3,103.14 270.3,100.23 271.42,99.11 271.42,91.17 273.59,88.99 273.59,74.32 273.68,74.23 273.68,69.94 273.76,69.85 274.2,69.85 274.38,69.66 274.38,68.98 274.2,68.79 273.76,68.79 273.68,68.7 273.68,68.15 273.76,68.06 274.2,68.06 274.38,67.88 274.38,67.19 274.2,67.01 273.76,67.01 273.68,66.92 273.68,66.37 273.76,66.28 274.2,66.28 274.38,66.09 274.38,65.41 274.2,65.22 273.76,65.22 273.68,65.13 273.68,59.33 273.76,59.25 274.21,59.25 274.3,59.33 v1(274.3,59.51)
M_A_DQSP1: length 58.3
  TOP w0.14: U41.BK3 261.8,105.7 v1(261.45,105.35) ; CN2063.34 269.93,54.62 270.05,54.73 270.05,56.66 269.79,56.92 269.41,56.92 v1(269.18,56.69)
  IN1 w0.089: v1(261.45,105.35) 261.63,105.35 261.75,105.23 261.75,104.8 261.99,104.56 262.55,104.56 262.91,104.21 264.15,104.21 265.82,102.54 265.82,90.74 268.41,88.15 268.41,58.69 268.1,58.38 268.1,58.05 268.61,57.54 268.96,57.54 269.18,57.32 v1(269.18,56.69)
M_A_DQSP2: length 56.6
  TOP w0.102: 261.3,102.7 261.3,102.71 261.32,102.73 261.32,103.1 260.83,103.59 260.83,104.12 260.75,104.2 260.75,104.58 260.5,104.83 260.5,105.17 260.29,105.38 259.58,105.38 259.39,105.57 U41.BF3
  TOP w0.14: v1(260.79,102.07) 260.79,102.01 260.93,101.86 261.21,101.86 261.3,101.95 261.3,102.7 ; v1(264.53,58.67) 264.64,58.56 264.96,58.56 265.13,58.73 265.13,59.2 264.84,59.49 264.84,60.65 264.69,60.81 CN2063.55
  IN1 w0.089: v1(260.79,102.07) 261.1,101.75 261.25,101.75 261.78,101.23 261.78,89.23 263.38,87.63 263.38,58.55 264.18,57.75 264.36,57.75 264.53,57.92 v1(264.53,58.67)
M_A_DQSP3: length 55.8
  TOP w0.14: CN2063.76 259.44,54.54 259.53,54.64 259.53,56.61 259.45,56.7 259.08,56.7 258.9,56.51 v1(258.9,56) ; v1(256.45,105.33) 256.83,105.7 U41.BC3
  IN1 w0.089: v1(256.45,105.33) 256.86,105.33 256.94,105.33 257.12,105.15 257.12,99.59 257.46,99.24 257.46,86.37 258.12,85.71 258.12,57.88 257.92,57.67 257.92,57.05 258.52,56.44 258.63,56.44 258.9,56.18 v1(258.9,56)
M_A_DQSP4: length 59.6
  TOP w0.14: CN2063.179 231.69,60.7 231.79,60.6 231.79,60.28 231.52,60.01 231.52,59.28 231.27,59.03 231.15,59.03 v1(230.65,59.53) ; v1(240.4,105.38) 240.08,105.7 U41.AB3
  IN1 w0.089: v1(230.65,59.53) 230.65,58.92 230.53,58.79 230.3,58.79 229.92,59.17 229.92,63.92 229.68,64.15 229.68,64.79 230.02,65.13 230.02,66.09 229.73,66.38 229.51,66.38 229.42,66.47 229.42,67.02 229.51,67.1 229.85,67.1 230.04,67.29 230.04,67.98 229.85,68.16 229.51,68.16 229.42,68.25 229.42,68.8 229.51,68.89 229.87,68.89 230.06,69.07 230.06,69.76 229.87,69.95 229.51,69.95 229.42,70.04 229.42,70.58 229.51,70.67 229.73,70.67 229.92,70.86 229.92,77.15 230.32,77.56 230.32,83.15 235.59,88.41 235.59,99.09 239.62,103.11 239.62,105.19 239.8,105.38 v1(240.4,105.38)
M_A_DQSP5: length 61.1
  TOP w0.102: v1(236.32,103.85) 236.42,103.94 236.42,105.2 236.6,105.38 237.17,105.38 U41.V3
  TOP w0.14: CN2063.200 226.43,54.55 226.47,54.59 226.47,54.9 226.3,55.07 226.3,56.94 226.2,57.04 226,57.04 v1(225.5,56.53)
  IN1 w0.089: v1(225.5,56.53) 225.5,57.12 225.28,57.33 225.02,57.33 224.59,57.76 224.59,58.33 224.82,58.56 224.82,60.78 224.24,61.36 224.24,62.75 224.59,63.1 224.59,65.56 224.24,65.91 224.24,66.69 224.49,66.94 224.68,66.94 224.83,67.09 224.83,67.65 224.59,67.89 224.59,84 231.33,90.74 231.33,98.04 232.58,99.29 232.81,99.29 235.59,102.07 235.59,103.12 v1(236.32,103.85)
M_A_DQSP6: length 64.6
  TOP w0.14: U41.R3 235.17,105.7 v1(235.42,105.45) ; CN2063.221 221.18,60.7 221.25,60.63 221.25,60.44 220.89,60.08 220.89,59.22 220.41,58.75 220.03,58.75 219.83,58.95 v1(219.83,59.53)
  IN1 w0.089: v1(219.83,59.53) 219.83,59.05 219.7,58.92 219.58,58.92 219.07,59.43 219.07,61.19 218.76,61.5 218.76,62.22 218.85,62.31 219.31,62.31 219.5,62.5 219.5,63.18 219.31,63.37 218.85,63.37 218.76,63.46 218.76,64 218.85,64.09 219.31,64.09 219.5,64.28 219.5,64.97 219.31,65.15 218.85,65.15 218.76,65.24 218.76,65.79 218.85,65.88 219.05,65.88 219.24,66.06 219.24,66.75 219.05,66.94 218.85,66.94 218.76,67.02 218.76,73.51 220.13,74.88 220.13,85.14 227.09,92.1 227.09,98.3 227.81,99.01 228.45,99.01 230.79,101.35 232.37,101.35 233.47,102.46 233.47,103.8 233.74,104.07 234.2,104.07 234.69,104.55 234.69,105.24 234.87,105.42 235.4,105.42 v1(235.42,105.45)
M_A_DQSP7: length 66.2
  TOP w0.14: v1(216.38,56.13) 215.94,55.69 CN2063.242 ; U41.M3 232.46,105.7 232.13,106.03 231.33,106.03 v1(231.28,105.98)
  IN1 w0.089: v1(216.38,56.13) 215.75,56.13 215.67,56.04 215.07,56.04 214.8,56.31 214.8,57.5 214.16,58.14 214.16,78.68 214.54,79.05 214.54,85.51 221.7,92.68 221.7,98.82 225.75,102.87 228.1,102.87 228.55,103.31 230.96,103.31 231.86,104.21 231.86,105.56 231.67,105.75 231.5,105.75 231.44,105.81 v1(231.28,105.98)
M_A_DQSP8: length 5.6
  TOP w0.14: CN2063.97 254.18,60.33 v1(253.23,59.38)
  BOTTOM w0.14: v1(253.23,59.38) 251.29,61.32 R21395.2
M_A_EVENT#: length 2.9
  TOP w0.14: v1(244.93,54.91) CN2063.134
  BOTTOM w0.14: v1(244.88,53.38) 244.94,53.45 R21387.2 244.94,54.91 v1(244.93,54.91)
M_A_ODT0_CPU: length 59.8
  TOP w0.216: U41.AD3 241.79,105.66 241.48,105.35 v1(241.36,105.35) ; CN2063.155 237.69,60.64 236.07,59.03 v1(235.2,59.03)
  IN1 w0.14: v1(241.36,105.35) 241.78,104.93 241.78,103.4 237.94,99.56 237.94,87.39 233.21,82.65 233.21,58.5 233.47,58.23 233.78,58.23 234,58 234,57.37 234.13,57.24 234.7,57.24 234.84,57.38 234.84,58.66 v1(235.2,59.03)
