# Allegro board DAZGLMB1ED0 dazglmb1ed0-d-ver a-165 (.BRD) .brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
R21789  *Short_0805  [S0805]  46.74 27.7 270 top
R21790  *Short_0402  [S0402]  31.39 23.08 90 top
R21792  *Short_0402  [S0402]  33.93 23.08 90 top
R21793  *Short_0402  [S0402]  34.95 23.08 90 top
R21794  *Short_0402  [S0402]  37.49 23.08 90 top
R21795  *Short_0402  [S0402]  38.5 23.08 90 top
R21796  *Short_0402  [S0402]  41.55 23.46 0 bottom
R21797  *10K_1%_2  [R0201]  41.17 22.57 0 bottom
R21798  *Short_0402  [S0402]  41.02 23.08 90 top
R21799  *Short_0402  [S0402]  42.03 23.08 90 top
R21800  *Short_0402  [S0402]  46.71 23.08 270 bottom
R21801  4.7K_1%_4  [R0402]  42.79 26.59 0 top
R21802  *0_5%_4  [R0402]  42.79 27.73 0 top
R21859  549_1%_4  [R0402]  201.57 129.76 0 top
R21860  1.33K_1%_4  [R0402]  200.19 132.24 180 bottom
R21861  121_1%_4  [R0402]  202.07 132.22 0 bottom
R21862  931_1%_4  [R0402]  201.57 128.62 0 top
R21863  121_1%_4  [R0402]  199.02 124.54 90 bottom
R21864  549_1%_4  [R0402]  184.81 171.41 90 bottom
R21865  121_1%_4  [R0402]  181.59 172.8 270 bottom
R21866  931_1%_4  [R0402]  185.82 171.41 90 bottom
R21867  1.33K_1%_4  [R0402]  182.65 171.41 90 bottom
R21868  121_1%_4  [R0402]  199.34 161.88 90 bottom
R21869  549_1%_4  [R0402]  142.26 174.08 180 bottom
R21870  1.33K_1%_4  [R0402]  142.26 171.8 180 bottom
R21872  931_1%_4  [R0402]  142.65 175.61 90 bottom
R21873  121_1%_4  [R0402]  145.87 169.63 270 bottom
R21874  549_1%_4  [R0402]  121.56 138.14 90 bottom
R21875  121_1%_4  [R0402]  120.78 135.55 90 bottom
R21876  1.33K_1%_4  [R0402]  122.7 138.14 90 bottom
R21877  931_1%_4  [R0402]  120.04 137.75 180 bottom
R21879  100K_1%_4  [R0402]  150.01 106.39 270 top
R21880  100K_1%_4  [R0402]  151.02 106.39 270 top
R21881  10K_1%_2  [R0201]  131.72 119.85 0 top
R21882  100K_1%_4  [R0402]  131.82 116.6 180 top
R21883  100K_1%_4  [R0402]  131.54 115.26 90 top
R21885  4.7K_1%_4  [R0402]  55.34 35.04 180 bottom
R21886  4.7K_1%_4  [R0402]  55.34 34 0 top
R21887  *4.7K_1%_4  [R0402]  55.34 34 180 bottom
R21888  *4.7K_1%_4  [R0402]  65.96 32.12 180 top
R21889  4.7K_1%_4  [R0402]  66.19 32.05 0 bottom
R21890  4.7K_1%_4  [R0402]  65.96 34.15 180 top
R21891  *4.7K_1%_4  [R0402]  66.19 34.08 0 bottom
R21892  4.7K_1%_4  [R0402]  64.89 44.26 180 bottom
R21893  *4.7K_1%_4  [R0402]  64.89 44.26 0 top
R21894  4.7K_1%_4  [R0402]  64.89 43.25 0 top
R21895  *4.7K_1%_4  [R0402]  64.89 43.25 180 bottom
R21896  *4.7K_1%_4  [R0402]  74.21 41.37 0 bottom
R21897  4.7K_1%_4  [R0402]  77.36 41.62 0 bottom
R21898  4.7K_1%_4  [R0402]  74.24 43.37 0 bottom
R21899  *4.7K_1%_4  [R0402]  77.36 43.65 0 bottom
R21900  *4.7K_1%_4  [R0402]  64.89 46.3 0 bottom
R21901  *4.7K_1%_4  [R0402]  64.89 45.28 0 bottom
R21902  *4.7K_1%_4  [R0402]  64.89 41.22 0 bottom
R21903  *4.7K_1%_4  [R0402]  69.84 37.41 90 top
R21904  *4.7K_1%_4  [R0402]  75.61 45.2 0 bottom
R21905  4.7K_1%_4  [R0402]  69.84 37.56 270 bottom
R21906  *PCIE@4.7K_1%_4  [R0402]  68.32 38.22 270 bottom
R21907  4.7K_1%_4  [R0402]  77.36 42.64 0 bottom
R21908  *4.7K_1%_4  [R0402]  77.36 45.69 180 bottom
R21909  *SATA@4.7K_1%_4  [R0402]  68.47 37.41 90 top
R21910  *4.7K_1%_4  [R0402]  77.36 44.67 0 bottom
R21911  *4.7K_1%_4  [R0402]  64.89 42.23 0 top
R21912  *4.7K_1%_4  [R0402]  74.19 48.23 270 top
R21913  *4.7K_1%_4  [R0402]  74.24 42.38 0 bottom
R21914  *4.7K_1%_4  [R0402]  74.19 40.25 0 bottom
R21915  4.7K_1%_4  [R0402]  71.65 48.23 270 top
R21916  4.99K_1%_4  [R0402]  74.77 39.77 0 top
R21917  *4.7K_1%_4  [R0402]  64.89 42.23 180 bottom
R21918  *4.7K_1%_4  [R0402]  75.31 48.23 90 top
R21919  *4.7K_1%_4  [R0402]  77.36 40.61 0 bottom
R21920  4.7K_1%_4  [R0402]  39.75 37.84 180 bottom
R21921  *4.7K_1%_4  [R0402]  39.75 37.84 0 top
R21922  4.7K_1%_4  [R0402]  39.75 36.87 0 top
R21923  *4.7K_1%_4  [R0402]  39.75 36.87 180 bottom
R21924  *4.7K_1%_4  [R0402]  51.35 35.04 180 top
R21925  4.7K_1%_4  [R0402]  51.35 35.04 0 bottom
R21926  4.7K_1%_4  [R0402]  51.35 37.08 180 top
R21927  *4.7K_1%_4  [R0402]  51.38 37.08 0 bottom
R21928  *4.7K_1%_4  [R0402]  49.55 47.41 0 top
R21929  4.7K_1%_4  [R0402]  49.32 47.44 180 bottom
R21930  4.7K_1%_4  [R0402]  49.55 46.35 0 top
R21931  *4.7K_1%_4  [R0402]  49.33 46.37 180 bottom
R21932  *4.7K_1%_4  [R0402]  61.13 43.93 180 top
R21933  4.7K_1%_4  [R0402]  61.28 43.93 0 bottom
R21934  *4.7K_1%_4  [R0402]  61.13 45.97 0 bottom
R21935  4.7K_1%_4  [R0402]  61.13 45.97 180 top
R21936  *4.7K_1%_4  [R0402]  49.31 49.65 0 bottom
R21937  *4.7K_1%_4  [R0402]  49.32 48.53 0 bottom
R21938  *4.7K_1%_4  [R0402]  49.31 44.21 0 bottom
R21939  *4.7K_1%_4  [R0402]  54.78 40.71 90 top
R21940  4.7K_1%_4  [R0402]  54.78 40.71 270 bottom
R21941  *4.7K_1%_4  [R0402]  61.13 46.98 180 top
R21942  4.7K_1%_4  [R0402]  61.28 44.95 0 bottom
R21943  *PCIE@4.7K_1%_4  [R0402]  53.26 40.71 270 bottom
R21944  *4.7K_1%_4  [R0402]  61.13 48.07 180 bottom
R21945  *SATA@4.7K_1%_4  [R0402]  53.26 40.71 90 top
R21946  *4.7K_1%_4  [R0402]  61.13 46.98 0 bottom
R21947  *4.7K_1%_4  [R0402]  42.13 38.68 180 bottom
R21948  *4.7K_1%_4  [R0402]  49.55 45.3 0 top
R21949  *4.7K_1%_4  [R0402]  58.92 51.17 270 bottom
R21950  *4.7K_1%_4  [R0402]  61.13 44.95 180 top
R21951  *4.7K_1%_4  [R0402]  61.13 42.92 180 top
R21952  4.7K_1%_4  [R0402]  56.28 51.25 270 top
R21953  6.2K_1%_4  [R0402]  61.13 41.9 180 top
R21954  *4.7K_1%_4  [R0402]  49.33 45.3 180 bottom
R21955  *4.7K_1%_4  [R0402]  59.99 51.17 90 bottom
R21956  *4.7K_1%_4  [R0402]  61.13 42.92 0 bottom
R21957  *4.7K_1%_4  [R0402]  39.75 38.83 0 top
R21958  *4.7K_1%_4  [R0402]  39.75 34.74 0 top
R21959  *4.7K_1%_4  [R0402]  44.95 31.82 90 top
R21960  *4.7K_1%_4  [R0402]  51.35 38.09 180 top
R21961  4.7K_1%_4  [R0402]  44.95 31.82 270 bottom
R21962  *PCIE@4.7K_1%_4  [R0402]  43.25 31.82 270 bottom
R21963  4.7K_1%_4  [R0402]  51.35 36.06 0 bottom
R21964  *4.7K_1%_4  [R0402]  51.35 39.21 180 top
R21965  *SATA@4.7K_1%_4  [R0402]  43.25 31.82 90 top
R21966  *4.7K_1%_4  [R0402]  51.35 38.09 0 bottom
R21967  *4.7K_1%_4  [R0402]  39.75 35.83 0 top
R21968  *4.7K_1%_4  [R0402]  49.14 42.21 270 top
R21969  *4.7K_1%_4  [R0402]  51.35 36.06 180 top
R21970  *Short_0402  [S0402]  51.61 50.51 180 bottom
R21971  *4.7K_1%_4  [R0402]  51.35 34.03 180 top
R21972  4.7K_1%_4  [R0402]  46.5 42.36 270 top
R21973  6.2K_1%_4  [R0402]  51.35 33.01 180 top
R21974  *4.7K_1%_4  [R0402]  39.75 35.83 180 bottom
R21975  *4.7K_1%_4  [R0402]  50.16 42.21 90 top
R21976  *4.7K_1%_4  [R0402]  51.35 34.03 0 bottom
R21977  *Short_0402  [S0402]  51.56 32.53 270 bottom
R21979  *4.7K_1%_4  [R0402]  55.34 36.08 0 top
R21981  4.99K_1%_4  [R0402]  65.83 30.06 180 top
R21982  *4.7K_1%_4  [R0402]  55.34 35.04 0 top
R21984  *4.7K_1%_4  [R0402]  55.34 37.2 0 top
R21986  *4.7K_1%_4  [R0402]  55.34 31.89 0 top
R21988  *4.7K_1%_4  [R0402]  65.96 36.34 180 top
R21990  *Short_0402  [S0402]  319.6 69.56 0 top
R21992  WIGIG@0_5%_4  [R0402]  322.85 66.39 180 bottom
R21993  *WIGIG@0_5%_4  [R0402]  61.82 55.21 180 bottom
R21994  *WIGIG@0_5%_4  [R0402]  61.82 56.23 180 bottom
R21995  WIGIG@0_5%_4  [R0402]  49.8 64.86 180 top
R21996  *WIGIG@0_5%_4  [R0402]  52.88 55.85 180 bottom
R21997  *WIGIG@0_5%_4  [R0402]  52.85 58.39 270 bottom
R21998  WIGIG@0_5%_4  [R0402]  60.42 59.33 180 bottom
R21999  WIGIG@0_5%_4  [R0402]  60.42 58.31 180 bottom
R22000  WIGIG@0_5%_4  [R0402]  60.47 66.13 90 bottom
R22001  WIGIG@100K_1%_4  [R0402]  49.91 70.68 0 top
R22002  WIGIG@100K_1%_4  [R0402]  49.93 69.38 0 top
R22003  *WIGIG@4.7K_1%_4  [R0402]  47.52 52.42 180 top
R22005  *WIGIG@4.7K_1%_4  [R0402]  49.73 52.26 0 top
R22007  *Short_0603  [S0603]  355.49 77.05 270 top
R22008  *Short_0402  [S0402]  348.51 78.32 270 bottom
R22009  *Short_0402  [S0402]  349.65 78.32 270 bottom
R22010  10K_1%_2  [R0201]  190.11 133.52 90 top
R22011  10K_1%_2  [R0201]  199.54 145.25 90 bottom
R22012  10K_1%_2  [R0201]  189.76 126.67 270 top
R22013  10K_1%_2  [R0201]  200.05 113.63 0 bottom
R22014  10K_1%_2  [R0201]  179.11 161.51 180 top
R22015  10K_1%_2  [R0201]  169.57 170.78 180 bottom
R22016  10K_1%_2  [R0201]  193.57 156.18 180 bottom
R22017  10K_1%_2  [R0201]  199.41 147.79 270 bottom
R22018  10K_1%_2  [R0201]  135.91 162.4 0 bottom
R22019  10K_1%_2  [R0201]  126.39 170.65 180 bottom
R22020  10K_1%_2  [R0201]  148.71 163.19 0 bottom
R22021  10K_1%_2  [R0201]  157.37 170.65 270 bottom
R22022  10K_1%_2  [R0201]  122.7 122.77 180 bottom
R22023  10K_1%_2  [R0201]  129.31 130.27 0 bottom
R22024  10K_1%_2  [R0201]  122.58 154.4 180 bottom
R22025  10K_1%_2  [R0201]  130.32 144.49 270 bottom
R22029  *Short_0402  [S0402]  340 60.42 90 top
R22031  *10K_1%_2  [R0201]  340 58.67 90 top
R22032  *Short_0603  [S0603]  341.9 62.96 0 bottom
R22035  *Short_0603  [S0603]  358.41 61.56 270 bottom
R22048  *4.7K_1%_4  [R0402]  30.5 53.94 270 top
R22050  *WIGIG@0_5%_4  [R0402]  310.41 48.99 270 bottom
R22060  1K_1%_4  [R0402]  20.34 33.11 270 bottom
R22061  *Short_0402  [S0402]  186.3 70.15 270 bottom
R22062  *Short_0402  [S0402]  187.27 70.15 270 bottom
R22063  15_1%_4  [R0402]  326.54 62.07 90 bottom
R22064  *Short_0402  [S0402]  324.51 62.07 90 bottom
R22065  *Short_0402  [S0402]  325.52 62.07 90 bottom
R22066  15_1%_4  [R0402]  329.97 62.07 90 bottom
R22067  15_1%_4  [R0402]  325.9 69.69 90 bottom
R22068  100K_1%_4  [R0402]  353.84 89.63 90 bottom
R22069  1K_1%_4  [R0402]  352.83 89.63 90 bottom
R22070  100K_1%_4  [R0402]  355.11 81.25 270 bottom
R22071  33_1%_2  [R0201]  353.13 81.32 270 bottom
R22073  *Short_0603  [S0603]  258.08 171.16 270 top
R22083  22_1%_4  [R0402]  35.07 35.09 0 top
R22084  *Short_0402  [S0402]  35.38 33.67 270 top
R22087  100K_1%_4  [R0402]  32.38 31.82 270 bottom
R22088  *Short_0402  [S0402]  34.51 32.43 180 bottom
R22089  *SUB@0_5%_4  [R0402]  36.98 51.91 270 bottom
R22090  *Short_0402  [S0402]  23.26 33.49 90 bottom
R22091  *0_5%_4  [R0402]  22.96 31.46 180 bottom
R22092  100K_1%_4  [R0402]  32.3 29.68 270 bottom
R22093  100K_1%_4  [R0402]  27.3 23.92 0 bottom
R22095  *Short_0402  [S0402]  345.44 75.26 180 bottom
R22096  *Short_0402  [S0402]  343.26 75.26 180 bottom
R22097  WIGIG@0_5%_4  [R0402]  56.92 71.77 0 bottom
R22100  2.2K_5%_4  [R0402]  367.76 39.51 90 top
R22101  2.2K_5%_4  [R0402]  364.74 41.72 90 top
R22118  6.2_1%_2  [R0201]  218.08 167.86 90 top
R22119  6.2_1%_2  [R0201]  218.84 167.86 90 top
R22120  6.2_1%_2  [R0201]  220.49 167.86 90 top
R22121  6.2_1%_2  [R0201]  221.25 167.86 90 top
R22122  6.2_1%_2  [R0201]  223.03 167.99 90 top
R22123  6.2_1%_2  [R0201]  223.92 167.99 90 top
R22124  6.2_1%_2  [R0201]  225.45 167.99 90 top
R22125  6.2_1%_2  [R0201]  226.33 167.99 90 top
R22126  *Short_0201  [S0201]  231.92 170.27 90 bottom
R22128  499_1%_2  [R0201]  218.08 168.04 270 bottom
R22129  499_1%_2  [R0201]  218.84 168.04 270 bottom
R22130  499_1%_2  [R0201]  220.49 168.04 270 bottom
R22131  499_1%_2  [R0201]  221.25 168.04 270 bottom
R22132  499_1%_2  [R0201]  223.03 168.16 270 bottom
R22133  499_1%_2  [R0201]  223.92 168.16 270 bottom
R22134  499_1%_2  [R0201]  225.45 168.16 270 bottom
R22135  499_1%_2  [R0201]  226.33 168.16 270 bottom
R22136  *Short_0201  [S0201]  257.96 171.03 180 bottom
R22137  100K_1%_4  [R0402]  216.68 166.21 270 bottom
R22138  10K_1%_2  [R0201]  57.83 75.71 90 bottom
R22139  *Short_0402  [S0402]  57.55 78.2 270 bottom
R22140  1K_1%_4  [R0402]  47.26 75.66 90 top
R22141  10K_1%_2  [R0201]  52.06 76.95 90 bottom
R22143  *Short_0402  [S0402]  86.43 80.18 180 top
R22145  *0_5%_4  [R0402]  189.63 69.92 90 bottom
R22146  *Short_0402  [S0402]  190.77 69.94 90 bottom
R22147  499_1%_2  [R0201]  352.83 48.28 270 bottom
R22148  499_1%_2  [R0201]  270.2 127.07 270 top
R22150  M_PB@33_1%_2  [R0201]  377.57 14.37 90 bottom
R22154  *Short_0603  [S0603]  128.8 64.61 90 top
R22155  4.7K_1%_4  [R0402]  196.87 66.51 180 top
R22156  4.7K_1%_4  [R0402]  196.87 67.53 180 top
R22159  *Short_0402  [S0402]  15.26 11.65 90 top
R22163  *CLK@4.7K_1%_4  [R0402]  32.02 61.89 0 top
R22164  CLK@1K_1%_4  [R0402]  34.64 62.22 180 top
R22166  CLK@1K_1%_4  [R0402]  45.99 59.15 0 top
R22167  CLK@2.2K_5%_4  [R0402]  34.03 53.48 0 top
R22168  CLK@2.2K_5%_4  [R0402]  45.11 53.94 180 top
R22169  CLK@33_1%_2  [R0201]  45.11 56.99 180 top
R22170  CLK@33_1%_2  [R0201]  45.11 56.1 180 top
R22171  CLK@2.2_1%_6  [R0603]  46.35 61.56 180 top
R22185  CLK@475_1%_4  [R0402]  45.99 60.29 180 top
R22187  CLK@49.9_1%_2  [R0201]  47.65 56.1 0 top
R22188  CLK@49.9_1%_2  [R0201]  47.65 57.12 0 top
R22191  *CLK@Short_0402  [S0402]  32.02 57.5 180 top
R22192  CLK@33_1%_2  [R0201]  33.93 55.72 0 top
R22193  CLK@33_1%_2  [R0201]  33.93 54.96 0 top
R22194  CLK@49.9_1%_2  [R0201]  32.02 54.96 180 top
R22195  CLK@49.9_1%_2  [R0201]  32.02 55.72 180 top
R22198  *0_5%_4  [R0402]  44.55 23.08 270 bottom
R22199  *0_5%_4  [R0402]  45.54 23.08 270 bottom
R22200  *Short_0402  [S0402]  44.46 23.08 90 top
R22201  *Short_0402  [S0402]  45.45 23.08 90 top
R22202  *0_5%_4  [R0402]  68.52 28.08 180 bottom
R22203  *0_5%_4  [R0402]  68.52 29.2 180 bottom
R22204  *Short_0402  [S0402]  66.44 28.08 180 bottom
R22205  *Short_0402  [S0402]  66.44 29.2 180 bottom
R22206  *Short_0402  [S0402]  32.02 59.78 0 top
R22207  *Short_0402  [S0402]  32.02 60.93 0 top
R22208  *CLK@0_5%_4  [R0402]  34.06 60.93 0 top
R22209  *CLK@0_5%_4  [R0402]  34.06 59.78 0 top
R22210  CLK@1K_1%_4  [R0402]  34.06 58.82 0 top
R22211  *CLK@0_5%_4  [R0402]  48.03 59.15 0 top
R22212  *CLK@10K_1%_2  [R0201]  49.73 59.15 0 top
R22213  *CLK@0_5%_4  [R0402]  32.02 58.64 0 top
R22214  *CLK@10K_1%_2  [R0201]  30.5 58.13 270 top
R67012  10K_1%_2  [R0201]  17.42 31.92 180 bottom
R67013  4.7K_1%_4  [R0402]  21 28.54 270 top
R67014  499_1%_2  [R0201]  15.64 26.25 0 bottom
R67015  22_1%_4  [R0402]  15.06 26.25 0 top
R67016  4.7K_1%_4  [R0402]  11.7 31.92 90 top
R67017  4.7K_1%_4  [R0402]  15.67 31.56 270 top
R67018  2.2K_5%_4  [R0402]  18.05 14.67 90 top
R67019  2.2K_5%_4  [R0402]  19.68 14.57 90 top
R67022  N-Tobii@10K_1%_2  [R0201]  322.85 61.05 180 top
R67023  374_1%_4  [R0402]  377.9 9.69 270 bottom
R67024  *0_5%_4  [R0402]  378.28 7.23 90 bottom
R67025  P_KB@0_5%_4  [R0402]  266.49 47.9 0 top
R67027  4.7K_1%_4  [R0402]  375.64 17.95 0 top
R67028  4.7K_1%_4  [R0402]  372.97 15.76 180 top
R67029  *Short_0402  [S0402]  374.8 5.78 180 bottom
R67030  *Short_0402  [S0402]  374.8 6.75 180 bottom
R67031  *Short_0402  [S0402]  376.65 5.83 0 bottom
R67035  *0_5%_4  [R0402]  379.24 5.79 90 top
R67038  *Short_0402  [S0402]  181.73 64.08 90 bottom
R67039  *0_5%_4  [R0402]  182.77 59.02 90 bottom
R67041  *0_5%_6  [R0603]  359.94 61.56 270 bottom
R67042  *0_5%_6  [R0603]  345.59 63.97 270 bottom
R67043  1M_1%_4  [R0402]  355.87 57.75 90 bottom
R67044  1M_1%_4  [R0402]  356.31 56.4 0 bottom
R67045  100K_1%_4  [R0402]  347.09 63.82 270 top
R67046  100K_1%_4  [R0402]  345.33 56.86 0 bottom
R67047  100K_1%_4  [R0402]  347.37 61.43 270 bottom
R67048  100K_1%_4  [R0402]  343.56 56.1 0 bottom
R67049  *10K_1%_2  [R0201]  335.05 65.71 90 top
R67050  *Short_0402  [S0402]  334.03 65.88 270 top
R67051  *10K_1%_2  [R0201]  348.38 61.43 90 bottom
R67053  *10K_1%_2  [R0201]  345.33 61.43 90 bottom
R67054  *100K_1%_4  [R0402]  350.41 61.43 270 top
R67055  *10K_1%_2  [R0201]  352.57 61.43 90 bottom
R67056  *10K_1%_2  [R0201]  354.6 61.43 90 bottom
R67072  OP@0_5%_4  [R0402]  309.39 48.99 270 bottom
R67084  *Short_0201  [S0201]  369.21 24.22 180 bottom
R67112  3.32K_1%_4  [R0402]  365.01 36.41 180 bottom
R67115  82D@10K_1%_2  [R0201]  370.66 33.49 270 bottom
R67116  82D@1M_1%_4  [R0402]  366.42 18.97 270 top
R67117  *Short_0201  [S0201]  364.76 25.24 270 bottom
R67118  1M_1%_4  [R0402]  367.56 18.97 90 top
R67119  1M_1%_4  [R0402]  368.7 18.97 90 top
R67121  100K_1%_4  [R0402]  365.4 33.49 270 bottom
R67122  100K_1%_4  [R0402]  371.24 25.24 0 bottom
R67123  100K_1%_4  [R0402]  371.37 23.21 0 bottom
R67124  100K_1%_4  [R0402]  373.7 31.92 270 top
R67125  100K_1%_4  [R0402]  373.15 21.05 90 top
R67126  100K_1%_4  [R0402]  372.13 21.05 90 top
R67127  100K_1%_4  [R0402]  371.11 21.05 90 top
R67128  15K_0.1%_4  [R0402]  368.7 21.05 90 top
R67131  10K_1%_2  [R0201]  372.23 17.16 180 bottom
R67132  10K_1%_2  [R0201]  365.27 21.05 270 bottom
R67133  *10K_1%_2  [R0201]  365.15 21.05 90 top
R67134  3.32K_1%_4  [R0402]  365.01 35.4 180 bottom
R67136  100K_1%_4  [R0402]  366.42 25.49 90 bottom
R67137  *Short_0201  [S0201]  368.45 30.37 180 bottom
R67138  *Short_0201  [S0201]  366.29 27.78 90 bottom
R67139  10K_1%_2  [R0201]  366.42 21.05 270 bottom
R67140  10K_1%_2  [R0201]  367.56 21.05 270 bottom
R67141  *Short_0201  [S0201]  367.3 33.11 90 bottom
R67144  *100K_1%_4  [R0402]  368.62 33.49 270 bottom
R67145  *10K_1%_2  [R0201]  369.64 33.49 90 bottom
R67146  Tobii@0_5%_4  [R0402]  29.61 77.31 270 top
R67147  Tobii@0_5%_4  [R0402]  30.63 77.31 270 top
R67148  100K_1%_4  [R0402]  322.35 75.4 180 top
R67149  *2.2K_5%_4  [R0402]  341.78 58.51 0 top
R67150  *2.2K_5%_4  [R0402]  347.37 63.59 270 bottom
R67151  *2.2K_5%_4  [R0402]  344.19 61.38 90 bottom
R67152  *2.2K_5%_4  [R0402]  343.17 61.38 90 bottom
R67153  10K_1%_2  [R0201]  351.4 61.43 270 top
R67154  *0_5%_4  [R0402]  353.69 59 180 bottom
R67156  *Short_0201  [S0201]  353.59 61.43 270 bottom
R67157  *0_5%_4  [R0402]  349.4 61.43 270 top
R67158  10K_1%_2  [R0201]  350.41 61.43 90 bottom
R67159  *Short_0402  [S0402]  373.53 36.8 270 bottom
R67160  *Short_0402  [S0402]  372.38 36.8 270 bottom
R67161  *Short_0402  [S0402]  374.67 36.8 270 bottom
R67162  *Short_0402  [S0402]  375.81 36.8 270 bottom
R67163  *0_5%_4  [R0402]  307.66 70.32 270 bottom
R67164  *Short_0402  [S0402]  181.22 56.81 180 bottom
R67166  *Short_0402  [S0402]  181.66 55.85 180 bottom
R67167  *Short_0402  [S0402]  375.87 12.8 90 top
R67168  *Short_0402  [S0402]  375.88 14.87 90 top
R67169  *Short_0402  [S0402]  372.74 9.97 90 bottom
R67170  *Short_0402  [S0402]  373.78 12.82 90 top
R67171  *Short_0402  [S0402]  372.76 12.82 90 top
R67172  *0_5%_4  [R0402]  320.06 47.82 270 top
R67173  *Short_0402  [S0402]  374.79 12.79 90 top
R67174  *Short_0402  [S0402]  361.61 38.9 180 top
R67175  *4.7K_1%_4  [R0402]  373.63 18.89 270 bottom
R67176  *Short_0402  [S0402]  373.53 17.11 270 bottom
R67179  10K_1%_2  [R0201]  366.42 33.49 90 bottom
R67180  *10K_1%_2  [R0201]  365.27 19.27 270 top
R67185  82D@1M_1%_4  [R0402]  364.38 33.49 90 bottom
R67186  1K_1%_4  [R0402]  22.27 23.03 270 top
R67187  1K_1%_4  [R0402]  22.12 24.88 270 top
R67188  *1K_1%_4  [R0402]  272.99 110.96 90 top
R67190  10K_1%_2  [R0201]  347.92 68.67 180 bottom
R67191  *10K_1%_2  [R0201]  347.92 69.69 0 bottom
R67192  *0_5%_2  [R0201]  345.84 63.47 90 top
R67193  10K_1%_2  [R0201]  355.62 61.43 90 bottom
R67195  *0_5%_4  [R0402]  210.31 63.08 0 bottom
R67196  *Short_0402  [S0402]  208.86 73.68 0 bottom
R67197  *0_5%_4  [R0402]  210.23 74.08 270 bottom
R67199  *0_5%_4  [R0402]  291.74 85.44 0 bottom
R67200  121_1%_4  [R0402]  139.06 172.43 90 bottom
R67201  121_1%_4  [R0402]  122.96 141.16 270 bottom
R67202  10K_1%_2  [R0201]  20.75 17.75 180 bottom
R67203  10K_1%_2  [R0201]  20.72 18.48 180 bottom
R67204  *0_5%_4  [R0402]  17.04 13.31 0 top
R67205  *0_5%_4  [R0402]  17.62 10.95 0 top
R67206  47_1%_4  [R0402]  16.66 14.82 180 top
R67207  47_1%_4  [R0402]  17.04 12.34 180 top
R67208  *Short_0603  [S0603]  300.4 48.86 270 bottom
R67211  *Short_0603  [S0603]  317.39 48.35 90 bottom
R67212  *0_5%_2  [R0201]  299.61 78.3 0 top
R67213  *Short_0402  [S0402]  294.51 80 0 top
R67214  *10K_1%_2  [R0201]  295.9 80 0 top
R67215  *0_5%_2  [R0201]  302.13 79.34 0 top
R67216  *0_5%_2  [R0201]  302.79 78.45 90 top
R67217  *0_5%_2  [R0201]  329.38 70.25 0 bottom
R67218  *Short_0201  [S0201]  329.38 70.96 180 bottom
R67220  *Short_0402  [S0402]  343.61 63.72 90 top
R67221  Max-P@10K_1%_2  [R0201]  322.85 62.07 0 top
R67223  N-GS@10K_1%_2  [R0201]  322.86 63.07 180 bottom
R67224  OP@10K_1%_2  [R0201]  317.65 61.69 0 top
R67225  GS@10K_1%_2  [R0201]  322.86 62.07 0 bottom
R67226  Max-Q@10K_1%_2  [R0201]  322.85 63.08 180 top
R67227  DIS@10K_1%_2  [R0201]  319.68 62.07 0 top
R67228  WIGIG@2.2K_5%_4  [R0402]  312.44 48.99 90 bottom
R67229  *2.2K_5%_4  [R0402]  307.69 51.38 90 bottom
R67230  100K_1%_4  [R0402]  316.71 50.64 270 bottom
R67231  *1K_1%_4  [R0402]  317.14 52.47 270 bottom
R67232  100K_1%_4  [R0402]  322.47 52.62 90 top
R67233  OP@1M_1%_4  [R0402]  323.11 56.68 180 top
R67234  100K_1%_4  [R0402]  326.56 55.57 0 top
R67235  OP@1M_1%_4  [R0402]  329.46 60.01 90 top
R67236  1K_1%_4  [R0402]  288.03 75.61 0 bottom
R67237  1K_1%_4  [R0402]  288.03 76.6 0 bottom
R67238  WIGIG@0_5%_2  [R0201]  310 77.92 90 top
R67239  *10K_1%_2  [R0201]  302.03 80.61 90 top
R67240  10K_1%_2  [R0201]  327.17 67.53 270 bottom
R67241  10K_1%_2  [R0201]  313.2 65.88 0 bottom
R67242  *10K_1%_2  [R0201]  319.81 62.83 0 bottom
R67243  10K_1%_2  [R0201]  325.52 60.29 90 bottom
R67245  *100K_1%_4  [R0402]  322.85 47.84 0 top
R67246  1.5K_1%_2  [R0201]  47.9 71.72 90 top
R67247  45.3K_1%_4  [R0402]  47.9 73.5 90 top
R67248  DIS@100K_1%_4  [R0402]  338.01 74.7 270 bottom
R67249  *0_5%_4  [R0402]  333.9 64.41 0 top
R67250  *Short_0402  [S0402]  332.15 64.41 180 top
R67251  *Short_0805  [S0805]  364.74 36.62 90 top
R67255  *Short_0402  [S0402]  309.52 76.29 270 bottom
R67257  *10K_1%_2  [R0201]  311.32 77.74 180 bottom
R67258  *Short_0402  [S0402]  122.96 66.64 0 top
R67259  *Short_0402  [S0402]  123.34 63.62 180 top
R67260  10K_1%_2  [R0201]  17.93 16.88 90 bottom
R67261  10K_1%_2  [R0201]  20.72 16.73 90 bottom
R67262  *100K_1%_4  [R0402]  16.4 8.09 180 bottom
R67263  100K_1%_4  [R0402]  17.8 9.36 180 bottom
R67264  *Short_0402  [S0402]  181.4 58.26 0 bottom
R67265  *0_5%_4  [R0402]  371.52 18.48 90 top
R67266  *0_5%_4  [R0402]  359.3 38.75 0 top
R67267  4.7K_1%_4  [R0402]  31.77 74.74 90 top
R67268  4.7K_1%_4  [R0402]  32.94 73.58 270 top
R67269  68.1K_1%_4  [R0402]  34.61 73.98 180 top
R67270  150K_1%_4  [R0402]  36.01 73.55 90 top
R67271  *Short_0402  [S0402]  309.7 77.72 180 bottom
R67272  *Short_0402  [S0402]  309.85 73.63 270 bottom
R67273  *10K_1%_2  [R0201]  309.34 81.5 270 bottom
R67274  *0_5%_4  [R0402]  121.41 65.09 180 bottom
R67275  *Short_0402  [S0402]  120.8 66.64 180 top
R67276  *0_5%_4  [R0402]  121.41 64.08 180 bottom
R67277  *Short_0402  [S0402]  121.43 63.62 180 top
R67278  *100_1%_2  [R0201]  64.76 22.83 270 bottom
R67280  *100_1%_2  [R0201]  41.8 30.78 180 top
R67281  33_1%_2  [R0201]  136.55 64.35 90 top
R67285  *10K_1%_2  [R0201]  40.46 31.44 270 top
R67290  10K_1%_2  [R0201]  39.14 30.95 270 top
R67291  *0_5%_2  [R0201]  178 60.34 180 bottom
R67293  *100K_1%_4  [R0402]  26.44 54.45 0 bottom
R67294  Macro@0_5%_2  [R0201]  192.81 61.43 0 bottom
R67295  *N-Macro@Short_0201  [S0201]  193.82 61.43 180 bottom
R67299  *M_KB@0_5%_4  [R0402]  127.87 51.55 180 bottom
R67300  M_KB@10K_1%_2  [R0201]  126.41 49.98 270 bottom
R67302  M_KB@10K_1%_2  [R0201]  127.48 52.52 180 bottom
R67303  10K_1%_2  [R0201]  378.55 11.27 270 top
R67304  30K_1%_4  [R0402]  349.17 66.62 180 top
R67306  *Short_0201  [S0201]  176.55 59.91 0 top
R67308  *0_5%_4  [R0402]  126.39 113 180 top
R67309  *Short_0603  [S0603]  121.43 121.28 180 top
R67310  *0_5%_4  [R0402]  17.61 9.86 0 top
R67311  *Short_0603  [S0603]  142.64 55.34 0 bottom
R67312  33_1%_2  [R0201]  188.49 60.29 0 bottom
R67313  *Short_0201  [S0201]  193.52 59.53 180 bottom
R67314  *0_5%_2  [R0201]  181.83 71.82 270 top
R67315  *Short_0201  [S0201]  182.6 71.82 270 top
R67319  *100K_1%_4  [R0402]  196.24 53.28 270 bottom
R67320  *Short_0402  [S0402]  124.1 113 180 bottom
R67321  *0_5%_4  [R0402]  124.07 113.96 180 bottom
R67322  *Short_0402  [S0402]  197.2 53.28 90 bottom
R67323  *0_5%_4  [R0402]  127.15 108.8 180 bottom
R67325  *0_5%_4  [R0402]  128.16 113.63 0 bottom
R67326  *Short_0402  [S0402]  126.39 113.63 180 bottom
R67327  *Short_0402  [S0402]  130.7 111.85 0 bottom
R67328  10K_1%_2  [R0201]  16.02 20.16 0 bottom
R67331  80@10K_1%_2  [R0201]  139.09 117.19 0 bottom
R67332  *0_5%_2  [R0201]  191.41 54.45 180 bottom
R67333  *0_5%_2  [R0201]  178.84 65.12 0 bottom
R67334  *Short_0201  [S0201]  178.84 64.35 0 bottom
R67335  *0_5%_2  [R0201]  188.36 61.31 90 bottom
R67336  *Short_0402  [S0402]  15.67 24.58 0 bottom
R67337  *0_5%_4  [R0402]  14.73 22.17 270 bottom
R67338  *0_5%_4  [R0402]  16.83 33.27 90 bottom
R67339  *Short_0402  [S0402]  135.78 60.04 180 bottom
R67340  *0_5%_4  [R0402]  135.78 61.18 180 bottom
R67341  *0_5%_4  [R0402]  192.68 64.99 270 bottom
R67342  *0_5%_4  [R0402]  17.9 33.27 90 bottom
R67349  SUB@0.1_1%_8  [R0805]  80.64 41.93 90 top
R67350  SUB@0.1_1%_8  [R0805]  78.58 40.73 270 top
R67351  *SUB@0_5%_4  [R0402]  28.52 43.76 0 bottom
R67352  SUB@0_5%_4  [R0402]  24.86 37.96 0 top
R67353  SUB@0_5%_4  [R0402]  31.59 43.7 270 bottom
R67354  *Short_0402  [S0402]  40.81 29.25 0 bottom
R67355  *Short_0402  [S0402]  40.81 28.19 0 bottom
R67356  *Short_0402  [S0402]  62.02 22.72 270 bottom
R67357  *Short_0402  [S0402]  63.88 22.72 270 bottom
R67358  HDD@0_5%_4  [R0402]  71.95 24.5 180 bottom
R67359  HDD@0_5%_8  [R0805]  41.3 41.44 180 top
R67362  HDD@0_5%_2  [R0201]  69.84 26.97 180 bottom
R67363  HDD@0_5%_2  [R0201]  69.84 26.15 180 bottom
R67364  180W@10K_1%_2  [R0201]  181.48 70.04 270 bottom
R67365  230W@10K_1%_2  [R0201]  182.39 70.04 90 bottom
R67366  10K_1%_2  [R0201]  181.45 73.7 270 top
R67367  *Short_0201  [S0201]  180.51 73.7 270 top
R67368  *Short_0402  [S0402]  15.72 7.74 90 top
R67369  *Short_0402  [S0402]  376.37 17.19 0 bottom
R67370  *0_5%_4  [R0402]  376.12 18.15 0 bottom
R67373  SUB@2.2K_5%_4  [R0402]  31.69 45.38 0 bottom
R67374  SUB@2.2K_5%_4  [R0402]  31.57 48.68 180 bottom
R67376  SUB@33_1%_2  [R0201]  37.13 49.78 270 bottom
R67377  SUB@33_1%_2  [R0201]  36.11 49.78 270 bottom
R67378  SUB@33_1%_2  [R0201]  38.2 49.78 270 bottom
R67379  SUB@33_1%_2  [R0201]  39.24 49.78 270 bottom
R67380  *Short_0201  [S0201]  128.7 112.89 270 top
R67381  DIS@4.7K_1%_4  [R0402]  339.04 73.17 90 bottom
R67382  4.7K_1%_4  [R0402]  337.38 52.44 0 top
R67385  *Short_0201  [S0201]  364.71 41.6 90 bottom
R67386  4.7K_1%_4  [R0402]  378.68 5.88 0 bottom
R67388  10K_1%_2  [R0201]  27.53 20.74 180 bottom
R67389  *Short_0402  [S0402]  379.37 11.14 180 bottom
R67391  *Short_0603  [S0603]  372.69 12.16 270 bottom
R67392  *0_5%_6  [R0603]  365.25 38.37 270 bottom
R67393  *Short_0402  [S0402]  367.99 37.94 90 bottom
R67394  *Short_0201  [S0201]  177.08 58.31 180 bottom
R67395  *NVSR@Short_0201  [S0201]  128.8 117.34 180 bottom
R67396  *DIS@4.7K_1%_4  [R0402]  338.08 72.84 90 bottom
R67397  *4.7K_1%_4  [R0402]  337.7 53.28 270 bottom
R67398  *Short_0402  [S0402]  358.17 43.39 270 bottom
R67401  *M_KB@Short_0402  [S0402]  121.15 61.38 270 bottom
R67402  *M_KB@Short_0603  [S0603]  127.91 58.26 0 bottom
R67403  *0_5%_2  [R0201]  360.93 39.97 90 bottom
R67404  *0_5%_2  [R0201]  358.11 40.2 270 bottom
R67405  *1K_1%_4  [R0402]  322.09 70.45 0 bottom
R67406  *1K_1%_4  [R0402]  322.09 71.47 0 bottom
R67407  *Short_0201  [S0201]  361.77 40.43 270 bottom
R67408  *Short_0201  [S0201]  358.92 38.45 90 bottom
RP1  *P_KB@10K_4_10P8R  [10P8R]  233.45 49.37 0 bottom
SPAD1  *pad-zgl-gddr5x-1  [PAD-ZGL-GDDR5X-1]  123.7 181.4 0 top
SPAD2  *spad-c315np  [SPAD-C315NP]  202.5 81.5 0 top
SPAD3  *spad-re217x138np  [SPAD-RE217X138NP]  384.25 36.28 180 bottom
SPAD4  *SPAD-RE217X94NP  [SPAD-RE217X94NP]  384.25 51.34 180 bottom
SPAD5  *spad-c315np  [SPAD-C315NP]  273.5 136 180 bottom
SPAD6  *spad-re256x118np  [SPAD-RE256X118NP]  3.25 50 180 bottom
SPAD7  *spad-re157x315np  [SPAD-RE157X315NP]  187.5 177 180 bottom
SPAD8  *spad-re276x197np  [SPAD-RE276X197NP]  224.51 179.5 180 bottom
SPAD9  *spad-re236x152np  [SPAD-RE236X152NP]  247.5 180.06 180 bottom
SPAD10  *spad-c315np  [SPAD-C315NP]  273.5 136 0 top
SPAD11  *spad-re354x103np  [SPAD-RE354X103NP]  326 81.7 180 bottom
SPAD12  *spad-re669x197np  [SPAD-RE669X197NP]  353 85.5 180 bottom
SPAD13  *spad-c197np  [SPAD-C197NP]  368.66 62.72 180 bottom
SPAD14  *SPAD-RE217X94NP  [SPAD-RE217X94NP]  384.25 51.34 0 top
SPAD15  *spad-re79x157np  [SPAD-RE79X157NP]  385.5 43.5 180 bottom
SPAD16  *spad-re217x138np  [SPAD-RE217X138NP]  384.25 36.28 0 top
SPAD17  *spad-zgl-gddr5x-2  [SPAD-ZGL-GDDR5X-2]  373.5 28.55 180 bottom
SPAD18  *spad-re315x59np  [SPAD-RE315X59NP]  251.5 43.55 180 bottom
SPAD19  *spad-re787x59np  [SPAD-RE787X59NP]  216.5 43.55 180 bottom
SPAD20  *spad-c315np  [SPAD-C315NP]  202.5 81.5 180 bottom
SPAD21  *SPAD-RE1024X59NP  [SPAD-RE1024X59NP]  145.5 46.55 180 bottom
SPAD22  *spad-re59x276np  [SPAD-RE59X276NP]  77.25 30.5 180 bottom
SPAD23  *spad-re236x148np  [SPAD-RE236X148NP]  21.5 5.12 180 bottom
SPAD24  *spad-re256x118np  [SPAD-RE256X118NP]  3.25 50 0 top
SPAD25  *spad-re472x59np  [SPAD-RE472X59NP]  49.5 83.25 180 bottom
SPAD26  *spad-re256x118np  [SPAD-RE256X118NP]  3.25 31.5 180 bottom
SPAD27  *spad-re256x118np  [SPAD-RE256X118NP]  3.25 31.5 0 top
SPAD28  *SPAD-RE157X355NP  [SPAD-RE157X355NP]  378.51 22.11 270 bottom
SW1  T3AL-23S-Q-T/R  [SW-T3AL-23-Q-TR-4P]  27.5 57 0 bottom
SW3  M_PB@PWR_BUTTON  [SW-MLC-63WQR-4P]  381.8 15.6 90 top
T3  *TP  [TP2050]  221.51 127.63 0 top
T4  *TP  [TP2050]  269.67 111.85 0 top
T7  *TP  [TP2050]  261.89 125.92 180 bottom
T8  *TP  [TP2050]  273.07 141.62 180 bottom
T9  *TP  [TP2050]  260.27 114.06 180 bottom
T10  *TP  [TP2050]  262.12 113.58 180 bottom
T11  *TP  [TP2050]  261.51 115.66 180 bottom
T12  *TP  [TP2050]  263.6 115.64 180 bottom
T13  *TP  [TP2050]  262.88 120.82 180 bottom
T14  *TP  [TP2050]  260.78 120.41 180 bottom
T15  *TP  [TP2050]  260.37 127.07 180 bottom
T16  *TP  [TP2050]  260.42 125.8 180 bottom
T17  *TP  [TP2050]  222.93 96.77 180 bottom
T18  *TP  [TP2050]  224.76 96.89 180 bottom
T19  *TP  [TP2050]  222.96 98.24 180 bottom
T20  *TP  [TP2050]  224.73 98.31 180 bottom
T21  *TP  [TP2050]  264.89 98.95 180 bottom
T22  *TP  [TP2050]  264.23 100.12 180 bottom
T23  *TP  [TP2050]  264.54 114.32 180 bottom
T24  *TP  [TP2050]  263.16 114.37 180 bottom
T25  *TP  [TP2050]  250.54 112.54 180 bottom
T26  *TP  [TP2050]  253.94 113.25 180 bottom
T27  *TP  [TP2050]  252.57 113.07 180 bottom
T28  *TP  [TP2050]  254.4 111.93 180 bottom
T29  *TP  [TP2050]  334.79 50.38 0 bottom
T30  *TP  [TP2050]  335.94 57.5 0 bottom
T31  *TP  [TP2050]  336.06 56.23 0 bottom
T32  *TP  [TP2050]  334.03 60.52 180 top
T33  *TP  [TP2050]  336.06 50.38 0 bottom
T56  *TP  [TP2050]  335.71 69.92 0 bottom
T57  *TP  [TP2050]  335.6 70.02 180 top
T58  *TP  [TP2050]  336.42 76.45 0 bottom
T59  *TP  [TP2050]  336.72 74.18 0 bottom
T60  *TP  [TP2050]  334.89 78.86 180 top
T61  *TP  [TP2050]  234.61 55.54 180 bottom
T62  *TP  [TP2050]  235.12 62.3 180 bottom
T63  *TP  [TP2050]  235.02 67.5 180 bottom
T64  *TP  [TP2050]  235 74.95 180 bottom
T71  *TP  [TP2050]  304.31 55.06 180 bottom
T72  *TP  [TP2050]  304.34 56.81 180 bottom
T76  *TP  [TP2050]  304.44 80.05 0 top
T77  *TP  [TP2050]  304.31 69.94 180 bottom
T78  *TP  [TP2050]  310.89 60.6 180 bottom
T91  *TP  [TP2050]  368.62 32.45 0 top
T92  *TP  [TP2050]  368.12 24.78 180 bottom
T93  *TP  [TP2050]  368.19 26.51 180 bottom
T96  *TP  [TP2050]  367.56 29.81 180 bottom
T9005  *TP  [TP2650]  262.58 169.49 0 top
T9006  *TP  [TP2650]  263.88 169.43 0 top
T9007  *TP  [TP2650]  265.15 169.44 0 top
T9008  *TP  [TP2650]  127.27 71.47 180 bottom
T9009  *TP  [TP2050]  268.98 113.83 0 top
T9010  *TP  [TP2050]  270.12 113.22 0 top
T9011  *TP  [TP2050]  263.67 119.57 180 bottom
T9012  *TP  [TP2050]  264.94 120.01 180 bottom
T9013  *TP  [TP2050]  265.91 118.99 180 bottom
T9014  *TP  [TP2050]  264.31 118.41 180 bottom
T9015  *TP  [TP2050]  265.96 122.32 180 bottom
T9016  *TP  [TP2050]  265.63 123.56 180 bottom
T9017  *TP  [TP2050]  261.64 124.65 180 bottom
T9018  *TP  [TP2050]  264.56 126.08 180 bottom
T9019  *TP  [TP2050]  264.94 121.5 180 bottom
T9020  *TP  [TP2050]  262.91 124.55 180 bottom
T9021  *TP  [TP2050]  265.98 120.77 180 bottom
T9022  *TP  [TP2050]  271.57 113.94 0 top
T9023  *TP  [TP2050]  311.93 58.39 180 bottom
T9024  *TP  [TP2050]  299.49 77.44 0 top
T9025  *TP  [TP2050]  301.65 76.42 180 bottom
T9028  *TP  [TP2050]  192.98 60.6 180 bottom
T9029  *TP  [TP2050]  176.83 53.1 0 top
T9030  *TP  [TP2050]  181.84 69.76 0 top
T9031  *TP  [TP2050]  195.64 56.93 0 top
T9032  *TP  [TP2050]  176.55 57.75 0 top
T9033  *TP  [TP2050]  180.96 71.98 0 top
T9034  *TP  [TP2050]  121.97 60.98 180 bottom
T9035  *TP  [TP2050]  126.18 60.93 180 bottom
T9036  *TP  [TP2050]  122.65 62.25 180 bottom
TP1  *TP  [TP2075]  64 51.76 0 top
TP61  *PAD  [ESD-6X3]  373.58 65.43 0 top
TP62  *PAD  [ESD-6X6]  13.36 39.61 90 top
TP63  *PAD  [ESD-6X6]  373.58 65.96 270 top
TP64  *PAD  [ESD-6X3]  373.76 59.67 0 top
TP65  *PAD  [ESD-6X6]  373.58 65.18 90 top
TP66  *PAD  [ESD-6X3]  373.58 65.7 0 top
TP67  *PAD  [ESD-6X3]  373.76 59.4 0 top
TP68  *PAD  [ESD-6X6]  373.76 59.92 270 top
TP69  *PAD  [ESD-6X3]  373.5 55.21 0 top
TP70  *PAD  [ESD-6X6]  373.76 59.15 90 top
TP71  *PAD  [ESD-6X3]  373.5 55.48 0 top
TP72  *PAD  [ESD-6X6]  373.5 55.73 270 top
TP13075  *TP  [TP2050]  308.37 59.47 180 bottom
TP13076  *TP  [TP2050]  308.38 58 180 bottom
TP13078  *TP  [TP2050]  313.33 59.02 180 bottom
TP13083  *TP  [TP2050]  294.15 57.24 180 bottom
TP13084  *TP  [TP2050]  292.68 56.43 180 bottom
TP13085  *TP  [TP2050]  298.72 57.62 180 bottom
TP13086  *TP  [TP2050]  298.85 56.35 180 bottom
TP13087  *TP  [TP2050]  315.11 62.2 180 bottom
TP13088  *TP  [TP2050]  317.16 75.1 0 top
TP13089  *TP  [TP2050]  319.45 75.02 0 top
TP13090  *TP  [TP2050]  310.92 78.15 0 top
TP13091  *TP  [TP2050]  309.06 78.15 0 top
TP13093  *TP  [TP2050]  313 54.98 180 bottom
TP13094  *TP  [TP2050]  317.11 51.83 0 top
TP13100  *TP  [TP2050]  34.69 28.16 0 top
TP13101  *TP  [TP2050]  156.48 112.74 180 bottom
TP13102  *TP  [TP2050]  124.4 101.77 0 top
TP13103  *TP  [TP2050]  127.68 96.97 0 top
TP13104  *TP  [TP2050]  132.74 106.9 0 top
TP13105  *TP  [TP2050]  132.4 102.84 0 top
TP13106  *TP  [TP2050]  148.86 108.4 180 bottom
TP13107  *TP  [TP2050]  151.4 111.47 180 bottom
TP13108  *TP  [TP2050]  139.21 111.7 0 top
TP13109  *TP  [TP2050]  140.56 107.87 0 top
TP13110  *TP  [TP2050]  156.48 110.15 0 top
TP13111  *TP  [TP2050]  155.19 109.97 0 top
TP13112  *TP  [TP2050]  139.09 123.28 0 top
TP13113  *TP  [TP2050]  137.31 114.01 180 bottom
TP13114  *TP  [TP2050]  137.26 120.16 0 top
TP13115  *TP  [TP2050]  137.82 123.28 0 top
TP13116  *TP  [TP2050]  137.21 122.06 0 top
TP13117  *TP  [TP2050]  181.88 141.7 180 bottom
TP13118  *TP  [TP2050]  54.88 20.01 180 bottom
TP13119  *TP  [TP2050]  70.02 19.88 180 bottom
TP13120  *TP  [TP2050]  71.42 19.9 180 bottom
TP13121  *TP  [TP2050]  33.73 20.18 180 bottom
TP13122  *TP  [TP2050]  44.22 20.11 180 bottom
TP13123  *TP  [TP2050]  45.74 20.11 180 bottom
TP13125  *TP  [TP2050]  50.69 71.72 0 top
TP13126  *TP  [TP2050]  309.01 60.8 180 bottom
TP13127  *TP  [TP2050]  309.04 73.3 180 bottom
TP13128  *TP  [TP2050]  308 80.99 0 top
TP13129  *TP  [TP2050]  308.78 79.8 0 top
TP13137  *TP  [TP2050]  308.48 64.1 180 bottom
TP13138  *TP  [TP2050]  309.44 68.04 180 bottom
TP13139  *TP  [TP2050]  317.06 59.71 0 top
TP13140  *TP  [TP2050]  308.88 56.73 180 bottom
TP13141  *TP  [TP2050]  312.95 64.86 180 bottom
TP13142  *TP  [TP2050]  297.84 48.86 0 top
TP13143  *TP  [TP2050]  296.57 48.86 0 top
TP13144  *TP  [TP2050]  309.11 62.93 180 bottom
TP13145  *TP  [TP2050]  311.25 51.15 180 bottom
TP13146  *TP  [TP2050]  304.21 68.55 180 bottom
TP13147  *TP  [TP2050]  304.74 71.21 180 bottom
TP13148  *TP  [TP2050]  317.39 63.21 180 bottom
TP13149  *TP  [TP2050]  24.81 28.26 0 top
TP13150  *TP  [TP2050]  26.13 28.44 0 top
TP13151  *TP  [TP2050]  69.97 29.4 0 top
TP13152  *PAD  [ESD-6X3]  21.41 77.83 0 top
TP13153  *PAD  [ESD-6X3]  21.41 78.1 0 top
TP13154  *PAD  [ESD-6X6]  13.69 37.43 90 bottom
TP13155  *PAD  [ESD-6X6]  13.69 38.21 270 bottom
TP13156  *PAD  [ESD-6X6]  373.5 54.96 90 top
TP13157  *PAD  [ESD-6X6]  21.42 78.35 270 top
TP13158  *PAD  [ESD-6X6]  21.43 77.53 90 top
TP13159  *PAD  [ESD-6X6]  13.43 60.43 270 top
TP13160  *PAD  [ESD-6X3]  13.69 37.95 180 bottom
TP13161  *PAD  [ESD-6X3]  13.36 40.14 0 top
TP13162  *PAD  [ESD-6X3]  13.58 43.82 180 bottom
TP13163  *PAD  [ESD-6X3]  13.69 37.68 180 bottom
TP13164  *PAD  [ESD-6X3]  13.36 39.87 0 top
TP13165  *PAD  [ESD-6X6]  13.43 59.66 90 top
TP13166  *PAD  [ESD-6X6]  13.1 56.44 270 bottom
TP13167  *PAD  [ESD-6X3]  13.58 44.09 180 bottom
TP13168  *PAD  [ESD-6X6]  13.1 55.66 90 bottom
TP13169  *PAD  [ESD-6X6]  13.63 62.36 270 bottom
TP13170  *PAD  [ESD-6X6]  13.63 61.59 90 bottom
TP13171  *PAD  [ESD-6X6]  13.58 44.34 270 bottom
TP13172  *PAD  [ESD-6X3]  13.1 56.18 180 bottom
TP13173  *PAD  [ESD-6X3]  13.43 60.18 0 top
TP13174  *PAD  [ESD-6X3]  13.63 61.84 180 bottom
TP13175  *PAD  [ESD-6X3]  13.1 55.92 180 bottom
TP13176  *PAD  [ESD-6X3]  13.43 59.91 0 top
TP13177  *PAD  [ESD-6X6]  13.58 43.56 90 bottom
TP13178  *PAD  [ESD-6X6]  13.36 40.39 270 top
TP13179  *PAD  [ESD-6X3]  13.63 62.11 180 bottom
U3  CLK@PI6CEQ20200LIEX  [TSSOP20-6_4-65]  39.77 57.75 270 top
U21  DSL6540-SLL44  [BGA337-INTEL-DSL6540]  350.05 53.16 180 top
U41  KBL_H_BGA1440P  [BGA1440-INTEL-SKYLAKE-H]  245.57 117.72 0 top
U49  IT8987E/CX  [LQFP128-16X16-4-1_6H]  186.2 59.4 270 top
U53  *NL17SZ08DFT2G  [SOT353-1-2_125-65-5P]  208.96 99.51 180 bottom
U13025  TUSB546-DCIRNQR  [QFN40-6X4-4-49P-SMT]  334.03 56.1 180 top
U13064  *74AUP1G07GW  [SOT353-1-2_125-65-5P]  212.08 101.31 270 bottom
U13076  W25Q80DVSSIG  [SOIC8-7_9-1_27]  338.66 66.26 0 top
U13079  DIS@TUSB546-DCIRNQR  [QFN40-6X4-4-49P-SMT]  334.28 74.51 180 top
U13080  SY6288C20AAC  [SOT23-2_85-95-5P]  325.01 74.01 90 top
U13081  G5245AT11U  [SOT23-5-2_8-95-5P-G708]  255.8 167.48 90 top
U13092  G781P8  [MSOP8-4_9-65]  360.5 42.94 270 top
U13093  P_KB@TLC59116IRHBR  [QFN32-5X5-5-33P-TRF7970A]  262.15 48.23 180 top
U13098  *NL17SZ08DFT2G  [SOT353-1-2_125-65-5P]  318.92 45.71 180 top
U13102  NL17SZ08DFT2G  [SOT353-1-2_125-65-5P]  328.95 50.26 90 top
U13103  W25Q128FVSIQ  [SOIC8-8-1_27]  326.54 66.01 0 top
U13108  ALC299-CG  [QFN48-6X6-4-49P-ALC280]  29.74 31.46 90 top
U13112  NS892407_1000  [TRF-10-1-24P-SMT]  363.3 71 270 top
U13113  SKY-H_PCH_BGA837P  [BGA837-INTEL-SKYLAKE-PCH]  302.51 63.57 0 top
U13114  GPU_N17E_2152P  [BGA2152-NVIDIA-N17E-G2]  161.11 131.36 270 top
U13115  NL17SZ08DFT2G  [SOT353-1-2_125-65-5P]  132.63 112.51 270 top
U13116  GD25LQ80BTIGR  [SOIC8-6-1_27-PM25LV010A]  129.26 102.2 0 top
U13117  *VBIOS Socket  [SOIC8-6-1_27-PM25LV010A]  129.26 102.2 0 top
U13118  74LVC1G32GW  [SSOP5-P-A-TOSHIBA-B]  126.92 118.84 270 top
U13119  74LVC1G32GW  [SSOP5-P-A-TOSHIBA-B]  123.21 116.42 90 top
U13120  60@NL17SZ08DFT2G  [SOT353-1-2_125-65-5P]  123.21 112.87 90 top
U13121  G524B2T11U  [SOT23-5]  20.85 63.72 180 top
U13122  AZ1065-06F.R7G  [DFN10-4_1X2-8-11P]  17.8 39.72 270 top
U13123  AZ1065-06F.R7G  [DFN10-4_1X2-8-11P]  17.8 48.23 270 top
U13124  PTN36242LBS  [QFN32-3X6-4-33P-1H]  27.96 48.73 90 top
U13125  G524B2T11U  [SOT23-5]  26.56 85.31 270 top
U13127  AZ1065-06F.R7G  [DFN10-4_1X2-8-11P]  370.18 59.81 90 top
U13128  SLGC55544VTR  [QFN16-3X3-5-22P-TPS2544RTER]  363.62 51.4 270 top
U13135  MT58K256M32JA-120:A  [BGA190-MICRON-MT58K256M32]  199.92 138.9 180 top
U13136  MT58K256M32JA-120:A  [BGA190-MICRON-MT58K256M32]  199.92 119.85 0 top
U13137  MT58K256M32JA-120:A  [BGA190-MICRON-MT58K256M32]  176.3 170.91 270 top
U13138  MT58K256M32JA-120:A  [BGA190-MICRON-MT58K256M32]  199.92 154.91 0 top
U13139  MT58K256M32JA-120:A  [BGA190-MICRON-MT58K256M32]  132.86 170.91 270 top
U13140  MT58K256M32JA-120:A  [BGA190-MICRON-MT58K256M32]  151.15 170.91 90 top
U13141  MT58K256M32JA-120:A  [BGA190-MICRON-MT58K256M32]  122.45 129 0 top
U13142  MT58K256M32JA-120:A  [BGA190-MICRON-MT58K256M32]  122.45 148.05 180 top
U13143  E2500-R1V1-RL  [QFN40-5X5-4-41P-IT6515FN]  350.41 71.34 0 top
U13146  PS8559BQFN40GTR-A0  [QFN40-6X4-4-41P-0_8H]  60.98 34.13 90 top
U13147  PS8559BQFN40GTR-A0  [QFN40-6X4-4-41P-0_8H]  71.14 42.64 90 top
U13148  PS8559BQFN40GTR-A0  [QFN40-6X4-4-41P-0_8H]  55.52 45.94 90 top
U13149  PS8559BQFN40GTR-A0  [QFN40-6X4-4-41P-0_8H]  45.74 36.92 90 top
U13150  SV3H715  [QFN16-3X3-5-17P-TPS2543RTER]  19.58 18.13 0 top
U13151  SV3S700A  [QFN16-3X3-5-17P-TPS2543RTER]  17.83 28.08 180 top
U13152  TLC59116IRHBR  [QFN32-5X5-5-33P-TRF7970A]  375.38 8.47 180 top
U13155  TPS65982ABZQZR  [BGA96-TEXAS-TPS65982]  368.62 26.99 0 top
U13156  *MAX9892  [DFN6-1_5X1-5]  19.86 12.01 180 bottom
U13157  SUB@ALC1006-VB-CGT  [QFN48-6X6-4-49P-ALC280]  34.72 40.78 180 top
U13158  M_KB@AOZ1331DI  [SON14-3X2-4-15P-SMT]  124.07 59.73 90 bottom
U13159  AOZ1331DI  [SON14-3X2-4-15P-SMT]  375.36 9.77 180 bottom
U13161  YB1253ST25X330  [SOT23-5-2_8-95-5P-1_45H]  24.68 18.15 270 top
Y3  25MHZ/30ppm  [XTL-2_05X1_65-1_4X1_1-0_6H]  354.65 43.27 180 top
Y1001  32.768KHZ/20ppm  [XTL-3_2X1_5-2_5-0_8H]  320.42 53.23 270 top
Y1002  24MHZ/20ppm  [XTL-2X1_6-1_35X1_05]  286.15 54.14 270 top
Y1003  25MHZ/30ppm  [XTL-2_05X1_65-1_4X1_1-0_6H]  351.81 64.48 180 top
Y1004  27MHZ/10ppm  [XTL-3_2X2_5-2_2X1_6-0_9H]  146.86 105.66 180 top

## Library data of the parts
C85 C194 C202 C216 C218 C260 C273 C417 C420 C574 C669 C670 C675 C680 C689 C718 C721 C755 C767 C802 C807 C812 C853 C887 C889-C892 C897 C961 C963 C1194 C13391 C13393 C13512 C13548 C93687 C93696 C94044 C94051 C94182 C94248-C94311 C94317-C94326 C94384-C94418 C94423-C94426 C94432-C94499 C94504-C94513 C94518 C94519 C94521-C94537 C94539 C94542-C94545 C94547-C94556 C94559-C94586 C94588-C94596 C94598-C94618 C94624-C94626 C94630-C94650 C94652 C94655-C94659 C94668-C94671 C94676-C94686 C94688-C94705 C94707-C94711 C94718-C94721 C94723-C94726 C94735-C94744 C94747-C94751 C94754 C94764 C94765 C94774 C94776 C94778 C94784-C94791 C94796-C94805 C94807-C94812 C94814 C94815 C94818-C94824 C94828-C94848 C94850-C94855 C94859-C94877 C94879 C94881-C94916 C94918 C94919 C94921-C94934 C94937-C94940 C94942 C94943 C94945-C94947 C94951-C94953 C94956 C94958-C94993 C95000 C95002-C95060 C95065-C95237 C95239-C95241 C95243-C95261 C95496 C95498-C95522 C95524-C95534 C95538-C95548 C95553-C95567 C95573-C95578 C95580 C95581 C95583 C95591 C95593-C95596 C95623-C95637 C95674-C95834 C95837-C95871 C95873-C95884 C95886-C95889 C95892-C95899 C95902-C95905 C95907-C95909 C95911-C95915 C95919 C95922 C95924 C95928-C95930 C95933-C95935 C95939-C95944 C95946 C95962 C95973-C95994 C95998 C96009-C96024 C96026-C96028 C96030 C96031 C96033-C96036 C96038 C96039 C96042 C96043 C96045-C96047 C96049 C96051-C96054 C96057-C96168 C96201-C96204 C96207 C96210-C96237 C96240-C96261 C96263 C96267-C96270 C96273 C96279-C96281 PC1-PC20 PC25 PC35-PC37 PC47 PC50 PC51 PC62 PC81 PC97-PC104 PC106-PC108 PC125 PC126 PC129-PC149 PC151 PC164-PC168 PC170 PC172 PC174 PC182 PC184 PC217 PC220-PC223 PC260-PC264 PC2021-PC2032 PC2034-PC2040 PC5583-PC5596 PC5598 PC5600-PC5603 PC5605 PC5606 PC5608 PC5614 PC5616 PC5623 PC5624 PC5626 PC5634 PC5635 PC5638 PC5639 PC5646 PC5647 PC5653 PC5654 PC5660 PC5667 PC6228 PC8099-PC8109 PC9000-PC9018 PC9022 PC9023 PC9026 PC9027 PC9030 PC9063-PC9078 PC9080-PC9082 PC9101-PC9103 PC9106 PC9107 PC9109 PC9112 PC9113 PC9121 PC9124 PC9126-PC9129 PC9131 PC9186 PC9194 PC9324-PC9326 PC9374-PC9386 PC9388-PC9390 PC9392-PC9407 PC9409-PC9413 PC9415-PC9423 PC9425-PC9433 PC9435 PC9436 PC9438-PC9443 PC9447 PC9451-PC9475 PC9482-PC9495 = CAP NON-POL_BGM
C94775 C94777 C94780-C94783 = CAP_8P4R_BGM
C95238 C95242 C96209 C96264-C96266 PC124 PC127 PC128 PC161 PC219 PC2033 PC9025 PC9029 PC9079 PC9110 PC9305 PC9354 PC9387 PC9391 PC9414 PC9444 PC9446 PC9477-PC9481 PC9496 = CAP POL_BGM
CLIP1-CLIP8 = CLIP_3P_BGM
CN11 = KBC CONN 28PIN_13
CN18 = USB3_1_24P_DX07S024JJ2_BGM
CN2039 CN2045 CN2046 CN2060 = Header_4P_BGM
CN2042 = Housing_40P_6fixP_BGM
CN2043 = DP20P_4fix_BGM
CN2044 = HDMI_19P_BGM
CN2048 = FFCFPC_26P_BGM
CN2049 = Housing_6P_BGM
CN2054 = RTC_4P_BGM
CN2058 CN2059 = COMBOJACK_8P_BGM
CN2061 = RJ45_8P_BGM
CN2062 CN2063 = DDR4_DIMM_260P_BGM
CN2064 CN2065 CN2067 = USB3_13P_BGM
CN2066 = USB2_8P_BGM
CN2068 = NGFF_79P_AKEY_FT_NAME_BGM
CN2069 CN2070 = NGFF_79P_MKEY_FT_BGM
CN2071 = FFCFPC_8P_BGM
CN2074 CN2079 = FFCFPC_6P_BGM
CN2075 = FFCFPC_14P_BGM
CN2076 = FFCFPC_20P_BGM
CN2077 = FFCFPC_4P_BGM
CN2078 = FFCFPC_10P_BGM
D11 D13 D15 D17-D19 D73 D8557 D8586-D8589 D8591 D8592 D8594 D13038 D13039 D13066 D13067 D13069 D13070 D13088-D13090 D13095 PD40 PD101 PD102 PD9000 = Schottky_DIODE_BGM
D51 D8553-D8556 D8558 D8565-D8567 D8569-D8571 D8575-D8577 D8596-D8599 D13025-D13037 D13040-D13042 D13046-D13051 D13053-D13061 D13064 D13065 D13071-D13087 D13094 = TVS_DIODE_BGM
D8559 D8595 = BAT54A_BGM
D8568 = BAT54C_BGM
ESD7 ESD8 = AZ1045-04F_BGM
HOLE1-HOLE22 SPAD2-SPAD28 = 3x2_3.1
JP1 = OPEN_BGM
JP10 PJ2003 PJ3004 PJ3005 PJ3007 PJ9002-PJ9004 PJ9010 PR1 PR2 PR4-PR6 PR8 PR17 PR19 PR25 PR26 PR30 PR32 PR100 PR102 PR104 PR127 PR128 PR130-PR132 PR136 PR169 PR171-PR176 PR179 PR180 PR192 PR208 PR210 PR264 PR266 PR303 PR304 PR309 PR310 PR312 PR706 PR2017 PR2018 PR2020 PR2024 PR2026 PR2028 PR2030 PR3022 PR6413 PR9008 PR9009 PR9011 PR9022 PR9028 PR9033 PR9038 PR9041 PR9042 PR9044 PR9047 PR9051 PR9054-PR9057 PR9065 PR9069-PR9071 PR9074 PR9075 PR9077 PR9135 PR9138 PR9217 PR9223 PR9225 PR9226 PR9230 PR9234 PR9241 PR9256 PR66825-PR66827 PR66835-PR66837 PR66839 PR66841 PR66843-PR66850 PR66853 PR66854 PR66856 PR66861 PR66870 PR66872 PR66874 PR66877 PR66879 PR66881 PR66883 PR66886 PR66889 PR66892-PR66894 PR66900 PR66905 PR66915 PR66920 PR66925 PR66937 PR66939-PR66957 PR66975-PR66980 PR66987-PR66995 PR66997 PR66999 PR67001 PR67004-PR67007 PR67010 PR67175 PR67176 PR67195-PR67199 PR67201 PR67219 PR67225 PR67236 R151 R540 R543 R556 R821 R20758 R20816 R20817 R20821-R20823 R20830 R20950 R20952-R20954 R20965 R20968 R20973 R20974 R21050 R21051 R21106 R21113 R21125 R21127 R21129 R21141 R21152 R21156 R21166 R21191 R21208 R21209 R21211 R21213 R21330-R21356 R21359 R21386 R21447 R21454 R21465 R21468 R21470 R21481 R21505 R21507 R21508 R21574 R21673-R21678 R21680-R21684 R21688 R21696-R21701 R21704 R21706 R21713 R21726 R21728-R21733 R21737 R21788 R21790 R21792-R21796 R21798-R21800 R21990 R22008 R22009 R22061 R22062 R22064 R22065 R22073 R22088 R22090 R22095 R22096 R22126 R22136 R22159 R22191 R22200 R22201 R22204-R22207 R67038 R67084 R67117 R67137 R67138 R67141 R67156 R67159-R67162 R67164 R67166 R67174 R67196 R67208 R67211 R67213 R67218 R67255 R67258 R67259 R67264 R67271 R67272 R67275 R67277 R67306 R67313 R67315 R67320 R67322 R67326 R67327 R67334 R67336 R67339 R67354-R67357 R67367 R67368 R67385 R67394 R67395 = SHORTPAD_BGM
L12 L4242 L4266 PL1-PL3 PL5 PL6 PL9 PL12 PL15 PL2001 PL8002 PL9001 PL9017 PL9019-PL9026 = INDUCTOR_BGM
L13 L14 L4238 L4240 L4241 L4243-L4246 L4250 L4258 L4259 L4264 L4268-L4273 = BEAD_BGM
