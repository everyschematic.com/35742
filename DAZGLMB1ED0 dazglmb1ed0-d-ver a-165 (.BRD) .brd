# Allegro board DAZGLMB1ED0 dazglmb1ed0-d-ver a-165 (.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SML0ALERT#: length 5.6
  TOP w0.14: v2(310.74,72.36) 310.94,72.15 U13113.BA40
  BOTTOM w0.14: v2(310.74,72.36) 310.28,72.81 310.28,72.97 310.35,73.04 310.35,74.56 310.51,74.72 R21259.1 310.51,75 310.03,75.48 310.03,76.01 310.48,76.46 R21252.2
SML2ALERT#: length 9.1
  TOP w0.102: 315,71.34 315,71.21 314.12,70.32 313.61,70.32 313.38,70.09 313.3,70.09 312.99,69.78 U13113.BD35
  TOP w0.127: 315,71.34 315,72.55 316.58,74.13 R21229.1
  TOP w0.14: R21220.2 318.55,73.65 317.36,73.65 R21229.1
SPI_CLK: length 10.7
  TOP w0.14: v1(323.87,70.83) 323.41,70.37 322.96,70.37 322.46,70.87 R21249.2 322.37,70.89 R21245.2 ; v1(327.68,68.55) 327.6,68.55 327.17,68.98 U13103.6 327.17,70.5 327.59,70.92 v1(327.59,71.16)
  IN1 w0.089: v1(323.87,70.83) 324.82,69.88 325,69.88 325.36,69.52 326.86,69.52 327.68,68.7 v1(327.68,68.55)
SPI_CS0#: length 5.7
  TOP w0.14: U13103.1 v1(324.63,60.93)
  BOTTOM w0.14: R22065.2 R22064.2 324.51,61.05 v1(324.63,60.93) 325.04,60.52 R67243.2 326.01,60.52 326.33,60.19 v1(326.33,59.58)
SPI_CS0#_UR_ME: length 200.5
  TOP w0.14: v1(191.23,65.83) 190.8,66.26 U49.101
  IN1 w0.089: v1(324.81,63.47) 325.78,62.5 325.78,60.54 326.23,60.09 326.23,57.1 325.88,56.75 325.88,54.54 324.44,53.09 324.44,50.45 322.85,48.87 322.85,47 321.46,45.61 318.11,45.61 317.24,46.49 311.34,46.49 310.9,46.05 289.78,46.05 287.44,48.38 269.14,48.38 268.62,47.85 268.2,47.44 268.2,45.84 267.96,45.61 266.81,45.61 266.72,45.7 266.72,46.46 266.63,46.55 266.36,46.55 266.27,46.46 266.27,45.7 266.18,45.61 265.92,45.61 265.83,45.7 265.83,46.46 265.74,46.55 265.47,46.55 265.38,46.46 265.38,45.7 265.3,45.61 265.03,45.61 264.94,45.7 264.94,46.46 264.85,46.55 264.58,46.55 264.5,46.46 264.5,45.7 264.41,45.61 264.06,45.61 263.42,46.25 262.94,46.25 262.85,46.33 262.85,46.86 262.76,46.95 262.5,46.95 262.41,46.86 262.41,46.33 262.32,46.25 262.05,46.25 261.96,46.33 261.96,46.86 261.88,46.95 261.61,46.95 261.52,46.86 261.52,46.33 261.43,46.25 259.89,46.25 259.81,46.33 259.81,46.86 259.72,46.95 259.45,46.95 259.36,46.86 259.36,46.33 259.27,46.25 259.01,46.25 258.92,46.33 258.92,46.86 258.83,46.95 258.56,46.95 258.47,46.86 258.47,46.33 258.38,46.25 258.12,46.25 258.03,46.33 258.03,46.86 257.94,46.95 257.67,46.95 257.58,46.86 257.58,46.33 257.49,46.25 203.36,46.25 202.52,47.08 195.17,47.08 194.59,47.66 193.39,47.66 193.31,47.75 193.31,48.54 193.22,48.63 193.04,48.63 192.95,48.54 192.95,47.75 192.86,47.66 192.68,47.66 192.59,47.75 192.59,48.55 192.51,48.64 192.33,48.64 192.24,48.55 192.24,47.75 192.15,47.66 191.97,47.66 191.88,47.75 191.88,48.55 191.79,48.64 191.62,48.64 191.53,48.55 191.53,47.75 191.44,47.66 191.26,47.66 191.17,47.75 191.17,48.55 191.08,48.64 190.91,48.64 190.82,48.55 190.82,48.02 190.74,47.95 190.57,47.95 190.46,48.06 190.46,48.55 190.37,48.64 190.19,48.64 190.11,48.55 190.11,47.96 189.97,47.82 189.59,47.82 189.44,47.97 v1(189.44,48.92)
  BOTTOM w0.14: v1(191.23,65.83) 191.23,64.15 190.89,63.81 190.89,62.96 190.44,62.51 188.28,62.51 187.42,61.65 187.42,58.65 187.88,58.18 187.88,56.45 189.07,55.26 189.07,53.59 189.72,52.94 189.72,50.55 189.54,50.37 189.54,50.01 189.33,49.81 189.33,49.04 v1(189.44,48.92) ; R22064.1 324.51,63.16 v1(324.81,63.47)
SPI_HOLD_IO3: length 2.6
  TOP w0.14: U13103.7 v1(325.9,68.6)
  BOTTOM w0.14: R21240.1 v1(325.9,68.6) R22067.2
SPI_SI: length 4.2
  TOP w0.14: U13103.5 328.44,70.96 v1(328.32,71.09)
  BOTTOM w0.14: R21246.2 328.47,68.67 328.31,68.83 R21250.2 328.31,71.08 v1(328.32,71.09)
SPI_SO: length 4.1
  TOP w0.14: U13103.2 325.9,61.36 v1(326.28,60.98)
  BOTTOM w0.14: R21243.2 R22063.2 326.54,61.23 v1(326.28,60.98) 326.44,60.82 v1(326.94,60.82)
SPI_WP_IO2: length 5.1
  TOP w0.14: v1(328.77,63.42) 327.45,63.42 327.17,63.14 U13103.3
  BOTTOM w0.14: R22066.2 329.19,62.46 R21253.2 328.82,63.36 v1(328.77,63.42)
SPKLN_L: length 14.1
  TOP w0.203: v1(38.76,39.13) 38.65,39.23 38.6,39.23 38.45,39.38 U13157.39
  TOP w0.508: L4237.1 28.21,38.84 v1(28.21,38.32)
  IN4 w0.508: v1(28.21,38.32) 29.38,37.15 31.44,37.15 32.38,38.09 37.33,38.09 38.07,38.83 38.45,38.83 v1(38.76,39.13)
SPKLP_L: length 14.6
  TOP w0.203: v1(38.8,39.78) U13157.40
  TOP w0.508: L4236.1 27.43,37.77 v1(27.43,38.27)
  IN4 w0.508: v1(38.8,39.78) 37.4,39.78 36.72,39.11 31.34,39.11 31.08,39.36 27.71,39.36 27.43,39.08 v1(27.43,38.27)
SPKRN_L: length 3.2
  TOP w0.203: U13157.46 38.38,42.18 38.55,42.36 38.63,42.36 v1(38.83,42.56)
  BOTTOM w0.508: v1(38.83,42.56) 39.16,42.56 39.48,42.88 L4235.1 39.69,43.73 v1(39.57,43.86)
SPKRP_L: length 3
  TOP w0.203: U13157.45 38.69,41.78 v1(38.81,41.9)
  BOTTOM w0.508: v1(38.81,41.9) 38.52,41.61 L4234.1 37.92,41.71 v1(37.92,42.59)
SRTC_RST#: length 21
  TOP w0.102: U13113.BB10 311.69,57.26 v2(311.42,56.99)
  TOP w0.14: Q7934.3 324.72,49.15 v1(324.23,49.65) 323.39,50.48 v1(323.39,50.85)
  IN2 w0.089: v1(317.83,56.71) 316.66,56.71 316.38,56.99 v2(311.42,56.99)
  BOTTOM w0.14: v1(317.83,56.71) 318.37,56.71 318.89,56.19 321.73,56.19 324.11,53.82 C94812.1 324.33,53.09 R21142.2 324.5,51.85 323.49,50.85 v1(323.39,50.85)
STEREO_OUT_SRV_HEAD: length 6.1
  TOP w0.14: U13114.BD4 v2(145.01,119.46)
  BOTTOM w0.14: v2(145.01,119.46) 144.96,119.46 144.77,119.65 141.47,119.65 141.14,119.98 v1(140.96,119.98) 140.66,119.68 R21581.2
STRAP0: length 6.2
  TOP w0.14: R21542.1 R21553.2 142.63,112.07 143.1,112.54 143.53,112.54 144.3,113.31 144.3,113.69 144.66,114.05 U13114.BL3
STRAP1: length 11.4
  TOP w0.127: U13114.BL4 145.36,114.21 145.71,113.85 145.71,113.37 145.56,113.22
  TOP w0.14: 145.56,113.22 145.56,111.98 144.67,111.09 144.67,109.59 143.83,108.75 143.83,108.57 143.17,107.92 v1(143.15,107.92) 143.1,107.87 143.1,107.42 142.56,106.89 142.56,106.18 R21554.2 R21543.1
STRAP2: length 11.3
  TOP w0.127: U13114.BM4 145.28,113.44
  TOP w0.14: 145.28,113.44 145.28,112.21 144.27,111.19 144.27,109.9 143.98,109.62 143.25,109.62 141.85,108.22 141.85,108.14 v1(141.83,108.12) 141.4,107.69 141.4,106.21 R21555.2 R21544.1
STRAP3: length 10.2
  TOP w0.127: 145.82,113.09 146.06,113.34 U13114.BM5
  TOP w0.14: 145.82,113.09 145.82,111.73 145.05,110.96 145.05,108.26 144.2,107.41 144.2,107.22 143.71,106.72 143.71,106.18 R21556.2 R21545.1
STRAP4: length 17.1
  TOP w0.127: U13114.BK5 v2(145.71,115.26)
  BOTTOM w0.14: v2(145.71,115.26) 145.52,115.07 145.52,115.01 145.2,114.69 145.2,114.31 144.94,114.05 144.94,108.14 144.29,107.49 144.29,103.67 v1(144.6,103.37) 144.62,103.34 144.62,101.1 R21557.2 R21546.1
STRAP5: length 18.4
  TOP w0.127: U13114.BJ5 v2(145.71,115.96)
  BOTTOM w0.14: v2(145.71,115.96) 145.25,115.5 145.25,115.12 144.9,114.77 144.9,114.52 143.96,113.58 143.96,110.71 143.76,110.51 143.76,106.75 143.15,106.14 143.15,102.53 v1(143.53,102.15) 144.01,101.67 144.01,101.31 144.17,101.15 R21558.2 R21547.1
SUSACK#: length 13.1
  TOP w0.102: 311.69,61.56 U13113.BB19
  TOP w0.14: v1(318.79,61.26) 318.49,61.26 318.16,60.93 R21125.1 ; 311.69,61.56 311.02,61.56 v2(310.66,61.21)
  IN1 w0.089: v1(318.79,61.26) 318.49,60.95 313.68,60.95 313.12,61.51 310.97,61.51 v2(310.66,61.21)
  BOTTOM w0.14: v1(318.79,61.26) 319.27,61.26 319.58,60.95 R21153.2 v1(319.58,59.91)
SUSB#: length 191.2
  TOP w0.102: U13113.AW15 310.66,59.4 v2(310.28,59.02)
  TOP w0.14: U49.119 183.6,65.65 183.76,65.49 183.76,64.67 185.77,62.66 v1(185.77,61.23)
  IN2 w0.089: v1(208.63,92.55) 208.63,91.86 207.7,90.93 207.7,73.15 v1(206.5,71.95)
  IN3 w0.079: v1(185.77,61.23) 185.77,61.85 187.67,63.75 190.95,63.75 191.43,64.23 193.82,64.23 194.71,63.35 195.37,63.35 195.74,63.71 195.74,63.77 196.23,64.26 196.23,65.36 197.76,66.89 198.14,66.89 198.65,66.38 202.58,66.38 205.25,69.05 205.25,70.7 v1(206.5,71.95) 211.43,76.89 211.43,78.15 214.14,80.85 275.02,80.85 279.36,76.52 279.36,75.18 280.94,73.59 280.94,69.82 279.36,68.23 279.36,66.44 282.14,63.66 290.94,63.66 292.82,61.78 305.2,61.78 305.84,61.15 305.84,59.78 306.09,59.53 309.77,59.53 v2(310.28,59.02)
  IN5 w0.089: v1(208.63,92.55) 208.86,92.78 208.86,93.46 208.07,94.25 208.07,97.63 207.64,98.06 v1(207.59,98.06)
  BOTTOM w0.14: U53.1 208.59,98.86 208.71,98.75 208.71,98.42 208.35,98.06 v1(207.59,98.06)
SUSC#: length 182
  TOP w0.102: U13113.BD15 313.08,59.55 313.49,59.55 313.67,59.73 314.46,59.73 314.67,59.53 315.03,59.53 v1(315.46,59.1)
  TOP w0.14: v1(182.67,60.98) 182.65,60.95 182.65,60.06 181.34,58.76 179.32,58.76 179.28,58.8 U49.18
  IN3 w0.079: v1(182.67,60.98) 182.97,60.68 185.97,60.68 186.48,61.19 186.48,61.96 187.95,63.43 191.09,63.43 191.74,62.78 191.74,62.38 192.07,62.05 193.02,62.05 194.95,60.13 194.95,58.82 195.36,58.4 195.95,58.4 198.01,56.34 198.54,56.34 198.76,56.11 199.14,56.11 199.31,55.94 202.59,55.94 205.56,58.91 205.56,62.93 205,63.49 205,68.29 205.69,68.98 205.69,69.63 212.91,76.85 212.91,78.68 214.76,80.54 274.89,80.54 279.04,76.39 279.04,75.05 280.61,73.48 280.61,69.96 279.05,68.4 279.05,66.31 282.01,63.35 290.2,63.35 293.01,60.54 299.23,60.54 299.49,60.29 301.01,60.29 301.26,60.54 304.19,60.54 305.2,59.53 305.64,59.53 305.99,59.18 307.1,59.18 307.77,58.52 314.88,58.52 v1(315.46,59.1)
SUSD: length 7
  TOP w0.14: PC62.1 214.12,162.79 PR66972.2 213.41,162.08 PQ9054.3 213.41,158.21 v1(213.51,158.11) 213.3,157.9 PQ9055.2
SUSON: length 371.2
  TOP w0.14: U49.120 183.2,68.42 183,68.62 183,69.13 182.93,69.21 R20892.1 183.41,70.04 183.41,71.06 183.92,71.57 183.92,71.97 v1(183.28,72.61) ; PQ8.2 213.23,142.35 v1(213.63,141.94) ; v1(187.85,72.99) PR304.2 ; Q7923.2 362.61,39.59 362.5,39.69 362.5,40.81 v1(363.04,41.34) ; v1(331.36,79.09) 331.36,80.31 331.57,80.51 331.57,85.23 331.97,85.64 334.26,85.64 335.8,87.18 338.98,87.18 340.54,88.74 341.17,88.74 342.74,90.31 342.74,91.46 343.53,92.24 344.9,92.24 PR67224.1
  IN1 w0.089: v1(213.63,141.94) 213.9,141.94 219.56,136.28 220.67,136.28 223.03,133.91 223.03,131.44 221.7,130.11 221.7,129.83 219.78,127.9 219.78,118 217.31,115.54 215.39,115.54 204.87,105.02 204.87,101.91 205.43,101.35 205.43,97.68 203.78,96.03 203.78,93.3 200.95,90.47 200.95,85.29 206.34,79.9 206.34,77.61 205.88,77.15 205.88,76.46 206.34,76.01 206.34,74.87 205.71,74.25 205.54,74.25 205.13,73.83 204.67,73.83 201.37,77.13 v1(201.37,77.21) 200.7,77.21 200.12,76.62 197.38,76.62 193.39,72.64 188.21,72.64 v1(187.85,72.99) 187.5,72.64 183.31,72.64 v1(183.28,72.61)
  IN3 w0.079: v1(201.37,77.21) 201.37,77.25 205.03,80.92 206.2,80.92 206.53,81.25 210.93,85.65 278.54,85.65 279.72,84.47 280.95,84.47 282.88,82.55 284.41,82.55 285.59,81.36 287.73,81.36 290.1,78.99 290.95,78.99 291.15,78.78 294.91,78.78 295.12,78.58 300.84,78.58 301.54,77.88 304.7,77.88 304.97,78.15 306.78,78.15 307.88,77.05 310.07,77.05 310.38,77.35 311.59,77.35 312.04,77.81 316.13,77.81 317.13,78.81 320.82,78.81 321.98,79.98 330.9,79.98 331.36,79.51 v1(331.36,79.09) 331.36,78.75 332.61,77.5 332.61,72.37 333.27,71.72 333.27,69.94 334.03,69.18 335.05,69.18 336.19,68.04 336.19,67.48 340.29,63.37 344.57,63.37 346.75,65.55 349.1,65.55 350.31,66.76 353.35,66.76 354.3,65.81 354.3,62.85 355.43,61.72 358.76,61.72 362.54,57.94 362.54,54.36 365,51.9 365,47.8 363.04,45.83 v1(363.04,41.34)
  IN5 w0.089: v1(174.39,82.52) 175.64,81.27 175.64,75.18 177.19,73.63 180.36,73.63 181.38,72.61 v1(183.28,72.61)
  BOTTOM w0.14: v1(174.39,82.52) 174.65,82.77 PR2018.2
SUSWARN#: length 8.2
  TOP w0.102: R21125.2 316.85,60.67 315.84,61.68 315.84,61.79 315.69,61.94 313.89,61.94 313.63,61.68 U13113.BD19
  TOP w0.14: R21125.2 317.38,60.57 317.82,60.13 319.04,60.13 319.58,60.68 R21151.2
SWVGA1: length 33.3
  BOTTOM w0.203: PR9235.1 147.39,66.74 149.64,68.99 149.64,69.83 150.01,70.2 150.01,72.1 150.9,72.99 150.9,74.77 150.57,75.1 150.57,76.42 149.93,77.05 148.74,77.05 147.49,78.3 147.49,86.66 146.78,87.37 v1(140.3,87.37)
  BOTTOM w0.508: PR9073.2 v1(139.67,94.99)
  vias: v1(138.32,97.22)
SWVGA2: length 24.8
  TOP w0.203: v1(149.73,75.68) 148.91,76.5 145.08,76.5 144.24,77.33 138.91,77.33
  IN5 w0.203: v1(149.73,75.68) 149.25,75.2 149.25,70.12 148.91,69.79 148,69.79 147.7,69.49 v1(147.7,68.18)
  BOTTOM w0.203: v1(147.7,68.18) 147.56,68.18 PR9239.1
  BOTTOM w0.508: PR66981.2 137.54,83.63 v1(136.62,84.55)
  vias: v1(135.43,86)
SWVGA3: length 18.9
  TOP w0.203: v1(149.92,76.34) 154.91,76.34 PL9025.1
  BOTTOM w0.203: v1(149.92,76.34) 150.22,76.04 150.22,74.96 150.55,74.63 150.55,73.13 149.66,72.24 149.66,70.34 149.3,69.97 149.3,69.13 148.84,68.67 PR9243.1
  BOTTOM w0.508: v3(152.88,77.21) 154.54,77.21 PR66982.2
  vias: v1(151.71,75.68)
SWVGA4: length 25.1
  IN5 w0.203: v1(148.66,69.23) 149.8,68.09 160.55,68.09 161.03,68.57 161.03,71.64 163.55,74.16 v1(163.55,76.52)
  BOTTOM w0.203: v1(148.66,69.23) 148.46,69.03 147.7,69.03 PR9245.1
  BOTTOM w0.508: PR66983.2 v3(164.21,76.09)
  vias: v1(163.29,75.76)
SYS_HWPG: length 181.9
  TOP w0.14: U49.124 181.6,66.24 181.96,65.88 v1(181.96,65.35)
  IN2 w0.089: v1(61.7,63.04) 60.72,62.06 60.72,57.97 64.79,53.9 65.71,53.9 66.68,52.92 66.68,52.02 67.65,51.04 68.67,51.04 70.32,49.39 72.55,49.39 72.84,49.1 77.78,49.1 78.16,49.49 82.94,49.49 83.95,50.49 93.64,50.49 96.41,53.26 100.46,53.26 101.17,53.97 110.11,53.97 111.17,55.03 115.04,55.03 115.31,54.77 118.23,54.77 118.55,54.45 124.23,54.45 125.12,53.56 126.39,53.56 131.08,58.26 131.08,59.76 131.54,60.21 137.56,60.21 138.16,60.81 145.86,60.81 147.22,59.45 149.5,59.45 150.95,58 159.27,58 159.7,58.42 161.6,58.42 162.55,59.38 163.24,59.38 163.67,58.94 167.25,58.94 168.28,59.98 169.75,59.98 171.88,62.11 174.58,62.11 176.14,63.67 178.92,63.67 180.18,64.93 180.79,64.93 181.21,65.35 v1(181.96,65.35)
  BOTTOM w0.14: v1(181.96,65.35) 181.43,65.35 179.62,67.15 179.62,68.98 178.56,70.04 174.88,70.04 174.66,70.25 174.11,70.25 173.89,70.03 173.89,69.02 173.67,68.8 D17.1
  BOTTOM w0.203: v1(61.7,63.04) 61.7,63.75 62.36,64.42 62.36,65.85 63.62,67.1 66.38,67.1 67.11,67.83 v1(67.58,67.83) 74.57,67.83 75.19,68.46 75.19,71.02 76.17,72 PR180.1
SYS_PEX_RST_MON#: length 7.4
  TOP w0.14: R21509.2 136.66,114.01 v1(136.66,113.58) ; R21509.2 136.86,114.41 135.99,115.28 135.55,115.28 135.3,115.03 135.3,114.68 134.89,114.27 R21508.1 134.63,114.02 134.41,114.24 133.97,114.24 U13115.4 ; R21509.2 R21580.2
SYS_PEX_RST_MON#_R: length 7.3
  TOP w0.14: R21580.1 138.7,115.19 138.77,115.13 R21594.2 140.05,115.13 142.84,117.92 143.47,117.92 U13114.BE2
SYS_PWROK: length 13.7
  TOP w0.14: R21127.2 315.66,45.61 R21150.1 315.68,44.73 315.95,44.47 318.46,44.47 319.05,45.06 U13098.4 320.74,45.06 320.96,44.84 R21152.1 321.63,44.84 322.55,45.76 v1(322.55,46.14) 322.55,47.01 321.91,47.64 320.49,47.64 320.28,47.43 R67172.1
SYS_PWROK_R: length 9.9
  TOP w0.114: U13113.AY1 310.97,52.62 311.13,52.46 311.36,52.46 311.68,52.14
  TOP w0.14: v1(312.95,45.09) 313.46,45.61 R21127.1 313.8,46.23 313.78,46.25 R21159.1 313.78,46.89 313.58,47.08 313.58,47.64 314.02,48.08 R21136.2 313.35,48.89 313.35,50.11 311.68,51.78 311.68,52.14
SYS_RESET#: length 4.6
  TOP w0.14: R21099.1 312.77,49.95 311.2,51.53 311.03,51.53 310.66,51.89 310.66,52.42 310.4,52.68 U13113.AW1
SYS_SHDN#: length 314.5
  TOP w0.14: v1(290.98,79.98) 290.57,80.38 PR3022.2 ; v1(192.6,69.74) v1(193.26,69.08) 193.75,69.08 194.13,68.69 194.13,68.22 192.99,67.08 192.99,66.08 192.81,65.91 192.81,65.46 192.34,64.98 191.77,64.98 190.52,63.73 190.52,61.92 191.47,60.97 192.56,60.97 192.8,61.2 U49.85 ; Q23.3 214.14,135.37 v1(213.91,135.6)
  IN1 w0.254: v1(104.11,59.45) 104.11,59.48 103.5,60.09 103.07,60.09 99.79,63.36 93.57,63.36 92.63,64.3 89.56,64.3 86.53,67.33 86.53,69.24 v1(86.36,69.41)
  IN3 w0.079: v1(104.11,59.45) 104.13,59.45 104.33,59.25 105.51,59.25 107.97,56.8 110.67,56.8 111.49,55.97 117.55,55.97 118.41,55.11 133.27,55.11 133.38,55.22 133.42,55.22 134.48,56.28 140.43,56.28 141.73,54.98 145.69,54.98 145.97,55.26 145.97,55.87 146.78,56.68 147.54,56.68 147.76,56.9 147.76,56.98 147.76,56.99 147.76,57.3 147.76,57.3 147.76,57.31 147.98,57.52 158.9,57.52 160.73,59.35 164.62,59.35 171.75,66.48 175.25,66.48 176.35,67.58 178.24,67.58 179.85,69.19 181.88,69.19 182.59,69.9 191.47,69.9 191.61,70.04 192.3,70.04 v1(192.6,69.74) 192.86,69.74 193.47,70.35 194.96,70.35 196.79,72.18 198.77,72.18 199.76,73.17 199.76,73.88 201.15,75.28 201.15,76.07 200.91,76.32 200.91,77.31 205.35,81.75 206.81,81.75 211.08,86.02 v1(211.78,86.02) 278.39,86.02 279.79,84.63 281.07,84.63 283,82.7 284.48,82.7 285.66,81.52 287.79,81.52 289.75,79.56 290.57,79.56 v1(290.98,79.98)
  IN5 w0.089: v1(213.91,135.6) 212.62,134.31 212.62,130.57 213.49,129.69 213.49,128.63 213.76,128.36 213.76,127.85 213.44,127.54 212.91,127.54 212.13,126.75 212.13,114.16 205.79,107.82 205.79,103.09 206.36,102.52 206.36,101.5 209.34,98.52 209.34,94.44 210.5,93.29 210.99,93.29 211.78,92.49 v1(211.78,86.02)
  IN5 w0.305: v1(86.36,69.41) 86.34,69.38 84.32,69.38 83.41,70.3 80.8,70.3 v1(80.15,70.95)
  BOTTOM w0.203: PU9.6 80.15,71.33 v1(80.15,70.95) ; PR179.1 PR186.2 85.88,69.89 v1(86.36,69.41)
SYSTEM_AGND: length 16.8
  TOP w0.254: PR192.2 79.47,71.15 v1(79.33,71.01)
  IN5 w0.305: v1(85.35,66.89) 85.35,67.28 82.89,69.74 80.58,69.74 79.33,70.99 v1(79.33,71.01)
  BOTTOM w0.203: v1(85.35,66.89) 85.35,66.92 84.86,67.42 PR182.2 PR185.2 ; PR189.2 PR190.2 77.63,68.03 v1(77.41,68.24) 77.41,68.43 77.76,68.77 77.76,69.1 78.38,69.72 78.38,70.06 v1(79.33,71.01)
TBT1_PCIE_RBIAS: length 1.3
  TOP w0.14: U21.N16 v4(349.72,50.89)
  BOTTOM w0.14: v4(349.72,50.89) 349.61,50.89 R379.1
TBT_BATLOW#: length 6.6
  TOP w0.079: U21.F2 352.81,57.82 352.57,58.06 352.57,59.01 352.03,59.55 350.34,59.55 349.66,60.23 349.59,60.23
  TOP w0.14: R67157.1 349.4,60.42 v1(349.42,60.39) 349.59,60.23
  BOTTOM w0.14: R20862.1 349.4,60.42 v1(349.42,60.39)
TBT_CIO_PLUG_EVENT#: length 12.4
  TOP w0.079: U21.W2 346.83,57.78 346.59,58.02 346.59,58.5 346.39,58.7 346.39,59.62 345.97,60.04 v1(345.97,60.16)
  TOP w0.14: v1(346.43,63.59) 346.07,63.24 R67192.1 345.56,63.24 345.36,63.43 345.36,63.7 345.25,63.82 R20693.1 344.45,63.82 343.96,63.33 R67220.2 343.58,63.31 D73.1
  BOTTOM w0.14: v1(345.97,60.16) 345.33,60.8 R67053.1 346.1,61.21 346.58,61.69 346.58,63.44 v1(346.43,63.59)
TBT_DP_HPD: length 305.9
  TOP w0.079: U21.AA2 345.91,57.79 345.68,58.02 345.68,58.83 345.35,59.16
  TOP w0.14: v1(131.34,114.14) 131.54,114.34 R21883.2 131.3,114.87 131.03,114.6 C95834.2 ; 345.35,59.16 345.17,59.34 343.1,59.34 342.52,59.91 R20865.1 342.17,59.66 341.9,59.4 341.02,59.4 v1(340.63,59.78)
  IN2 w0.089: v1(336.14,51.17) 334.44,51.17 333.78,50.51 330.7,50.51 v1(330.14,51.07)
  IN3 w0.079: v1(172.51,53.82) 173.09,53.24 175.98,53.24 178.79,56.06 179.84,56.06 180.28,56.5 183.39,56.5 183.84,56.05 189.03,56.05 189.6,56.62 191.41,56.62 192.31,55.72 192.78,55.72 194.27,54.23 195.36,54.23 195.87,53.72 198.33,53.72 198.86,53.18 199.62,53.18 199.93,52.87 202.68,52.87 203.04,53.23 205.54,53.23 205.81,53.5 205.81,55.03 206.62,55.85 207.67,55.85 208.15,55.36 208.15,55.06 209.6,53.61 225.83,53.61 226.03,53.81 270.15,53.81 272.12,51.85 286.25,51.85 286.54,52.13 289.47,52.13 290.29,51.31 291.76,51.31 292.38,50.7 296.32,50.7 298.37,52.75 299.97,52.75 300.27,53.05 301.49,53.05 301.87,52.67 307.51,52.67 309.14,51.05 v1(310,51.05) 312.62,51.05 313.13,51.55 313.13,52.11 313.43,52.41 313.74,52.41 313.95,52.19 317.41,52.19 318.82,50.79 322.75,50.79 323.85,51.88 328.51,51.88 329.32,51.07 v1(330.14,51.07)
  IN5 w0.089: v1(165.25,64.99) 164.59,65.65 162.72,65.65 162,64.93 156.54,64.93 155.28,66.19 153.61,66.19 151.95,64.53 150.23,64.53 149.39,65.36 137.06,65.36 136.67,65.75 134.12,65.75 133.24,66.63 133.24,68.29 131.92,69.61 127.77,69.61 127.38,70 127.38,71.94 125.88,73.45 125.88,84.01 127.05,85.18 127.05,88.87 128.65,90.47 128.65,93.63 128.47,93.81 128.47,99.99 129.56,101.08 129.56,101.57 130.91,102.91 130.91,111.78 130.83,111.85 130.83,113.63 v1(131.34,114.14)
  BOTTOM w0.14: v1(336.14,51.17) 336.57,51.6 R20830.2 336.94,52.92 337.12,53.09 337.12,54.07 337.77,54.72 338.48,54.72 339.24,55.48 339.24,57.77 340.63,59.17 v1(340.63,59.78) ; v1(310,51.05) 308.68,49.72 308.68,48.89 308.97,48.6 R67072.1 ; v1(172.51,53.82) 170.63,55.7 170.63,58.25 169.67,59.21 167.93,59.21 167.1,60.04 167.1,61.77 165.07,63.81 165.07,64.81 v1(165.25,64.99)
TBT_DP_HPD_Q: length 2.9
  TOP w0.14: R21882.1 130.8,116.6 v1(130.63,116.42) ; R21882.1 131.43,116.21 131.54,116.09 R21883.1 ; R21882.1 131.43,116.97 131.32,117.08 Q7880.2
TBT_DPSNK0_DDC_CLK: length 12.3
  TOP w0.14: R67149.1 342.17,58.01 341.9,57.75 340.43,57.75 v1(339.92,57.24) ; U21.Y5 v4(346.47,56.09)
  IN1 w0.089: v1(339.92,57.24) 340,57.17 340,56.44 340.28,56.16 345.13,56.16 345.45,56.48 346.08,56.48 v4(346.47,56.09)
  BOTTOM w0.14: R67046.1 345.72,56.84 v4(346.47,56.09)
TBT_DPSNK0_DDC_DATA: length 8
  TOP w0.14: v4(348.4,56.75) 348.72,57.06 U21.R4
  BOTTOM w0.14: v4(348.4,56.75) 348.4,57.07 348,57.47 v1(348,57.8) 347.37,58.44 R67047.1 346.99,61.04 346.86,61.18 346.86,62.7 R67150.1
TBT_DPSNK1_DDC_CLK: length 1.2
  TOP w0.079: v4(346.47,55.44) 346.15,55.11 U21.Y8
  BOTTOM w0.14: R397.1 346.45,55.46 v4(346.47,55.44)
TBT_DPSNK1_DDC_DATA: length 1.2
  TOP w0.14: U21.N4 349.42,57.06 v4(349.74,56.75)
  BOTTOM w0.14: R20844.1 349.91,56.91 v4(349.74,56.75)
TBT_DPSNK1_HPD: length 2.4
  TOP w0.14: v4(345.85,56.1) 346.15,55.8 U21.Y6
  BOTTOM w0.14: R67048.1 v4(345.85,56.1)
TBT_DPSRC_HPD: length 5.8
  TOP w0.079: 348.85,60.23 349.44,59.64 349.62,59.64 v1(349.64,59.62) 349.88,59.38 351.98,59.38 352.35,59.01 U21.G1
  TOP w0.14: R20689.1 348.38,60.7 348.85,60.23
TBT_EE_CLK: length 72.1
  TOP w0.079: 344.36,56.97 344.71,56.62 345.22,56.62 U21.AB4
  TOP w0.14: v1(343.51,57.33) 343.87,56.97 344.36,56.97 ; v1(339.59,68.83) 339.59,68.9 339.29,69.2 U13076.6
  IN4 w0.089: v1(339.59,68.83) 339.16,68.39 338.45,68.39 337.08,67.03 337.08,63.22 336.32,62.45 336.32,59.09 339.44,55.97 342.16,55.97 v1(343.51,57.33) 345.9,57.33 346.35,57.78 347.21,57.78 347.86,57.13 353.71,57.13 354.59,56.25 354.59,48.4 356.15,46.83 356.15,45.71 358.19,43.68 358.19,40.21 358.67,39.72 358.67,36.97 360.22,35.42 361.08,35.42 363.75,32.76 363.75,31.57 v1(365.19,30.13)
  BOTTOM w0.14: R67117.1 364.76,28.67 364.64,28.79 364.64,29.57 v1(365.19,30.13)
TBT_EE_CLK_R: length 2.8
  TOP w0.14: U13155.A3 365.98,25.49 365.86,25.37 364.69,25.37 364.31,24.98 v1(364.15,24.98)
  BOTTOM w0.14: v1(364.15,24.98) 364.18,25.01 R67117.2
TBT_EE_CS_N: length 71.5
  TOP w0.079: 344.38,57.69 344.57,57.5 344.57,57.5 344.76,57.3 U21.AC3
  TOP w0.081: 365.78,25.09 365.87,25.09 366.02,25.24 366.28,25.24 366.53,25.49 U13155.B3
  TOP w0.14: 344.38,57.69 344.26,57.81 344.13,57.81 343.94,58 343.94,58.01 343.29,58.66 v1(343.29,58.85) ; v1(364.15,23.97) 364.36,24.17 364.36,24.38 365.07,25.09 365.78,25.09 ; U13076.1 336.75,63.84 v1(336.7,63.9)
  IN2 w0.089: v1(336.7,63.9) 337.03,64.23 337.64,64.23 337.9,63.98 337.9,63.68 339.94,61.64 340.14,61.44 340.14,61.04 340.62,60.56 340.8,60.56 342.49,58.87 343.26,58.87 v1(343.29,58.85)
  IN4 w0.089: v1(343.29,58.85) 343.29,59.13 344.09,59.94 344.8,59.94 345.56,60.7 347.14,60.7 347.54,60.29 347.54,59.54 348.03,59.06 348.03,58.56 348.33,58.26 354.18,58.26 354.8,57.63 356.81,57.63 357.02,57.41 357.02,56.7 357.24,56.48 357.24,54.55 357.4,54.39 357.4,50.22 357.84,49.79 357.84,47.2 359.53,45.51 359.53,42.89 360.19,42.23 360.19,40.53 360.4,40.32 360.4,39.31 360.06,38.97 360.06,37.44 360.62,36.87 360.83,36.87 361.44,36.26 361.44,35.98 v1(361.61,35.81)
  IN5 w0.089: v1(364.15,23.97) 364.15,24.32 365.09,25.26 365.09,28.34 364.39,29.04 364.39,32.18 363.37,33.2 363.37,34.02 361.61,35.78 v1(361.61,35.81)
  BOTTOM w0.14: R20855.1 v1(336.7,63.9)
TBT_EE_DI: length 70.2
  TOP w0.079: 344.38,58.09 344.67,57.81 344.67,57.62 344.76,57.53 345.22,57.53 U21.AB3
  TOP w0.081: U13155.B4 366.53,25.99 366.28,25.74 365.96,25.74 365.89,25.67 365.75,25.67
  TOP w0.14: v1(343.95,58.85) 343.95,58.52 344.38,58.09 ; v1(340.25,68.83) 340.56,69.13 U13076.5 ; v1(364.15,25.85) 364.23,25.92 364.92,25.92 365.17,25.67 365.75,25.67
  IN2 w0.089: v1(343.95,58.85) 343.54,59.26 343.13,59.26 340.7,61.69 340.26,61.69 338.16,63.79 338.16,64.3 337.98,64.48 337.98,67.97 338.35,68.35 339.78,68.35 v1(340.25,68.83)
  IN4 w0.089: v1(360.97,36.03) 360.97,36.18 360.6,36.55 360.44,36.55 359.54,37.45 359.54,41.09 359.84,41.39 359.84,42.21 359.15,42.89 359.15,45.2 357.35,47.01 357.35,49.9 357.14,50.11 357.14,54.28 356.3,55.11 356.3,56.4 355.7,57 355.05,57 354.07,57.99 348.22,57.99 347.76,58.45 347.76,58.95 347,59.71 345.31,59.71 345.1,59.5 344.6,59.5 v1(343.95,58.85)
  IN5 w0.089: v1(360.97,36.03) 360.97,35.9 363.11,33.76 363.11,33.09 364.12,32.07 364.12,28.93 364.74,28.31 364.74,26.43 v1(364.15,25.85)
TBT_EE_DO: length 64
  TOP w0.079: 344.38,57.28 344.82,56.84 U21.AC4
  TOP w0.14: U13155.A4 365.41,25.99 364.87,26.53 v1(364.15,26.53) ; 344.38,57.28 344.23,57.43 344.13,57.43 343.56,58 343.2,58 v1(342.79,58.41) ; U13076.2 338.02,63.31 v1(337.51,63.82)
  IN2 w0.089: v1(342.79,58.41) 342.55,58.41 340.67,60.29 340.51,60.29 339.87,60.93 339.87,61.33 337.51,63.69 v1(337.51,63.82)
  IN4 w0.089: v1(360.34,36.16) 359.27,37.23 359.27,39.97 358.78,40.46 358.78,45.01 357.04,46.75 357.04,49.35 356.87,49.52 356.87,54.17 356.04,55 356.04,56.25 355.6,56.68 355,56.68 353.96,57.73 348.11,57.73 347.49,58.34 347.49,58.84 346.89,59.44 346.26,59.44 345.23,58.41 v1(342.79,58.41)
  IN5 w0.089: v1(360.34,36.16) 360.34,35.63 360.51,35.47 361.03,35.47 362.84,33.65 362.84,32.98 363.72,32.09 363.72,26.97 v1(364.15,26.53)
  BOTTOM w0.14: v1(337.51,63.82) 337.84,64.15 R20854.1
TBT_EE_WP_N: length 17.2
  TOP w0.079: 346.93,60.04 347.35,59.62 347.35,58.51 347.29,58.45 U21.V1
  TOP w0.14: 346.93,60.04 346.93,60.09 v1(346.81,60.21) ; U13076.3 339.29,63.29 v1(338.63,63.95)
  IN2 w0.089: v1(338.63,63.95) 340.18,65.5 342.29,65.5 344.6,63.18 346.25,63.18 346.73,62.7 346.73,60.29 v1(346.81,60.21)
  BOTTOM w0.14: R20852.2 338.63,64.24 v1(338.63,63.95)
TBT_FORCE_PWR: length 86.2
  TOP w0.14: U21.H4 v4(352.32,56.74) ; R67215.2 302.35,79.87 302.74,80.26 302.74,80.86 303.42,81.55 v1(303.42,81.65)
  IN2 w0.089: v1(303.42,81.65) 304.11,82.34 318.59,82.34 319.17,81.75 319.17,81.47 319.52,81.12 322.9,81.12 323.41,81.63 330.09,81.63 331.87,83.4 333.78,83.4 334.03,83.15 334.03,82.13 333.52,81.63 333.52,79.37 336.34,76.55 338.65,76.55 339.91,75.29 342.17,75.29 342.56,74.9 342.56,74.5 342.06,74 342.06,73.17 341.27,72.38 341.27,68.04 342.2,67.1 345.19,67.1 345.36,67.28 347.2,67.28 348.13,66.36 348.13,62.25 348.94,61.43 350.26,61.43 352.42,59.27 353.52,59.27 353.74,59.49 353.74,60.24 v1(354.02,60.52)
  BOTTOM w0.14: v4(352.32,56.74) 352.19,56.87 R20863.1 352.55,57.53 352.67,57.65 352.67,58.56 351.94,59.29 351.83,59.29 351.5,59.62 351.5,60.87 351.84,61.21 R67055.1 R67156.2 354.02,60.78 v1(354.02,60.52)
TBT_FORCE_PWR_NL5: length 7.1
  TOP w0.127: U13113.AE45 303.73,75.91
  TOP w0.14: 303.73,75.91 303.73,76.97 302.8,77.9 302.36,77.9 302,78.26 v1(302,78.56) 301.9,78.65 R67215.1 301.9,79.95 302.03,80.08 R67239.1
TBT_FORCE_PWR_WS1: length 61.3
  TOP w0.14: v1(306.19,75.53) 306.6,75.12 306.6,74.35 306.67,74.28 U13113.AL44
  IN1 w0.089: v1(353.69,62.7) 353.87,62.88 353.87,65.73 353.12,66.47 348.39,66.47 347.75,67.1 342.43,67.1 341.35,66.03 339.37,66.03 338.73,66.67 338.07,66.67 337.82,66.42 337.39,66.42 336.41,67.4 336.41,68.17 335.74,68.84 333.42,68.84 333.15,69.11 331.57,69.11 330.53,70.15 330.35,70.33 330.13,70.55 328.3,70.55 328.16,70.7 328.15,70.7 327.93,70.93 327.93,72.16 325.35,74.74 321.11,74.74 320.74,74.38 319.41,74.38 318.66,73.63 318.16,73.63 317.65,74.13 315.74,74.13 314.83,75.05 310.48,75.05 309.77,75.76 307.94,75.76 307.69,76.01 306.67,76.01 v1(306.19,75.53)
  BOTTOM w0.14: v1(353.69,62.7) 353.59,62.6 R67156.1
TBT_HPD: length 4.3
  TOP w0.14: U13025.32 336.86,55.1 v1(336.88,55.12)
  BOTTOM w0.14: v1(336.88,55.12) 336.12,55.12 335.55,54.55 R20829.1 R20830.1
TBT_HTPLG_NL5: length 49.7
  TOP w0.102: 307.59,75.81 307.74,75.66 307.74,74.04 U13113.AN44
  TOP w0.14: v1(338.45,67.81) 338.45,66.95 339.47,65.93 D73.2 342.29,65.34 342.78,64.85 343.19,64.85 343.61,64.43 R67220.1 ; 307.59,75.81 307.11,76.29 306.98,76.29 v1(306.32,76.95) 305.96,77.31 R17808.1
  IN1 w0.089: v1(306.32,76.95) 306.34,76.93 309.27,76.93 309.35,76.85 319.51,76.85 320.82,75.53 325.67,75.53 328.82,72.38 328.82,71.8 329.17,71.45 329.57,71.45 329.77,71.65 331.18,71.65 331.38,71.45 331.67,71.16 332.21,71.16 333.74,69.63 334.06,69.63 334.33,69.9 337.48,69.9 338.45,68.93 v1(338.45,67.81)
TBT_HTPLG_WS1: length 41.7
  TOP w0.14: v1(346.43,64.25) 345.86,63.69 R67192.2
  IN2 w0.089: v1(346.43,64.25) 346.43,66.55 345.87,67.1 345.55,67.1 345.38,66.93 342.13,66.93 341.09,67.96 341.09,72.48 341.83,73.22 341.83,74.02 342.39,74.58 342.39,74.82 342.1,75.11 339.55,75.11 338.3,76.37 336.27,76.37 332.67,79.96 330.13,79.96 v1(329.56,79.39)
  BOTTOM w0.14: v1(329.56,79.39) 329.56,78.49 330.22,77.83 330.22,72.79 v1(330.5,72.51) 330.22,72.23 330.22,70.86 R67217.2
TBT_I2C_SCL: length 56.1
  TOP w0.079: U21.U2 347.97,57.99 347.97,58.92 348.28,59.22 348.56,59.22 v1(348.71,59.38)
  TOP w0.081: 367.37,24.08 367.37,24.74 U13155.D2
  TOP w0.14: v1(348.71,59.38) 348.71,59.58 347.37,60.93 R20860.2 ; v1(367.08,23.11) 367.08,23.3 367.37,23.59 367.37,24.08
  IN2 w0.089: v1(361.16,42.82) 360.05,41.71 360.05,40.77 361.87,38.95 361.87,37.91 362.22,37.56 362.22,36.7 362.69,36.23 362.69,35.62 365.18,33.13 365.18,30.68 365.58,30.28 365.58,28.48 366.05,28.02 366.05,25.55 367.08,24.52 v1(367.08,23.11)
  IN4 w0.089: v1(361.16,42.82) 360.65,43.32 360.65,44.37 360.91,44.63 360.91,45.52 360.1,46.33 359.38,46.33 358.31,47.39 358.31,49.98 357.91,50.38 357.91,54.64 357.71,54.83 357.71,56.68 357.49,56.9 357.49,57.69 357.08,58.1 355,58.1 354.37,58.73 352.4,58.73 351.75,59.38 v1(348.71,59.38)
TBT_I2C_SDA: length 58.4
  TOP w0.079: U21.U1 347.62,58.35 347.62,59.17 v1(348.05,59.61)
  TOP w0.14: R20859.2 346.61,61.04 v1(348.05,59.61) ; U13155.D1 367.62,23.02 367.05,22.44 v1(367.05,22.34)
  IN2 w0.089: v1(360.98,42) 360.98,41.36 362.34,40 362.34,38.1 363.34,37.11 363.34,35.65 366.05,32.94 366.05,28.68 366.52,28.22 366.52,25.75 367.56,24.71 367.56,22.85 v1(367.05,22.34)
  IN4 w0.089: v1(360.98,42) 360.98,42.08 361.61,42.71 361.61,43.17 361.13,43.65 361.13,44.16 361.38,44.41 361.38,45.71 360.16,46.93 359.61,46.93 358.78,47.76 358.78,50.18 358.41,50.54 358.41,54.6 358.76,54.95 358.76,57.53 357.72,58.57 355.19,58.57 354.42,59.34 352.63,59.34 352.13,59.85 348.29,59.85 v1(348.05,59.61)
TBT_JTAG_TCK: length 9
  TOP w0.14: v4(347.77,56.74) U21.T4
  BOTTOM w0.14: R20846.2 342.64,59.88 344.49,59.88 v1(345,60.39) 345.08,60.39 346.34,59.14 346.34,58.43 346.99,57.77 347.3,57.77 347.77,57.3 v4(347.77,56.74)
TBT_JTAG_TDI: length 5.6
  TOP w0.14: U21.Y4 v4(346.47,56.74)
  BOTTOM w0.14: v4(346.47,56.74) 346.47,56.87 345.97,57.37 344.95,57.37 344.44,57.88 v1(344.11,57.88) 342.38,57.88 R454.2
TBT_JTAG_TDO: length 7.5
  TOP w0.14: U21.W4 v4(347.12,56.74)
  BOTTOM w0.14: R20847.2 342,58.87 342.45,59.32 344.25,59.32 344.47,59.1 344.47,58.59 345.18,57.88 v1(345.51,57.88) 345.97,57.88 347.11,56.74 v4(347.12,56.74)
TBT_JTAG_TMS: length 6.8
  TOP w0.14: v4(347.13,57.36) 347.43,57.06 U21.V4
  BOTTOM w0.14: v4(347.13,57.36) 347.01,57.36 346.06,58.31 346.06,58.75 v1(345.56,59.25) 345.21,59.6 342.07,59.6 R20845.2
TBT_MAINON: length 7.5
  TOP w0.079: 353.63,60.23 353.66,60.19 353.66,59.07 353.5,58.91 353.5,57.99 U21.D2
  TOP w0.14: 353.63,60.23 353.36,60.49 v1(353.36,60.62) 353.36,60.9 353.49,61.03 R20849.1
  BOTTOM w0.14: R67193.1 R67056.1 354.6,60.8 354.71,60.7 v1(354.71,60.34) 354.42,60.06 353.82,60.06 353.36,60.52 v1(353.36,60.62)
TBT_RBIAS: length 1.1
  TOP w0.14: U21.J6 v4(351.67,55.44)
  BOTTOM w0.14: v4(351.67,55.44) 351.72,55.49 R402.1
TBT_RESET_N: length 46.2
  TOP w0.14: v4(352.97,56.74) U21.F4
  IN2 w0.089: v4(352.97,56.74) 351.09,58.62 351.09,59.99 v1(350.74,60.34)
  IN3 w0.079: v4(352.97,56.74) 353.31,56.4 353.76,56.4 354.38,55.79 354.38,52.19 354.71,51.86 354.71,50.33 355.21,49.83 356.86,49.83 357.48,49.2 357.48,46.23 v1(357.09,45.84)
  BOTTOM w0.14: R67141.2 367.3,34.23 367.02,34.51 367.02,35.17 366.62,35.58 366.62,36.46 366.12,36.96 364.32,36.96 363.44,36.08 362.73,36.08 362.3,36.52 362.3,40.91 362.15,41.06 361.21,41.06 359.67,42.61 358.71,42.61 358.08,41.98 356.86,41.98 356.55,42.29 356.55,45.3 v1(357.09,45.84) ; v1(350.74,60.34) 350.24,59.83 349.09,59.83 348.38,60.54 R67051.1
TBT_RSENSE: length 1.4
  TOP w0.14: v4(352.32,56.09) U21.H6
  BOTTOM w0.14: R402.2 352.99,55.49 352.39,56.09 v4(352.32,56.09)
TBT_SPI_HOLD#: length 3.3
  TOP w0.14: U13076.7 338.02,70.43 v1(338.8,71.2)
  BOTTOM w0.14: v1(338.8,71.2) 338.8,70.62 v1(338.62,70.45) 338.62,70 R20853.2
TBT_SRC0_CFG1: length 6.3
  TOP w0.079: 345.33,59.49 345.84,58.98 345.84,58.3 U21.AA1
  TOP w0.14: 345.33,59.49 345.2,59.62 343.21,59.62 342.65,60.18 342.65,60.44 R20868.1 341.9,61.19 v1(341.9,61.74)
TBT_SRC0_DDC_CLK: length 7.1
  TOP w0.079: 345.45,59.68 346,59.13 346,58.6 346.14,58.45 346.14,57.99 U21.Y2
  TOP w0.14: 345.45,59.68 345.24,59.88 343.63,59.88 v1(343.17,60.34) R20858.2
  BOTTOM w0.14: v1(343.17,60.34) R67152.2 342.67,60.99 v1(342.36,61.31)
TBT_SRC0_DDC_DATA: length 4.9
  TOP w0.079: 345.4,60.04 346.21,59.22 346.21,58.6 346.37,58.45 U21.Y1
  TOP w0.14: 345.4,60.04 345.27,60.16 344.37,60.16 v1(344.19,60.34) R20857.2
  BOTTOM w0.14: v1(344.19,60.34) R67151.2
TBT_TEST_EN: length 4.8
  TOP w0.079: U21.E1 v1(353.27,59.33) 352.92,59.33 352.2,60.05 351.75,60.05 351.57,60.23
  TOP w0.14: 351.57,60.23 351.51,60.29 351.51,60.72 351.99,61.21 R396.2
TBT_TEST_PWRGD: length 3.9
  TOP w0.079: 344.38,56.16 344.38,56.16 345.22,56.16 345.44,56.38 U21.AB5
  TOP w0.14: 344.38,56.16 344.26,56.29 343.49,56.29 343.17,56.61 342.54,56.61 342.17,56.99 R20850.2
TBT_XTL25_IN: length 6.3
  TOP w0.079: U21.D22 353.81,48.56 353.96,48.41 353.96,47.6 354.1,47.46
  TOP w0.14: 354.1,47.46 354.73,46.83 354.73,46.07 354.98,45.82 C13512.2 354.71,45.33 354.55,45.17 354.55,45.05 355.01,44.59 355.37,44.59 355.51,44.45 355.51,43.97 Y3.1
TBT_XTL25_OUT: length 6.3
  TOP w0.14: U21.D23 353.73,47.12 354.25,46.6 v1(354.25,46.28) 354.25,45.6 C94581.2 354.03,45.28 354.03,44.84 354.68,44.19 354.68,43.4 354.01,42.72 Y3.3
TBTA_ACE_GPIO0: length 64.6
  TOP w0.081: 366.2,24.21 366.38,24.39 366.38,24.74 U13155.B2
  TOP w0.14: v1(366.42,19.99) 366.3,19.99 365.8,19.5 R67180.1 365.27,19.9 365.15,20.03 R67133.1 365.56,20.82 365.73,21 365.73,21.73 365.04,22.42 365.04,23.31 365.95,24.21 366.2,24.21
  IN2 w0.089: v1(360.19,42.79) 359.18,42.79 358.54,42.16 358.54,41.24 356.61,39.31 356.61,38.35 362.35,32.6 363.37,32.6 363.75,32.22 363.75,21.94 365.02,20.67 365.91,20.67 366.42,20.15 v1(366.42,19.99)
  IN3 w0.079: v1(353.23,59.96) 356.14,59.96 356.29,59.81 356.9,59.81 357.53,59.18 359.4,59.18 360.29,58.28 360.29,54.75 359.97,54.43 359.97,51.52 361.46,50.03 361.46,44.95 360.19,43.68 v1(360.19,42.79)
  BOTTOM w0.14: R67154.2 354.08,59.55 353.92,59.71 353.49,59.71 v1(353.23,59.96)
TBTA_ACE_GPIO1: length 6.8
  TOP w0.081: 366.8,24.08 366.87,24.15 366.87,24.74 U13155.C2
  TOP w0.14: 366.8,24.08 366.8,23.98 366.03,23.21 366.03,22.6 366.77,21.86 366.77,20.32 366.91,20.18 366.91,19.59 366.68,19.36 R67116.2
TBTA_ACE_GPIO2: length 6.6
  TOP w0.14: v1(367.79,28.49) 367.62,28.65 U13155.D10
  BOTTOM w0.14: v1(367.79,28.49) 367.79,28.82 364.38,32.22 R67185.2
TBTA_ACE_GPIO3: length 3.2
  TOP w0.14: U13155.G11 369.12,30.71 368.94,30.9 368.94,31.58 368.8,31.72 368.8,32.27 T91.1
TBTA_ACE_GPIO6: length 6.6
  TOP w0.081: 368.85,29.83 368.85,29.63 368.88,29.6 368.88,29.24 U13155.G10
  TOP w0.14: v1(368.25,31.9) 368.25,31.61 368.6,31.26 368.6,30.85 368.85,30.6 368.85,29.83
  BOTTOM w0.14: v1(369.87,32.53) 369.87,33.04 R67145.1 369.21,33.27 369.04,33.1 R67144.1 368.62,32.28 v1(368.25,31.9)
TBTA_ACE_GPIO7: length 8.1
  TOP w0.14: v1(367.15,27.23) 367.41,27.49 U13155.D7
  BOTTOM w0.14: v1(367.15,27.23) 366.89,27.23 366.54,26.89 366.16,26.89 365.78,26.51 365.78,25.37 364.76,24.35 v1(364.76,23.59) 364.76,22.95 365.27,22.44 R67132.1
TBTA_ACE_GPIO8: length 8.2
  TOP w0.14: U13155.H6 369.89,26.99 v1(370.07,26.81)
  BOTTOM w0.14: R67115.2 370.66,30.47 v1(369.89,29.71) 368.94,28.76 368.94,27.92 369.72,27.14 369.74,27.14 v1(370.07,26.81)
TBTA_AUX_N: length 2.5
  TOP w0.14: U21.W15 346.8,51.86 v4(347.13,51.54)
  BOTTOM w0.14: v4(347.13,51.54) 346.97,51.39 346.97,51.09 346.2,50.32 345.9,50.32 C94569.1
TBTA_AUX_P: length 2.5
  TOP w0.14: v4(346.48,51.54) 346.53,51.59 346.53,51.68 346.43,51.78 346.23,51.78 U21.Y15
  BOTTOM w0.14: v4(346.48,51.54) 346.59,51.54 346.65,51.48 346.65,51.22 346.07,50.64 345.87,50.64 345.81,50.69 C94568.1
TBTA_CA2HD_0_N: length 30.4
  TOP w0.079: U21.A21 355.06,49.02 arc(354.98,49.06) 354.95,49.14 354.95,49.15 arc(354.98,49.23) 355.05,49.26 355.16,49.26 arc(355.31,49.23) 355.44,49.15 355.6,48.98 arc(355.64,48.95) 355.69,48.95 355.79,48.95 arc(355.82,48.95) 355.84,48.97 355.9,49.03 355.92,49.03
  TOP w0.14: v1(356.56,49.29) 356.41,49.14 arc(356.28,49.06) 356.13,49.03 355.97,49.03 355.92,49.03 ; CN18.B10 380.85,41.63 arc(380.79,41.64) v4(380.74,41.67)
  BOTTOM w0.14: v1(356.56,49.29) 356.71,49.14 arc(356.86,49.04) 357.03,49.01 359.24,49.01 arc(360.19,48.82) 361,48.28 363.41,45.88 365.46,43.82 366.05,43.23 arc(367.64,42.17) 369.51,41.79 372.74,41.79 arc(372.97,41.89) 373.07,42.12 D13031.2 373.17,42.1 arc(373.51,41.87) 373.92,41.79 374.42,41.79 arc(374.68,41.74) 374.89,41.59 arc(374.97,41.54) 375.07,41.52 380.38,41.52 arc(380.57,41.56) v4(380.74,41.67)
TBTA_CA2HD_0_P: length 30.4
  TOP w0.079: U21.B21 354.83,48.84 arc(354.89,48.8) 354.96,48.79 355.79,48.79 arc(355.82,48.78) 355.84,48.76 355.9,48.71 355.92,48.71
  TOP w0.14: 355.92,48.71 356.1,48.71 356.2,48.71 arc(356.26,48.7) 356.3,48.67 v1(356.55,48.42) ; v4(380.74,41.13) CN18.B11
  BOTTOM w0.14: v4(380.74,41.13) arc(380.66,41.18) 380.55,41.2 375.07,41.2 arc(374.85,41.25) 374.67,41.37 arc(374.56,41.44) 374.42,41.47 373.79,41.47 arc(373.5,41.41) 373.26,41.25 D13026.2 373.07,41.18 arc(372.98,41.39) 372.77,41.48 369.51,41.48 arc(367.52,41.87) 365.83,43 365.24,43.59 363.18,45.65 360.78,48.05 arc(360.07,48.52) 359.24,48.69 357.22,48.69 arc(356.86,48.62) v1(356.55,48.42)
TBTA_CA2HD_1_N: length 29.9
  TOP w0.079: U21.B15 354.73,51.7 arc(354.89,51.59) 355.09,51.55 355.2,51.55 arc(355.35,51.6) 355.47,51.69 355.59,51.8 arc(355.6,51.81) 355.61,51.82 arc(355.69,51.86) 355.77,51.88 355.96,51.88 arc(356.07,51.86) 356.15,51.8
  TOP w0.14: 356.15,51.8 356.26,51.8 arc(356.57,51.86) 356.83,52.04 356.86,52.07 arc(357.04,52.18) 357.25,52.23 357.78,52.23 arc(358.24,52.13) 358.64,51.87 362.99,47.52 arc(363.52,47.09) 364.13,46.76 arc(364.33,46.7) 364.55,46.68 367.51,46.68 arc(367.68,46.61) 367.75,46.44 D13030.2 368.06,46.58 arc(368.19,46.66) 368.34,46.68 arc(368.37,46.68) 368.4,46.68 368.5,46.68 arc(368.64,46.65) 368.76,46.57 369.17,46.16 370.41,44.93 arc(371.94,43.9) 373.76,43.54 374.91,43.54 arc(375.26,43.57) 375.6,43.68 376.07,43.87 arc(376.82,44.27) 377.48,44.82 377.78,45.11 arc(378.18,45.38) 378.66,45.48 379.29,45.48 arc(379.33,45.46) 379.36,45.44 379.37,45.43 arc(379.43,45.39) 379.5,45.38 CN18.A10
TBTA_CA2HD_1_P: length 29.8
  TOP w0.079: U21.A15 355.01,51.78 arc(354.89,51.9) 355.01,52.02 355.16,52.02 arc(355.27,52) 355.37,51.93 arc(355.43,51.91) 355.49,51.93 355.51,51.94 arc(355.63,52.01) 355.77,52.04 355.87,52.04 arc(355.92,52.05) 355.96,52.07 355.98,52.09 arc(356.01,52.11) 356.05,52.12 356.15,52.12
  TOP w0.14: CN18.A11 379.28,45.87 arc(379.19,45.86) 379.11,45.8 arc(379.09,45.8) 379.06,45.79 378.66,45.79 arc(378.06,45.68) 377.56,45.34 377.26,45.04 arc(376.65,44.54) 375.95,44.16 375.48,43.97 arc(375.2,43.89) 374.91,43.86 373.76,43.86 arc(372.07,44.19) 370.63,45.15 369.81,45.98 368.99,46.8 arc(368.76,46.95) 368.5,47 368.4,47 arc(368.18,47.04) 368,47.17 D13027.2 367.75,47.24 arc(367.68,47.06) 367.51,46.99 364.55,46.99 arc(364.4,47.01) 364.25,47.05 arc(363.7,47.35) 363.21,47.75 358.86,52.09 arc(358.37,52.43) 357.78,52.54 357.25,52.54 arc(356.92,52.48) 356.64,52.29 356.61,52.26 arc(356.45,52.15) 356.26,52.12 356.15,52.12
TBTA_CC1: length 24.7
  TOP w0.254: U13155.K9 U13155.L9 371.42,28.49 372.21,29.28 372.21,30.06 371.83,30.45 v1(371.83,30.67)
  IN4 w0.508: v1(371.83,30.67) 371.72,30.78 371.72,32.76 372.54,33.57 373.17,33.57 374.33,34.72 374.33,37.32 373.4,38.24 373.4,40.89 374.38,41.87 376.69,41.87 377.87,43.04 378.84,43.04 v1(378.86,43.02)
  BOTTOM w0.203: D13034.2 377.72,42.76 377.97,43.02 v1(378.86,43.02)
  BOTTOM w0.508: v1(371.83,30.67) 371.83,30.75 371.52,31.06 C96019.1
TBTA_CC2: length 29.3
  TOP w0.254: v1(371.62,29.76) 371.62,29.4 371.21,28.99 U13155.L10 U13155.K10 ; CN18.B5 381.01,44.13 380.89,44.24 380.77,44.24 v4(380.74,44.26)
  IN4 w0.457: 379.97,44.65 380.35,44.26 v4(380.74,44.26)
  IN4 w0.508: 379.97,44.65 379.97,45.25 379.68,45.54 378.21,45.54 375.52,42.84 373.45,42.84 370.5,39.89 370.5,36.67 371.13,36.05 371.13,30.26 v1(371.62,29.76)
  BOTTOM w0.203: D13035.2 382.14,43.91 381.78,44.26 v4(380.74,44.26)
  BOTTOM w0.508: C96018.1 371.62,29.18 v1(371.62,29.76)
TBTA_DBG_CTL1: length 5.5
  TOP w0.14: v1(367.7,25.47) 367.7,25.57 U13155.E4
  BOTTOM w0.14: v1(367.7,25.47) 367.43,25.19 367.43,23.96 367.84,23.55 367.84,22.32 v1(368.09,22.06) 367.56,21.53 R67140.1
TBTA_DBG_CTL2: length 6.4
  TOP w0.14: U13155.D5 367.62,26.41 v1(367.15,25.94)
  BOTTOM w0.14: R67139.1 366.64,21.27 367.56,22.19 367.56,23.38 v1(366.92,24.02) 367.15,24.25 v1(367.15,25.94)
TBTA_DEBUG1: length 12.1
  TOP w0.14: R67124.1 373.7,31 373.45,30.75 373.45,24.12 373.68,23.89 373.68,23.26 373.52,23.1 372.7,23.1 372.01,23.79 372.01,24 371.12,24.89 U13155.L2
TBTA_DEBUG2: length 5.1
  TOP w0.081: U13155.K2 370.37,24.74 370.37,24.3 370.72,23.95
  TOP w0.14: 370.72,23.95 370.72,23.8 371.31,23.21 371.56,23.21 372.33,22.44 372.33,22.04 372.93,21.44 R67125.1
TBTA_DIG_AUD_N: length 5.1
  TOP w0.081: U13155.K3 370.88,25.24 371.23,25.24 371.5,24.98
  TOP w0.14: 371.5,24.98 371.5,24.83 372.23,24.09 372.23,23.97 372.7,23.5 373.19,23.5 v1(373.19,23.51)
  BOTTOM w0.14: v1(373.19,23.51) 373.19,23.5 372.89,23.2 372.57,23.2 v1(372.56,23.21) R67123.1
TBTA_DIG_AUD_P: length 5.7
  TOP w0.14: v1(372.7,24.12) 372.52,24.12 371.9,24.74 371.9,24.88 371.29,25.49 U13155.L3
  BOTTOM w0.14: v1(371.5,26.66) 371.34,26.51 371.34,25.75 371.63,25.46 R67122.1 371.63,24.6 372.1,24.12 v1(372.7,24.12)
TBTA_DPSRC_AUX_N: length 51.7
  TOP w0.081: v1(370.86,22.45) 370.86,22.9 370.35,23.41 370.35,23.84 369.87,24.32 369.87,24.74 U13155.J2
  TOP w0.14: v1(370.86,22.45) 371.37,21.94 371.37,21.69 R67127.1
  IN2 w0.089: v1(344.47,50.3) 344.71,50.54 344.78,50.54 346.86,48.45 350.9,48.45 351.35,48 354.95,48 356.21,46.73 356.81,46.73 360.21,43.34 361.3,43.34 362.27,42.36 362.27,41.27 363.21,40.33 363.21,38.03 363.88,37.37 363.88,35.91 366.54,33.24 366.54,30.06 367.3,29.3 369.85,29.3 370.48,28.67 370.48,23.59 370.86,23.21 v1(370.86,22.45)
  BOTTOM w0.14: C94569.2 345.13,50.47 344.64,50.47 v1(344.47,50.3)
TBTA_DPSRC_AUX_P: length 51.8
  TOP w0.081: v1(371.49,22.57) 371.27,22.57 371.07,22.77 371.07,22.92 370.51,23.48 370.51,23.91 370.06,24.36 370.06,24.43 U13155.J1
  TOP w0.14: R67126.1 371.7,21.87 371.7,22.37 v1(371.49,22.57)
  IN2 w0.089: v1(371.49,22.57) 371.04,23.03 371.04,23.29 370.66,23.66 370.66,28.74 369.92,29.48 367.38,29.48 366.72,30.14 366.72,33.31 364.05,35.98 364.05,37.45 363.39,38.11 363.39,40.4 362.45,41.34 362.45,42.43 361.37,43.51 360.28,43.51 356.88,46.91 356.29,46.91 355.02,48.18 351.43,48.18 350.97,48.63 346.93,48.63 344.85,50.71 344.76,50.71 v1(344.47,51)
  BOTTOM w0.14: v1(344.47,51) 344.69,50.79 345.15,50.79 C94568.2
TBTA_HD2CA_0_N: length 25.5
  TOP w0.14: CN18.A3 379.21,41.87 arc(379.14,41.86) 379.09,41.83 arc(379.04,41.79) 378.99,41.78 374.07,41.78 arc(373.53,41.89) D13029.2 373.07,41.98 arc(373.06,41.93) 373.03,41.89 372.97,41.83 arc(372.93,41.8) 372.88,41.79 369.36,41.79 arc(367.89,42.09) 366.64,42.92 359.7,49.86 arc(359.46,50.02) 359.17,50.08 358.77,50.08 arc(358.44,50.15) C94571.1
TBTA_HD2CA_0_P: length 25.5
  TOP w0.14: CN18.A2 379.25,41.38 arc(379.19,41.39) 379.14,41.42 arc(379.09,41.45) 379.03,41.47 374.05,41.47 arc(373.52,41.36) D8599.2 373.07,41.24 arc(373.06,41.27) 373.06,41.3 arc(372.97,41.43) 372.82,41.48 369.36,41.48 arc(367.77,41.79) 366.42,42.69 359.48,49.63 arc(359.34,49.73) 359.17,49.76 358.62,49.76 arc(358.37,49.71) C94572.1
TBTA_HD2CA_1_N: length 27.3
  TOP w0.14: CN18.B3 381.21,45.13 arc(380.94,45.18) v4(380.72,45.33)
  BOTTOM w0.14: C94570.1 358.34,50.64 arc(358.4,50.65) 358.44,50.68 358.58,50.82 arc(358.63,50.85) 358.68,50.86 359.05,50.86 arc(359.48,50.77) 359.85,50.53 360.73,49.65 363.37,47.02 arc(363.73,46.77) 364.15,46.69 367.39,46.69 arc(367.64,46.59) 367.75,46.33 D13028.2 368.06,46.58 arc(368.18,46.66) 368.32,46.69 368.35,46.69 arc(368.62,46.64) 368.84,46.49 370.41,44.92 arc(371.92,43.91) 373.7,43.55 375.5,43.55 arc(376.16,43.68) 376.73,44.06 377.55,44.89 arc(378.21,45.33) 378.99,45.48 380.34,45.48 arc(380.55,45.44) v4(380.72,45.33)
TBTA_HD2CA_1_P: length 27.3
  TOP w0.14: v4(380.72,45.88) 380.77,45.82 arc(380.99,45.67) 381.24,45.63 CN18.B2
  BOTTOM w0.14: C13391.1 358.34,51.4 arc(358.4,51.39) 358.44,51.36 358.58,51.22 arc(358.63,51.19) 358.68,51.18 359.05,51.18 arc(359.61,51.07) 360.08,50.75 361.02,49.81 363.59,47.24 arc(363.85,47.07) 364.15,47.01 367.45,47.01 arc(367.66,47.09) 367.75,47.3 D13025.2 368.05,47.11 arc(368.17,47.03) 368.31,47.01 368.35,47.01 arc(368.74,46.93) 369.07,46.71 370.64,45.14 arc(372.04,44.2) 373.7,43.87 375.5,43.87 arc(376.04,43.98) 376.5,44.28 377.33,45.11 arc(378.09,45.62) 378.99,45.8 380.53,45.8 arc(380.63,45.82) v4(380.72,45.88)
TBTA_HPD: length 42.9
  TOP w0.14: U13155.C10 367.12,28.98 v1(367.12,28.53) ; U21.M4 350.05,57.02 v4(350.35,56.72)
  IN1 w0.089: v1(359.3,41.6) 360.77,41.6 361.81,40.56 361.81,38.97 362.43,38.36 362.43,35.59 364.8,33.22 364.8,28.88 365.16,28.53 v1(367.12,28.53)
  IN3 w0.079: v1(359.3,41.6) 358.54,42.36 358.54,46.32 358.29,46.57 358.29,49.06 357.01,50.34 357.01,51.78 356.78,52.02 355.28,52.02 354.85,52.45 354.85,56.41 353.92,57.34 350.98,57.34 v4(350.35,56.72)
  BOTTOM w0.14: v4(350.35,56.72) 350.99,57.36 R20864.1
TBTA_I2C_INT: length 51.9
  TOP w0.14: U13155.C1 367.12,23.89 366.54,23.31 v1(366.54,22.76) ; U21.J4 v4(351.67,56.74)
  IN1 w0.089: v1(366.54,22.76) 366.16,23.14 366.16,25.49 364.66,26.99 364.66,27.97 364.45,28.19 364.45,33.07 362.07,35.45 362.07,36.06 361.92,36.21 361.46,36.21 361.08,36.59 360.4,36.59 360.17,36.82 360.17,37.75 360.83,38.41 360.83,39.89 360.04,40.68 359.42,40.68 358.73,41.37 358.73,44.2 v1(357.7,45.23)
  IN3 w0.079: v4(351.67,56.74) 351.99,57.06 353.75,57.06 354.53,56.28 354.53,52.25 354.86,51.92 354.86,50.4 355.26,50 356.9,50 357.7,49.2 v1(357.7,45.23)
  BOTTOM w0.14: R20861.2 351.18,60.57 351.21,60.53 351.21,60.02 v1(350.72,59.53) 351.22,59.03 351.22,58.7 351.56,58.36 351.56,56.85 v4(351.67,56.74)
TBTA_I2C_IRQ2Z: length 26.8
  TOP w0.081: 365.91,26.74 366.29,26.74 366.54,26.99 U13155.B6
  TOP w0.14: v1(363.89,18.83) 363.64,19.07 363.64,28.28 363.8,28.44 364.59,28.44 364.94,28.08 364.94,27.72 365.78,26.88 365.78,26.88 365.91,26.74
  BOTTOM w0.14: v1(363.89,18.83) 364.05,18.66 369.69,18.66 372.03,16.32 373.22,16.32 373.53,16.63 R67176.1 372.9,16.72 R67131.1 372.46,17.67 372.55,17.76 Q7927.1
TBTA_I2C_IRQ2Z_EC: length 243.8
  TOP w0.14: v1(181.17,55.19) 180.39,54.4 U49.29
  IN3 w0.079: v1(181.17,55.19) 181.55,54.8 182.42,54.8 182.52,54.91 182.52,55.41 182.8,55.69 183.18,55.69 183.47,55.41 190.87,55.41 191.87,54.4 193.4,54.4 194.06,53.74 195.18,53.74 195.68,53.24 198.07,53.24 198.67,52.65 199.49,52.65 199.74,52.4 202.88,52.4 203.19,52.7 205.79,52.7 206.32,53.23 206.32,54.8 206.78,55.26 207.28,55.26 207.61,54.93 207.61,54.83 209.37,53.08 226.05,53.08 226.26,53.28 269.82,53.28 271.72,51.38 286.56,51.38 286.84,51.65 289.28,51.65 290.09,50.84 291.43,50.84 291.54,50.74 291.54,50.73 293.16,49.11 301.47,49.11 302.8,50.43 304.04,50.43 304.6,50.99 305.04,50.99 305.31,50.72 306.46,50.72 307.43,49.76 312.06,49.76 314.34,52.03 317.32,52.03 318.73,50.63 322.67,50.63 322.92,50.38 323.48,50.38 324.82,51.73 328.44,51.73 329.48,50.69 334.33,50.69 334.72,51.07 334.72,51.85 335.27,52.41 340.29,52.41 344.1,56.22 345.03,56.22 346.84,58.04 347.91,58.04 348.1,57.85 354.52,57.85 356.35,56.02 356.35,54.71 357.6,53.46 357.6,50.54 358.92,49.22 358.92,47.07 359.04,46.96 359.04,42.86 360.11,41.79 360.11,40.97 360.56,40.52 361.38,40.52 362.22,39.68 363.06,39.68 364.17,38.58 364.17,35.99 366.36,33.8 366.36,30.83 368.09,29.1 368.6,29.1 369.01,28.69 369.01,26.08 369.39,25.7 369.39,22.41 371.77,20.04 v1(371.84,20.04)
  BOTTOM w0.14: Q7927.3 371.2,19.22 371.04,19.38 371.04,19.88 v1(371.06,19.9) 371.19,20.04 v1(371.84,20.04) 371.84,19.78 372.1,19.52 372.92,19.52 373.12,19.32 373.12,18.74 373.36,18.5 R67175.1 373.63,18.1 373.53,18 R67176.2
TBTA_LDO_BMC: length 3.3
  TOP w0.152: U13155.E1 368.12,22.95 368.19,22.88 368.19,22.43 367.56,21.79 C96010.2
TBTA_LSRX: length 48.5
  TOP w0.081: U13155.K4 370.88,25.74 371.38,25.74 371.61,25.52 371.89,25.52 372.13,25.27 372.13,25.24
  TOP w0.14: v1(372.54,24.76) 372.54,24.83 372.13,25.24 ; U21.A4 355.18,56.78 356.85,56.78 356.98,56.65 358.06,56.65 v1(358.29,56.87) 358.66,57.24 R20867.1
  IN2 w0.089: v1(372.54,24.76) 371.85,24.76 371.27,25.34 371.27,29.02 370.1,30.19 369.21,30.19 368.65,30.75 368.65,35.2 367.48,36.36 366.62,36.36 366.11,36.87 365.71,36.87 365.22,37.36 365.22,38.75 364.21,39.77 364.21,40.93 364.46,41.19 364.46,41.98 359.53,46.91 359.1,46.91 357.22,48.79 357.22,56.53 357.57,56.87 v1(358.29,56.87)
TBTA_LSTX: length 48.3
  TOP w0.081: 372.16,25.54 372.01,25.68 371.67,25.68 371.45,25.9 371.21,25.9 U13155.L4
  TOP w0.14: R403.1 358.82,56.1 358.69,55.97 v1(358.29,55.97) 358.29,56.18 358.13,56.33 356.99,56.33 356.76,56.56 355.28,56.56 U21.A5 ; 372.16,25.54 372.25,25.44 v1(372.56,25.44)
  IN2 w0.089: v1(372.56,25.44) 372.56,25.34 372.16,24.93 371.93,24.93 371.44,25.42 371.44,29.1 370.17,30.37 369.29,30.37 368.83,30.83 368.83,35.27 367.56,36.54 366.69,36.54 366.19,37.05 365.78,37.05 365.4,37.43 365.4,38.83 364.38,39.84 364.38,40.86 364.64,41.11 364.64,42.05 359.61,47.08 359.18,47.08 357.4,48.86 357.4,56.46 357.64,56.7 357.89,56.7 358.11,56.48 358.39,56.48 358.52,56.35 358.52,56.2 v1(358.29,55.97)
TBTA_MRESET: length 18.2
  TOP w0.14: v1(367.21,31.08) 367.39,30.9 367.39,30.72 367.99,30.12 367.99,29.63 U13155.E11 ; Q7923.6 363.62,40.09 363.47,39.94 363.47,39.19 363.37,39.09 Q7923.3 362.19,39.09 R67174.2 362.39,38.52 v1(362.81,38.52)
  IN1 w0.089: v1(367.21,31.08) 367.21,33.78 362.81,38.18 v1(362.81,38.52)
  BOTTOM w0.14: v1(367.21,31.08) 365.4,32.89 R67121.1
