# Allegro board DAZGLMB1ED0 dazglmb1ed0-d-ver a-165 (.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCH_AZ_CODEC_SYNC: length 317.7
  TOP w0.14: v1(319.91,48.86) 319.91,49.21 319.55,49.56 R21104.1 ; U13108.15 31.14,35.14 31.57,35.58 32.53,35.58 v1(32.76,35.35)
  IN2 w0.089: v1(32.76,35.35) 32.21,35.35 32,35.13 32,34.33 32.39,33.94 33.02,33.3 33.02,32.9 33.5,32.43 34.92,32.43 35.55,33.06 35.55,33.92 36.68,35.04 37.23,35.04 37.92,35.73 37.92,36.03 38.32,36.44 38.58,36.44 39.56,35.46 40.96,35.46 41.57,34.85 47.26,34.85 49.01,33.1 49.85,33.1 50.82,32.13 55.39,32.13 55.56,31.96 64.02,31.96 65.53,30.45 72.46,30.45 73.07,31.06 73.07,33.34 76.73,37 76.73,37.74 78.61,39.62 81.13,39.62 82.41,40.89 83.06,40.89 84.68,42.51 86.14,42.51 88.03,44.4 97.3,44.4 97.63,44.73 97.63,45.31 99.71,47.39 179.53,47.39 182.52,44.4 269.23,44.4 271.62,46.8 286.41,46.8 288.53,44.67 289.07,44.67 289.34,44.4 317.76,44.4 319.55,46.19 v1(319.55,46.91)
  BOTTOM w0.14: v1(319.55,46.91) 320.14,46.32 321.08,46.32 321.46,46.7 v1(321.46,47.34) 321.46,47.72 320.92,48.25 320.39,48.25 319.91,48.73 v1(319.91,48.86)
PCH_BLON_EC: length 181.4
  TOP w0.14: U49.88 195.34,62.4 v1(195.4,62.35)
  IN1 w0.089: v1(341.27,87.09) 339.21,85.03 335.53,85.03 334.07,83.57 331,83.57 328.59,81.16 317.5,81.16 317.25,81.41 313.98,81.41 313.49,80.92 309.82,80.92 309.68,81.06 309.09,81.06 308.96,80.92 306.79,80.92 306.34,81.37 306.34,81.75 306.01,82.08 287.06,82.08 285.13,80.15 v1(282.09,80.15)
  IN4 w0.089: v1(282.09,80.15) 282.09,80.6 281.56,81.13 281.56,81.41 280.82,82.14 280.47,82.14 274.94,87.68 220.61,87.68 219.8,88.48 207.45,88.48 205.4,86.43 204.46,86.43 v1(203.98,85.94)
  IN5 w0.089: v1(203.98,85.94) 204.92,85.01 204.92,80.15 203.3,78.54 203.3,72.15 200.5,69.35 200.5,67.3 199.41,66.21 198.88,66.21 198.32,65.65 197.99,65.65 195.97,63.62 195.97,63.25 195.4,62.68 v1(195.4,62.35)
  BOTTOM w0.14: R20965.1 343,90.85 342.03,89.88 342.03,89.52 341.42,88.91 341.42,87.24 v1(341.27,87.09)
PCH_BRIGHT: length 29.9
  TOP w0.14: v1(355.62,82.39) 355.35,82.12 CN2042.33
  IN4 w0.089: v1(341.52,89.88) 343.48,89.88 343.91,89.45 346.58,89.45 351.35,84.67 352.29,84.67 354.3,82.67 354.3,82.21 354.63,81.88 355.11,81.88 v1(355.62,82.39)
  BOTTOM w0.14: R20945.2 R20947.2 336.95,85.32 336.95,86.12 v1(336.77,86.3) 336.77,86.67 337.97,87.86 Q7819.3 338.74,87.86 340.76,89.88 v1(341.52,89.88) ; v1(355.62,82.39) 355.11,81.88 R22070.2
PCH_DISP_ON: length 24.8
  TOP w0.14: R20959.1 321.58,74.39 v1(321.33,74.13) ; U13113.W42 300.22,72.47 v2(300.22,72.25)
  IN1 w0.089: v2(300.22,72.25) 301.98,74.01 307.03,74.01 307.26,74.24 314.12,74.24 315.62,72.74 317.71,72.74 318.26,73.28 318.81,73.28 319.53,74.01 321.2,74.01 v1(321.33,74.13)
PCH_DPST_PWM: length 42.4
  TOP w0.14: U13113.W36 301.26,70.22 v2(301.27,70.23)
  IN2 w0.089: v2(301.27,70.23) 301.72,70.68 301.72,73.17 302.14,73.59 305.43,73.59 306.06,74.23 306.96,74.23 308.27,75.53 310.2,75.53 310.37,75.37 312.62,75.37 313.05,75.8 314.85,75.8 317.48,78.44 320.71,78.44 323.56,81.28 331.27,81.28 332.7,82.71 333.48,82.71 v1(333.59,82.82)
  BOTTOM w0.14: R20945.1 335.62,84.29 v1(334.87,83.53) 334.16,82.82 v1(333.59,82.82)
PCH_LVDS_BLON: length 55.1
  TOP w0.14: v2(301.28,69.61) 300.89,69.61 U13113.W35
  IN2 w0.089: v1(332.89,81.78) 332.05,80.94 323.7,80.94 320.85,78.1 317.63,78.1 314.99,75.46 313.19,75.46 312.76,75.03 309.9,75.03 309.49,74.62 307.84,74.62 307.1,73.88 306.21,73.88 305.57,73.24 302.28,73.24 302.08,73.04 302.08,70.41 v2(301.28,69.61)
  BOTTOM w0.14: v1(332.89,81.78) 332.89,84.21 335.63,86.96 336.32,86.96 337.69,88.33 338.65,88.33 340.71,90.39 341.14,90.39 342.62,91.86 R20951.1
PCH_PECI: length 130.1
  TOP w0.102: 306.4,52.71 306.4,52.76 306.22,53.05 306.22,53.38 306.45,53.61 U13113.AL3
  TOP w0.112: 306.4,52.71 306.4,51.6 306.28,51.48 306.28,50.66 306.09,50.47 v1(306.09,50.08)
  TOP w0.14: R21192.2 305.43,49.55 305.96,50.08 v1(306.09,50.08) ; R563.1 271.17,131.66 v1(271.52,132.02)
  IN1 w0.089: v1(271.52,132.02) 271.52,131.82 272.08,131.26 272.08,131.13 272.8,130.41 272.8,128.08 272.28,127.56 272.28,126.84 271.89,126.45 271.89,125.27 270.38,123.76 268.24,123.76 267.2,122.72 267.2,115.59 269.9,112.89 271.88,112.89 272.61,112.16 272.61,109.31 273.51,108.42 273.51,108.32 274.33,107.5 274.33,106.6 274.92,106 274.92,103.22 276.57,101.58 276.57,98.45 278.98,96.04 278.98,81.47 282.2,78.25 282.2,73.93 287.46,68.67 296.57,68.67 296.69,68.55 298.09,68.55 298.34,68.8 301.52,68.8 304.82,65.5 305.22,65.5 306.73,63.99 306.73,61.99 306.98,61.74 306.98,60.93 307.66,60.24 307.66,59.73 308,59.4 308.12,59.4 308.38,59.15 308.38,58.69 308.77,58.29 308.77,57.87 309.08,57.56 312.38,57.56 313.82,56.11 313.82,53.92 312.5,52.59 309.51,52.59 308.88,51.97 308.88,50.39 307.71,49.22 306.95,49.22 v1(306.09,50.08)
PCH_PWROK: length 204.7
  TOP w0.14: v1(318.87,46.78) 319.04,46.96 R21156.2 ; v1(192.83,58.51) 192.94,58.4 U49.78
  IN5 w0.089: v1(191.84,46.73) 192.34,46.23 193.58,46.23 193.92,46.57 196.57,46.57 197.1,46.04 197.1,45.61 197.35,45.36 257.53,45.36 257.87,45.71 265.84,45.71 266.74,46.61 268.03,46.61 269.02,47.6 286.64,47.6 288.65,45.58 290.81,45.58 291.27,46.05 315.85,46.05 316.43,46.63 318.71,46.63 v1(318.87,46.78) ; v1(202.1,98.54) 201.9,98.54 196.69,93.34 196.69,91.86 197,91.55 197,89.37 203.47,82.9 203.47,79.37 202.83,78.73 202.83,74.36 202.31,73.83 202.31,71.82 194.1,63.62 194.1,59.78 v1(192.83,58.51)
  BOTTOM w0.14: R205.1 205.79,100.66 205.67,100.55 R204.2 205.12,99.66 203.22,99.66 v1(202.1,98.54) ; v1(192.83,58.51) 192.48,58.87 190.24,58.87 189.63,58.26 189.2,58.26 188.65,57.71 188.65,57.28 189.24,56.7 189.24,55.83 189.59,55.48 189.59,53.81 190.24,53.16 190.24,50.33 189.85,49.94 189.85,49.31 191.84,47.31 v1(191.84,46.73)
PCH_RSMRST#: length 5.3
  TOP w0.127: U13113.BA11 311.3,57.5 v2(310.79,56.99)
  BOTTOM w0.14: R21129.2 313.32,57.42 313.23,57.33 R21134.2 312.95,56.86 312.81,56.73 R21141.1 311.96,56.73 311.76,56.53 311.07,56.53 310.87,56.33 v1(310.71,56.33) 310.71,56.91 v2(310.79,56.99)
PCH_SPI_CLK: length 25.9
  TOP w0.102: U13113.BC31 312.51,67.5 312.77,67.24 314.66,67.24 315.31,67.89 315.59,67.89 315.72,68.01 315.72,68.93 v1(315.62,69.03)
  TOP w0.14: v1(320.95,68.93) 321.32,69.3 321.32,69.52 321.43,69.64 R21245.1
  IN5 w0.089: v1(315.62,69.03) 316.88,69.03 316.97,68.94 316.97,67.71 317.06,67.62 317.24,67.62 317.33,67.71 317.33,69.45 317.42,69.54 317.59,69.54 317.68,69.45 317.68,67.71 317.77,67.62 317.95,67.62 318.04,67.71 318.04,69.02 318.13,69.11 318.31,69.11 318.4,69.02 318.4,68.54 318.48,68.45 318.66,68.45 318.75,68.54 318.75,69.25 318.84,69.34 319.02,69.34 319.11,69.25 319.11,68.19 319.2,68.1 319.37,68.1 319.46,68.19 319.46,70.19 319.58,70.3 319.75,70.3 319.82,70.24 319.82,68.19 319.91,68.1 320.08,68.1 320.17,68.19 320.17,69.32 320.26,69.41 320.46,69.41 v1(320.95,68.93)
PCH_SPI_CLK_EC: length 204.6
  TOP w0.14: R21249.1 322.4,70.04 321.71,69.36 v1(321.71,68.95) ; U49.105 189.2,66.43 189.3,66.34 189.3,66.08 189.3,66.08 189.3,65.73 189.12,65.55 189.12,64.99 v1(188.84,64.71)
  IN1 w0.089: v1(321.71,68.95) 321.97,68.7 323.18,68.7 323.41,68.93 324.61,68.93 324.78,68.75 324.78,68.16 325.17,67.78 326.31,67.78 327.2,66.89 327.2,65.65 326.03,64.48 326.03,63.21 326.7,62.55 326.7,56.91 326.35,56.56 326.35,54.34 324.91,52.9 324.91,50.25 323.32,48.67 323.32,46.81 321.66,45.14 317.92,45.14 317.16,45.9 311.76,45.9 311.08,45.22 289.36,45.22 286.66,47.91 269.34,47.91 268.67,47.24 268.67,45.58 268.23,45.14 263.87,45.14 263.23,45.78 203,45.78 202.23,46.55 195.04,46.55 194.4,47.19 191.55,47.19 191.33,46.98 189.74,46.98 189.5,47.22 187.85,47.22 v1(187.31,46.68)
  BOTTOM w0.14: v1(188.84,64.71) 186.25,62.12 186.25,58.18 186.73,57.7 186.73,55.95 187.42,55.26 187.42,52.77 186.41,51.76 184.86,51.76 183.74,50.64 181.07,50.64 180.84,50.41 180.84,49.77 181.12,49.5 183.18,49.5 183.56,49.11 184.98,49.11 187.18,46.92 187.18,46.81 v1(187.31,46.68)
PCH_SPI_CS0#: length 25.6
  TOP w0.102: U13113.BD31 312.96,67.45 314.58,67.45 315.08,67.94 315.08,68.34 315.23,68.5 v1(315.23,68.51)
  IN4 w0.089: v1(315.23,68.51) 315.23,68.5 315.11,68.37 315.11,67.91 313.08,65.88 313.08,65.62 313.33,65.37 313.82,65.37 313.91,65.46 313.91,65.53 314,65.62 314.18,65.62 314.27,65.53 314.27,65.46 314.36,65.37 314.54,65.37 314.62,65.46 314.62,65.53 314.71,65.62 314.89,65.62 314.98,65.53 314.98,65.46 315.07,65.37 315.25,65.37 315.34,65.46 315.34,65.53 315.42,65.62 315.6,65.62 315.69,65.53 315.69,65.46 315.78,65.37 315.96,65.37 316.05,65.46 316.05,65.53 316.14,65.62 316.31,65.62 316.4,65.53 316.4,65.46 316.49,65.37 316.76,65.37 317.14,65.75 317.14,66.39 317.9,67.15 320.95,67.15 321.36,67.56 321.81,67.56 322.22,67.15 322.22,66.26 323.38,65.1 324.52,65.1 325.78,63.85 325.78,63.72 v1(325.52,63.47)
  BOTTOM w0.14: v1(325.52,63.47) R22065.1
PCH_SPI_IO2: length 26.4
  TOP w0.102: U13113.BC29 312.57,66.46 313.62,66.46 313.79,66.63 v1(316.5,66.63) 316.89,66.63
  TOP w0.14: 316.89,66.63 317.1,66.85 320.57,66.85 321.55,67.82 322.15,67.82 R21247.1 R21238.2 322.46,69.22 v1(323.06,69.82)
  IN1 w0.089: v1(323.06,69.82) 323.46,69.41 324.81,69.41 325.17,69.05 326.66,69.05 327.17,68.55 327.17,67.59 327.5,67.25 327.94,67.25 328.49,67.81 329.23,67.81 329.59,67.45 329.59,64.86 v1(329.94,64.51)
  BOTTOM w0.14: R22066.1 329.97,63.01 329.94,63.03 v1(329.94,64.51)
PCH_SPI_IO3: length 25.5
  TOP w0.102: U13113.BD30 313.04,66.66 313.53,66.66 313.71,66.84 315.08,66.84 v1(315.54,67.3)
  IN1 w0.089: v1(323.21,70.86) 322.55,70.86 321.03,69.33 320.49,69.33 320.26,69.11 320.26,67.86 320.18,67.77 320,67.77 319.91,67.86 319.91,69.76 319.82,69.85 319.64,69.85 319.55,69.76 319.55,67.86 319.46,67.77 319.29,67.77 319.2,67.86 319.2,68.57 319.11,68.66 318.14,68.66 318.03,68.55 318.03,67.71 317.86,67.54 317.59,67.54 317.51,67.63 317.51,68.57 317.42,68.66 317.24,68.66 317.15,68.57 317.15,67.35 317.06,67.26 316.88,67.26 316.79,67.35 316.79,68.15 316.71,68.23 316.53,68.23 316.44,68.15 316.44,67.87 316.35,67.78 315.74,67.78 315.54,67.58 v1(315.54,67.3)
  BOTTOM w0.14: v1(323.21,70.86) 323.21,70.66 R21254.2 323.84,70.08 R21261.1 R22067.1
PCH_SPI_SI: length 26.2
  TOP w0.102: U13113.BB29 311.93,66.38 312.34,66.79 v2(312.34,67.02)
  IN1 w0.089: v1(326.56,66.51) 326.56,66.79 326.11,67.25 324.02,67.25 323.62,67.66 320.44,67.66 320.06,67.28 317.45,67.28 317.07,66.89 315.14,66.89 315.05,66.98 315.05,68.04 314.96,68.13 314.78,68.13 314.7,68.04 314.7,66.98 314.61,66.89 314.43,66.89 314.34,66.98 314.34,67.79 314.25,67.88 314.07,67.88 313.98,67.79 313.98,66.98 313.9,66.89 313.72,66.89 313.63,66.98 313.63,67.79 313.54,67.88 313.36,67.88 313.27,67.79 313.27,66.98 313.18,66.89 312.47,66.89 v2(312.34,67.02)
  BOTTOM w0.14: R21246.1 328.47,67.15 328.92,66.7 328.92,66.11 v1(328.99,66.03) 328.95,65.99 328.21,65.99 R21277.1 R21270.2 327.06,66.01 v1(326.56,66.51)
PCH_SPI_SI_EC: length 200.2
  TOP w0.14: U49.102 190.4,65.97 v1(190.57,65.8)
  IN1 w0.089: v1(189.17,46.78) 189.71,46.24 194.43,46.24 195.24,45.43 200.17,45.43 200.3,45.31 253.45,45.31 253.53,45.22 253.53,44.76 253.62,44.67 253.89,44.67 253.98,44.76 253.98,45.22 254.07,45.31 254.33,45.31 254.42,45.22 254.42,44.76 254.51,44.67 254.78,44.67 254.87,44.76 254.87,45.22 254.96,45.31 255.22,45.31 255.31,45.22 255.31,44.76 255.4,44.67 255.67,44.67 255.76,44.76 255.76,45.22 255.85,45.31 256.11,45.31 256.2,45.22 256.2,44.76 256.29,44.67 256.56,44.67 256.65,44.76 256.65,45.22 256.73,45.31 257,45.31 257.09,45.22 257.09,44.76 257.18,44.67 257.45,44.67 257.53,44.76 257.53,45.22 257.62,45.31 257.89,45.31 257.98,45.22 257.98,44.76 258.07,44.67 258.33,44.67 258.42,44.76 258.42,45.22 258.51,45.31 258.78,45.31 258.87,45.22 258.87,44.76 258.96,44.67 259.22,44.67 259.31,44.76 259.31,45.22 259.4,45.31 259.67,45.31 259.76,45.22 259.76,44.76 259.85,44.67 260.11,44.67 260.2,44.76 260.2,45.22 260.29,45.31 263.03,45.31 263.67,44.67 269,44.67 271.78,47.44 286.47,47.44 289.16,44.75 311.27,44.75 311.95,45.43 316.96,45.43 317.72,44.67 321.85,44.67 324.51,47.32 324.51,48.23 325.16,48.88 325.16,49.83 325.38,50.05 325.38,52.7 326.82,54.15 326.82,56.36 327.17,56.72 327.17,64.74 329.13,66.69 v1(329.13,67.2)
  BOTTOM w0.14: R21250.1 329.09,67.24 v1(329.13,67.2) ; v1(189.17,46.78) 188.54,47.41 188.41,47.41 v1(187.35,48.48) 185.96,49.87 185.96,50.53 186.35,50.92 186.75,50.92 188.28,52.44 188.28,55.61 187.57,56.32 187.57,58.05 187.09,58.53 187.09,61.77 188.15,62.83 190.31,62.83 190.57,63.09 190.57,64.02 190.91,64.37 190.91,65.46 v1(190.57,65.8) 190.37,66.01 R20890.1
PCH_SPI_SO: length 27
  TOP w0.102: 316.99,68.04 316.16,68.04 315.83,67.71 315.39,67.71 314.72,67.04 313.47,67.04 U13113.BE30
  TOP w0.14: v1(318.69,68.06) 319.14,68.06 319.29,67.91 R21219.2 R21225.1 317.45,68.04 316.99,68.04
  IN4 w0.089: v1(318.69,68.06) 316.73,68.06 316.36,67.69 315.31,67.69 315.15,67.53 315.15,67.14 315.38,66.91 317.29,66.91 317.79,67.42 320.83,67.42 321.24,67.82 321.92,67.82 322.6,67.15 322.6,66.26 323.49,65.37 324.63,65.37 v1(326.54,63.47)
  BOTTOM w0.14: v1(326.54,63.47) R22063.1
PCH_SPI_SO_EC: length 200.6
  TOP w0.14: v1(190.44,65.12) 189.82,65.74 189.82,66.2 190,66.38 U49.103
  IN1 w0.089: v1(327.68,63.9) 328.06,63.52 328.06,60.54 327.44,59.92 327.44,56.61 327.08,56.25 327.08,54.04 325.7,52.65 325.7,50 325.42,49.72 325.42,48.62 324.77,47.97 324.77,47.21 321.96,44.4 289.13,44.4 286.38,47.16 271.95,47.16 269.2,44.4 252.92,44.4 252.83,44.49 252.83,44.95 252.74,45.04 252.48,45.04 252.39,44.95 252.39,44.49 252.3,44.4 252.03,44.4 251.94,44.49 251.94,44.95 251.85,45.04 251.59,45.04 251.5,44.95 251.5,44.49 251.41,44.4 251.14,44.4 251.05,44.49 251.05,44.95 250.97,45.04 250.7,45.04 250.61,44.95 250.61,44.49 250.52,44.4 250.25,44.4 250.17,44.49 250.17,44.95 250.08,45.04 249.81,45.04 249.72,44.95 249.72,44.49 249.63,44.4 249.37,44.4 249.28,44.49 249.28,44.95 249.19,45.04 248.92,45.04 248.83,44.95 248.83,44.49 248.74,44.4 248.48,44.4 248.39,44.49 248.39,44.95 248.3,45.04 248.03,45.04 247.94,44.95 247.94,44.49 247.85,44.4 247.59,44.4 247.5,44.49 247.5,44.95 247.41,45.04 247.14,45.04 247.05,44.95 247.05,44.49 246.97,44.4 200,44.4 199.91,44.49 199.91,44.96 199.82,45.05 199.64,45.05 199.55,44.96 199.55,44.49 199.46,44.4 199.28,44.4 199.2,44.49 199.2,44.96 199.11,45.05 198.93,45.05 198.84,44.96 198.84,44.49 198.75,44.4 198.57,44.4 198.48,44.49 198.48,44.96 198.4,45.05 198.22,45.05 198.13,44.96 198.13,44.49 198.04,44.4 197.86,44.4 197.77,44.49 197.77,44.96 197.68,45.05 197.51,45.05 197.42,44.96 197.42,44.49 197.33,44.4 197.15,44.4 197.06,44.49 197.06,44.96 196.97,45.05 196.8,45.05 196.71,44.96 196.71,44.49 196.62,44.4 196.44,44.4 196.35,44.49 196.35,44.96 196.26,45.05 196.08,45.05 196,44.96 196,44.49 195.91,44.4 193.68,44.4 192.23,45.85 189.42,45.85 v1(188.51,46.75)
  BOTTOM w0.14: R21243.1 v1(327.68,63.9) ; v1(190.44,65.12) 190.52,65.05 190.52,64.45 190.19,64.13 190.19,63.7 189.78,63.29 R20891.1 188.16,63.29 186.77,61.9 186.77,58.4 187.25,57.92 187.25,56.19 187.95,55.48 187.95,52.57 186.62,51.24 186.21,51.24 185.64,50.66 185.64,49.5 188.39,46.75 v1(188.51,46.75)
PCH_THRMTRIP_R#: length 9
  TOP w0.102: U13113.AJ3 304.92,53.29 304.92,53 305.08,52.84 305.08,52.52 305.33,52.27 305.33,52.02 305.07,51.76 305.02,51.76 304.75,51.49 304.75,51.28 304.06,50.59 303.77,50.59 303.31,50.13 303.22,50.13
  TOP w0.14: 303.22,50.13 302.29,49.2 v1(302.29,48.18) 303.37,47.09 R21189.1
PCI_PLTRST#: length 35.4
  TOP w0.102: U13113.BB27 311.91,65.75 v2(311.75,65.9)
  TOP w0.14: v1(324.99,54.19) 325.75,53.43 v1(326.31,53.43) 327.66,53.43 328.95,52.14 U13102.2 328.95,50.51 329.08,50.38 329.46,50.38 329.6,50.53 U13102.1
  IN1 w0.089: v1(324.99,54.19) 324.99,54.51 325.41,54.93 325.41,56.95 325.76,57.3 325.76,59.9 325.31,60.35 325.31,62.11 324.38,63.04 324.38,64.1 324.89,64.61 324.89,66.13 324.73,66.29 323.97,66.29 323.5,66.76 317.6,66.76 317.26,66.42 313.23,66.42 312.95,66.13 311.98,66.13 v2(311.75,65.9)
PCIE9_SATA_RXN: length 255.2
  TOP w0.14: C95583.2 62.92,39.75 62.92,40.35 v1(62.61,40.66) ; v2(294.15,68.19) 294.36,67.98 U13113.G31
  IN4 w0.089: v1(62.61,40.66) 62.76,40.66 63.02,40.92 63.02,41.36 63.48,41.82 64.52,41.82 65.2,41.14 65.2,37.66 66.29,36.57 67.6,36.57 71.46,40.43 75.74,40.43 76.52,41.22 78.2,41.22 80.42,43.43 86.53,43.43 88.2,45.1 90.76,45.1 92.23,46.57 96.91,46.57 99.07,48.73 173.8,48.73 175.98,50.9 177.52,50.9 178.21,51.59 178.79,51.59 179.3,52.1 193.46,52.1 193.51,52.05 195.35,52.05 195.56,52.26 204.45,52.26 205.45,53.26 263.8,53.26 264.17,53.63 277.78,53.63 281.46,57.31 281.46,61.4 283.82,63.76 284.22,63.76 285.83,65.37 289.42,65.37 289.59,65.54 290.72,65.54 290.87,65.39 291.26,65.39 291.74,65.86 291.74,66.79 292.7,67.76 294.25,67.76 294.34,67.85 294.34,68 v2(294.15,68.19)
PCIE9_SATA_RXN_C: length 3.8
  TOP w0.14: C95583.1 62.97,38.77 62.97,38.68 62.87,38.58 62.61,38.58 62.35,38.32 62.35,37.78 61.58,37.01 U13146.13
PCIE9_SATA_RXN_C_RE: length 16.3
  TOP w0.14: U13146.36 61.58,31.6 61.71,31.46 61.71,30.67 61.39,30.34 61.39,29.76 61.56,29.58 61.56,29.3 v1(61.34,29.07) ; R21736.2 v4(69.21,26.97)
  IN4 w0.089: v4(69.21,26.97) 69.34,26.84 69.34,26.59 69.24,26.49 69.01,26.49 68.9,26.6 67.4,26.6 66.69,27.31 62.45,27.31 60.87,28.89 60.87,29.27 61.18,29.58 61.64,29.58 61.73,29.49 61.73,29.29 61.51,29.07 v1(61.34,29.07)
  BOTTOM w0.14: R21736.2 v4(69.21,26.97)
PCIE9_SATA_RXN_C_RE_C: length 10.5
  TOP w0.14: R21736.1 70.22,26.81 70.64,26.81 70.99,26.47 70.99,25.59 70.67,25.28 68.92,25.28 68.68,25.04 68.68,22.39 67.98,21.68 67.61,21.68 67.28,21.35 67.24,21.31 CN2069.43
PCIE9_SATA_RXP: length 255.2
  TOP w0.14: v2(294.86,68.19) 295.12,67.93 U13113.H31 ; v1(63.46,40.66) 63.19,40.38 63.19,39.79 63.44,39.54 C95580.2
  IN4 w0.089: v2(294.86,68.19) 294.69,68.01 294.58,68.01 294.51,67.94 294.51,67.78 294.32,67.59 292.77,67.59 291.91,66.72 291.91,65.79 291.33,65.22 290.8,65.22 290.65,65.37 289.66,65.37 289.49,65.2 285.9,65.2 284.29,63.59 283.89,63.59 281.63,61.33 281.63,57.24 277.85,53.46 264.24,53.46 263.87,53.09 205.52,53.09 204.52,52.09 195.63,52.09 195.42,51.88 193.44,51.88 193.39,51.93 179.37,51.93 178.86,51.43 178.28,51.43 177.59,50.74 176.05,50.74 173.87,48.56 99.14,48.56 96.98,46.41 92.3,46.41 90.83,44.93 88.27,44.93 86.6,43.26 80.49,43.26 78.27,41.05 76.59,41.05 75.81,40.26 71.53,40.26 67.67,36.4 66.22,36.4 65.03,37.59 65.03,41.07 64.45,41.65 63.55,41.65 63.19,41.29 63.19,40.93 v1(63.46,40.66)
PCIE9_SATA_RXP_C: length 3.7
  TOP w0.14: U13146.12 61.98,37.03 62.61,37.67 62.61,38.2 62.72,38.31 62.98,38.31 63.24,38.57 63.24,38.86 C95580.1
PCIE9_SATA_RXP_C_RE: length 16.3
  TOP w0.14: v1(62.07,29.07) 61.83,29.32 61.83,29.69 61.65,29.87 61.65,30.22 61.98,30.55 U13146.37 ; R21735.2 v4(69.21,26.15)
  IN4 w0.089: v4(69.21,26.15) 69.04,26.32 68.94,26.32 68.83,26.43 67.33,26.43 66.62,27.14 62.38,27.14 60.7,28.82 60.7,29.34 61.11,29.74 61.71,29.74 61.89,29.56 61.89,29.25 v1(62.07,29.07)
  BOTTOM w0.14: R21735.2 v4(69.21,26.15)
PCIE9_SATA_RXP_C_RE_C: length 10.4
  TOP w0.14: R21735.1 70.07,26.48 70.14,26.55 70.53,26.55 70.72,26.36 70.72,25.7 70.56,25.54 68.81,25.54 68.42,25.15 68.42,22.5 67.87,21.95 67.5,21.95 67.05,21.5 66.97,21.42 66.97,21 66.74,20.76 CN2069.41
PCIE9_SATA_TXN: length 244
  TOP w0.081: v1(288.46,67.1) 288.68,67.31 288.68,67.52 288.92,67.76 290.5,67.76 290.61,67.86 291.84,67.86 291.95,67.98 292.19,67.98 292.53,67.63 U13113.C31
  TOP w0.14: C95578.2 66.01,37.76 66.26,37.76 v1(66.46,37.96)
  IN4 w0.089: v1(288.46,67.1) 288.68,66.88 288.68,66.7 288.54,66.56 286.2,66.56 285.68,66.04 284.88,66.04 280.45,61.61 280.45,57.08 277.62,54.26 263.9,54.26 263.5,53.86 205.12,53.86 204.07,52.82 195.78,52.82 195.24,53.36 190.15,53.36 189.77,53.74 183.86,53.74 183.6,53.48 180.69,53.48 179.97,52.76 179,52.76 178.52,52.29 177.27,52.29 176.45,51.47 175.67,51.47 173.49,49.29 98.78,49.29 96.63,47.15 92.01,47.15 90.53,45.66 87.97,45.66 86.32,44.01 79.96,44.01 78.25,42.31 75.86,42.31 75.6,42.57 72.8,42.57 67.92,37.69 66.73,37.69 v1(66.46,37.96)
PCIE9_SATA_TXN_C: length 3.8
  TOP w0.14: U13146.10 62.78,36.91 63.01,37.14 64.12,37.14 64.92,37.94 C95578.1
PCIE9_SATA_TXN_C_RE: length 16.6
  TOP w0.14: U13146.39 62.78,31.56 62.85,31.49 62.85,31.02 63.47,30.4 63.47,29.38 v1(63.29,29.21) ; v4(69.21,23.99) C95566.1
  IN4 w0.089: v1(63.29,29.21) 63.61,28.89 63.61,28.32 64.19,27.74 69.17,27.74 69.8,27.1 69.8,25.74 69.58,25.52 68.69,25.52 68.38,25.21 68.38,24.52 68.73,24.17 69.04,24.17 v4(69.21,23.99)
  BOTTOM w0.14: v4(69.21,23.99) C95566.1
PCIE9_SATA_TXN_C_RE_C: length 6.2
  TOP w0.14: CN2069.47 68.24,20.82 68.47,21.05 68.47,21.43 69.48,22.43 69.48,22.61 70.59,23.72 70.59,24.14 70.38,24.36 70.15,24.36 70.07,24.27 C95566.2
PCIE9_SATA_TXP: length 244
  TOP w0.081: v1(289.11,67.11) 288.92,67.11 288.84,67.19 288.84,67.45 288.99,67.6 290.57,67.6 290.68,67.7 292.06,67.7 U13113.B31
  TOP w0.14: C95581.2 65.83,37.18 66.13,37.48 66.27,37.48 66.46,37.28 v1(66.46,37.11)
  IN4 w0.089: v1(66.46,37.11) 66.46,37.44 66.55,37.52 67.99,37.52 72.87,42.41 75.53,42.41 75.79,42.14 78.32,42.14 80.03,43.85 86.39,43.85 88.04,45.5 90.59,45.5 92.08,46.98 96.7,46.98 98.85,49.13 173.56,49.13 175.74,51.3 176.52,51.3 177.34,52.12 178.59,52.12 179.06,52.59 180.04,52.59 180.76,53.32 183.67,53.32 183.93,53.57 189.7,53.57 190.08,53.19 195.17,53.19 195.71,52.65 204.14,52.65 205.19,53.7 263.57,53.7 263.97,54.09 277.69,54.09 280.61,57.02 280.61,61.54 284.95,65.87 285.75,65.87 286.27,66.4 288.61,66.4 288.84,66.63 288.84,67 288.96,67.11 v1(289.11,67.11)
PCIE9_SATA_TXP_C: length 3.7
  TOP w0.14: U13146.9 63.18,36.57 63.05,36.71 63.05,36.8 63.12,36.87 64.23,36.87 65.01,37.65 65.06,37.65 65.38,37.32 C95581.1
PCIE9_SATA_TXP_C_RE: length 16.6
  TOP w0.14: U13146.40 63.18,31.56 63.11,31.49 63.11,31.13 63.74,30.51 63.74,29.51 v1(64.04,29.21) ; C95567.1 v4(69.21,24.76)
  IN4 w0.089: v1(64.04,29.21) 63.77,28.94 63.77,28.39 64.26,27.91 69.24,27.91 69.97,27.17 69.97,25.67 69.65,25.35 68.76,25.35 68.55,25.14 68.55,24.59 68.8,24.34 69.08,24.34 69.21,24.47 v4(69.21,24.76)
  BOTTOM w0.14: C95567.1 v4(69.21,24.76)
PCIE9_SATA_TXP_C_RE_C: length 6.2
  TOP w0.14: CN2069.49 68.74,21.32 69.74,22.32 69.74,22.5 70.86,23.61 70.86,24.25 70.49,24.62 70.2,24.62 C95567.2
PCIE10_SATA_RXN: length 257.5
  TOP w0.14: v2(295.02,67.05) 294.49,66.52 U13113.G29 ; C95874.2 58.83,39.83 58.83,40.03 59.08,40.28 59.51,40.28 59.67,40.44 59.67,40.62 v1(59.58,40.71)
  IN4 w0.089: v1(59.58,40.71) 59.76,40.53 59.76,40.11 60.41,39.46 62.85,39.46 64.43,37.88 64.43,37.35 65.35,36.44 65.35,35.58 65.75,35.18 67.25,35.18 69.03,36.96 72.61,36.96 73.85,38.2 74.87,38.2 76.92,40.26 79.11,40.26 80.84,41.99 83.91,41.99 84.6,42.67 86.81,42.67 88.5,44.37 91.06,44.37 92.51,45.82 97.45,45.82 99.63,48 174.19,48 176.37,50.18 178.46,50.18 179.6,51.32 195.65,51.32 195.86,51.53 204.88,51.53 205.88,52.53 258.88,52.53 258.94,52.47 264.21,52.47 264.59,52.85 278.21,52.85 282.57,57.21 282.57,60.57 284.33,62.34 284.33,62.69 286.29,64.64 289.37,64.64 289.85,64.16 291.39,64.16 293.63,66.4 294.53,66.4 294.8,66.67 294.8,66.83 v2(295.02,67.05)
PCIE10_SATA_RXN_C: length 3.2
  TOP w0.14: C95874.1 58.85,38.83 58.85,36.92 58.78,36.86 U13146.20
PCIE10_SATA_RXN_C_RE: length 19.2
  TOP w0.14: U13146.29 58.78,31.54 58.58,31.35 57.92,31.35 57.64,31.63 56.7,31.63 56.34,31.27 56.34,30.91 v1(56.15,30.72) ; R21731.1 65.86,24.1 65.98,24.22 65.98,24.61 v1(65.81,24.78)
  IN4 w0.089: v1(56.15,30.72) 56.18,30.72 56.37,30.53 56.37,29.79 57.47,28.69 58.32,28.69 58.63,28.38 58.63,26.8 59.53,25.9 60.09,25.9 60.57,25.42 61.84,25.42 61.95,25.32 65.88,25.32 65.97,25.23 65.97,24.94 v1(65.81,24.78)
PCIE10_SATA_RXN_C_RE_C: length 4.8
  TOP w0.14: CN2069.29 63.74,20.93 63.86,21.05 63.86,21.32 65.25,22.71 65.75,22.71 65.83,22.8 65.83,22.92 R21731.2
PCIE10_SATA_RXP: length 257.5
  TOP w0.14: U13113.E29 293.8,66.52 v2(294.37,67.09) ; C95875.2 59.1,39.79 59.1,39.92 59.19,40.01 59.62,40.01 59.95,40.34 59.95,40.42 60.13,40.61 v1(60.29,40.61)
  IN4 w0.089: v1(60.29,40.61) 60.02,40.61 59.93,40.52 59.93,40.18 60.48,39.63 62.92,39.63 64.6,37.95 64.6,37.42 65.52,36.51 65.52,35.65 65.81,35.35 67.18,35.35 68.96,37.13 72.54,37.13 73.78,38.37 74.8,38.37 76.86,40.43 79.04,40.43 80.77,42.16 83.84,42.16 84.53,42.84 86.74,42.84 88.43,44.54 90.99,44.54 92.44,45.99 97.38,45.99 99.56,48.17 174.12,48.17 176.3,50.34 178.39,50.34 179.53,51.49 195.58,51.49 195.79,51.7 204.81,51.7 205.81,52.69 258.95,52.69 259.01,52.64 264.14,52.64 264.52,53.02 278.14,53.02 282.4,57.28 282.4,60.64 284.17,62.41 284.17,62.76 286.22,64.81 289.44,64.81 289.92,64.33 291.32,64.33 293.56,66.56 294.46,66.56 294.63,66.74 294.63,67 294.55,67.09 v2(294.37,67.09)
PCIE10_SATA_RXP_C: length 3.1
  TOP w0.14: U13146.19 59.18,36.82 59.11,36.88 59.11,38.9 C95875.1
PCIE10_SATA_RXP_C_RE: length 19.3
  TOP w0.14: R21732.1 66.25,24.3 66.25,24.56 v1(66.49,24.81) ; v1(56.83,30.72) 56.75,30.72 56.61,30.86 56.61,31.16 56.81,31.36 57.53,31.36 57.81,31.08 58.69,31.08 59.18,31.57 U13146.30
  IN4 w0.089: v1(56.83,30.72) 56.67,30.72 56.54,30.58 56.54,29.86 57.54,28.86 58.39,28.86 58.8,28.45 58.8,26.87 59.6,26.07 60.16,26.07 60.64,25.59 61.91,25.59 62.01,25.48 65.98,25.48 66.14,25.32 66.14,24.98 66.31,24.81 v1(66.49,24.81)
PCIE10_SATA_RXP_C_RE_C: length 4.7
  TOP w0.14: CN2069.31 64.24,20.93 64.12,21.05 64.12,21.21 65.36,22.44 65.86,22.44 66.1,22.69 66.1,22.98 R21732.2
PCIE10_SATA_TXN: length 251.9
  TOP w0.081: U13113.C32 292.49,68.51 291.02,68.51 290.72,68.8 290.28,68.8 290.22,68.86
  TOP w0.14: C95873.2 60.4,39.87 60.4,40.02 61.17,40.79 61.17,40.9 v1(60.99,41.08) ; v1(288.84,68.21) 289.49,68.86 290.22,68.86
  IN4 w0.089: v1(60.99,41.08) 61.22,41.31 61.22,41.49 61.53,41.8 62.4,41.8 62.78,42.18 62.78,43.05 63.53,43.8 64.9,43.8 65.56,43.14 66.07,43.14 66.78,43.85 67.88,43.85 68.52,43.21 75.45,43.21 75.56,43.32 78.46,43.32 79.71,44.58 86.09,44.58 87.74,46.22 90.29,46.22 91.8,47.73 96.26,47.73 98.46,49.93 173.24,49.93 175.34,52.03 176.22,52.03 177.23,53.04 178.14,53.04 178.48,53.38 179.64,53.38 180.39,54.14 183.23,54.14 183.51,54.42 191.38,54.42 191.84,53.96 195.89,53.96 196.46,53.38 203.77,53.38 204.83,54.44 205.13,54.44 206.05,55.36 207.39,55.36 208.31,54.44 263.19,54.44 263.57,54.82 276.72,54.82 277.63,55.73 277.63,59.92 284.31,66.6 285.45,66.6 285.99,67.15 287.56,67.15 288.17,67.76 288.99,67.76 289.03,67.8 289.03,68.02 v1(288.84,68.21)
PCIE10_SATA_TXN_C: length 3.3
  TOP w0.14: U13146.17 59.98,36.67 60.04,36.73 60.04,37.72 60.35,38.03 60.35,38.86 C95873.1
PCIE10_SATA_TXN_C_RE: length 15.6
  TOP w0.14: v1(59.19,28.34) 59.35,28.5 59.35,30.67 59.98,31.3 U13146.32 ; v1(67.33,24.07) 67.3,24.05 C95564.1
  IN4 w0.089: v1(59.19,28.34) 59.42,28.11 59.42,27.97 61.28,26.1 62.07,26.1 62.28,25.9 66.56,25.9 67.61,24.85 67.61,24.22 67.46,24.07 v1(67.33,24.07)
PCIE10_SATA_TXN_C_RE_C: length 4.5
  TOP w0.14: CN2069.35 65.24,20.86 65.43,21.06 65.43,21.4 65.92,21.89 66.49,21.89 67.34,22.74 67.44,22.84 67.44,22.97 C95564.2
PCIE10_SATA_TXP: length 251.8
  TOP w0.081: 290.22,68.6 290.26,68.64 290.66,68.64 290.95,68.34 292.19,68.34 292.27,68.26 U13113.B32
  TOP w0.14: C95837.2 60.66,39.75 60.66,39.91 61.44,40.68 61.44,40.85 61.58,40.99 v1(62.05,40.99) ; 290.22,68.6 289.61,68.6 289.46,68.45 289.46,68.25 v1(289.53,68.18)
  IN4 w0.089: v1(62.05,40.99) 61.53,40.99 61.39,41.13 61.39,41.42 61.6,41.63 62.47,41.63 62.95,42.11 62.95,42.98 63.6,43.63 64.83,43.63 65.49,42.97 66.14,42.97 66.85,43.68 67.81,43.68 68.45,43.04 75.52,43.04 75.63,43.16 78.52,43.16 79.78,44.41 86.16,44.41 87.81,46.06 90.36,46.06 91.87,47.57 96.33,47.57 98.53,49.76 173.31,49.76 175.41,51.86 176.29,51.86 177.3,52.88 178.21,52.88 178.55,53.21 179.71,53.21 180.46,53.97 183.3,53.97 183.58,54.25 191.31,54.25 191.77,53.79 195.82,53.79 196.39,53.21 203.84,53.21 204.9,54.27 205.19,54.27 206.12,55.2 207.32,55.2 208.24,54.27 263.26,54.27 263.64,54.66 276.79,54.66 277.79,55.66 277.79,59.85 284.38,66.43 285.52,66.43 286.06,66.98 287.63,66.98 288.24,67.59 289.06,67.59 289.2,67.73 289.2,68.04 289.34,68.18 v1(289.53,68.18)
PCIE10_SATA_TXP_C: length 3.3
  TOP w0.14: C95837.1 60.61,38.87 60.61,37.92 60.3,37.61 60.3,36.8 60.38,36.72 U13146.16
PCIE10_SATA_TXP_C_RE: length 15.7
  TOP w0.14: C95565.1 68.04,24.02 v1(67.99,24.07) ; v1(59.86,28.34) 59.62,28.58 59.62,30.56 60.25,31.19 60.25,31.48 60.38,31.61 U13146.33
  IN4 w0.089: v1(67.99,24.07) 67.78,24.28 67.78,24.92 66.63,26.07 62.35,26.07 62.14,26.27 61.35,26.27 59.58,28.04 59.58,28.19 59.74,28.34 v1(59.86,28.34)
PCIE10_SATA_TXP_C_RE_C: length 4.5
  TOP w0.14: C95565.2 68.04,23.06 67.85,22.87 67.73,22.75 67.63,22.65 67.45,22.47 66.6,21.62 66.03,21.62 65.7,21.29 65.7,20.97 65.74,20.93 CN2069.37
PCIE11_SATA_RXN: length 244.7
  TOP w0.14: U13113.L31 297,68.02 v2(297,68.11) ; C95843.2 72.83,48.36 72.83,48.8 74.43,50.4 76.61,50.4 78.09,48.92 78.09,47.81 78.27,47.63 v1(78.27,47.63)
  IN4 w0.089: v2(297,68.11) 296.82,68.29 296.82,68.55 296.63,68.74 293.86,68.74 293.72,68.88 289.78,68.88 289.55,69.11 284.06,69.11 277.42,62.47 206.66,62.47 205.74,61.55 205.74,59.01 202.59,55.85 199.38,55.85 199.11,56.13 197.99,56.13 197.25,56.86 195.22,56.86 193.73,58.35 193.73,58.61 193.21,59.14 191.57,59.14 190.73,58.3 185.73,58.3 184.54,57.12 179.55,57.12 177.46,55.03 176.84,55.03 176.22,54.42 172.28,54.42 170.68,52.82 170.17,52.82 169.36,52.01 130.98,52.01 130.68,52.32 128.59,52.32 128.27,52 117.57,52 117.2,51.63 96.83,51.63 94.62,49.42 91.11,49.42 89.59,47.91 87.04,47.91 85.42,46.29 84.24,46.29 82.51,48.02 79.17,48.02 78.86,47.71 78.86,47.39 78.56,47.08 78.23,47.08 78.07,47.24 78.07,47.44 v1(78.27,47.63)
PCIE11_SATA_RXN_C: length 3.5
  TOP w0.14: C95843.1 72.77,47.39 72.77,47.26 72.51,47 72.51,46.16 71.82,45.48 71.82,45.17 71.74,45.09 U13147.13
PCIE11_SATA_RXN_C_RE: length 24.6
  TOP w0.14: v1(71.85,37.86) 72.07,38.08 72.07,38.18 71.65,38.6 71.65,39.15 71.78,39.28 71.78,39.81 71.74,39.84 U13147.36 ; v1(62.25,24.78) 62.25,24.49 R21728.1
  IN5 w0.089: v1(71.85,37.86) 71.87,37.86 72.15,37.58 72.15,37.46 71.85,37.16 71.85,29.16 70.78,28.08 68.65,28.08 66.52,25.95 63.06,25.95 62.51,25.41 62.51,25.05 v1(62.25,24.78)
PCIE11_SATA_RXN_C_RE_C: length 4.2
  TOP w0.14: R21728.2 62.25,22.94 62.25,22.78 60.86,21.38 60.86,21.05 60.74,20.93 CN2069.17
PCIE11_SATA_RXP: length 244.7
  TOP w0.14: v2(296.26,68.11) 296.32,68.06 296.32,67.86 296.12,67.66 U13113.K31 ; C95844.2 73.1,48.27 73.1,48.69 74.54,50.13 76.5,50.13 77.82,48.81 77.82,47.77 77.71,47.65 v1(77.56,47.65)
  IN4 w0.089: v2(296.26,68.11) 296.36,68.01 296.59,68.01 296.63,68.06 296.63,68.26 296.65,68.28 296.65,68.48 296.56,68.57 293.79,68.57 293.65,68.71 289.71,68.71 289.48,68.94 284.13,68.94 277.49,62.3 206.73,62.3 205.91,61.48 205.91,58.94 202.65,55.68 199.32,55.68 199.04,55.96 197.92,55.96 197.18,56.69 195.15,56.69 193.56,58.28 193.56,58.54 193.14,58.97 191.64,58.97 190.8,58.14 185.8,58.14 184.61,56.95 179.62,56.95 177.53,54.87 176.91,54.87 176.29,54.25 172.35,54.25 170.75,52.65 170.61,52.65 170.24,52.65 169.43,51.84 130.91,51.84 130.61,52.15 128.66,52.15 128.34,51.83 117.64,51.83 117.27,51.46 96.9,51.46 94.69,49.26 91.18,49.26 89.66,47.74 87.11,47.74 85.49,46.12 84.17,46.12 82.44,47.85 79.24,47.85 79.03,47.64 79.03,47.32 78.63,46.92 78.16,46.92 77.88,47.19 77.88,47.52 77.74,47.65 v1(77.56,47.65)
PCIE11_SATA_RXP_C: length 3.5
  TOP w0.14: U13147.12 72.14,45.13 72.09,45.18 72.09,45.37 72.77,46.05 72.77,46.89 73.03,47.15 73.03,47.35 C95844.1
PCIE11_SATA_RXP_C_RE: length 24.6
  TOP w0.14: v1(63.01,24.76) 62.89,24.63 R21729.1 ; U13147.37 72.14,40.02 72.04,39.92 72.04,39.17 71.91,39.04 71.91,38.71 72.33,38.29 72.33,38.15 v1(72.65,37.84)
  IN5 w0.089: v1(63.01,24.76) 62.94,24.76 62.68,25.01 62.68,25.34 63.13,25.79 66.59,25.79 68.72,27.92 70.85,27.92 72.02,29.09 72.02,37.09 72.32,37.39 72.32,37.5 v1(72.65,37.84)
PCIE11_SATA_RXP_C_RE_C: length 4.2
  TOP w0.14: R21729.2 62.52,22.96 62.52,22.66 61.12,21.27 61.12,21.05 61.24,20.93 CN2069.19
PCIE11_SATA_TXN: length 227.5
  TOP w0.14: C95842.2 77.94,46.85 79.17,46.85 79.82,46.2 79.82,45.96 v1(79.99,45.79) ; v1(286.92,68.54) 287.04,68.54 287.42,68.93 288.53,68.93 288.96,69.36 290.82,69.36 291.08,69.1 292.24,69.1 U13113.C33
  IN4 w0.089: v1(79.99,45.79) 79.79,45.59 79.79,45.36 80.01,45.14 85.85,45.14 87.5,46.79 90.06,46.79 91.58,48.3 95.31,48.3 97.5,50.49 172.92,50.49 175.01,52.59 175.98,52.59 177.3,53.91 177.96,53.91 178.74,54.7 183,54.7 183.28,54.98 191.61,54.98 192.08,54.52 196.97,54.52 197.28,54.83 198.55,54.83 198.86,54.52 202.86,54.52 206.48,58.13 207.44,58.13 209.7,60.39 210.99,60.39 211.73,61.13 213.99,61.13 214,61.14 277.94,61.14 283.95,67.16 285.21,67.16 285.78,67.73 286.45,67.73 286.95,68.24 286.95,68.52 v1(286.92,68.54)
PCIE11_SATA_TXN_C: length 5.9
  TOP w0.14: C95842.1 77.23,47.05 76.7,47.05 76.47,46.83 75.99,46.83 75.48,46.32 73.76,46.32 72.94,45.5 U13147.10
PCIE11_SATA_TXN_C_RE: length 24
  TOP w0.14: C95562.1 64.13,23.91 64.13,24.02 v1(63.9,24.25) ; v1(73.04,38.96) 73.02,38.98 73.02,40.04 72.94,40.13 U13147.39
  IN5 w0.089: v1(73.04,38.96) 73.34,38.66 73.34,37.85 72.41,36.93 72.41,28.86 68.95,25.39 64.59,25.39 64.27,25.07 64.27,24.6 63.91,24.25 v1(63.9,24.25)
PCIE11_SATA_TXN_C_RE_C: length 4.3
  TOP w0.14: CN2069.23 62.24,20.93 62.36,21.05 62.36,21.35 63.49,22.48 63.89,22.48 64.03,22.62 64.03,22.85 C95562.2
PCIE11_SATA_TXP: length 227.6
  TOP w0.14: U13113.B33 292,68.84 290.97,68.84 290.71,69.09 289.07,69.09 288.64,68.66 287.53,68.66 287.39,68.52 287.39,68.32 v1(287.52,68.19) ; C95845.2 77.77,46.32 78.04,46.59 79.06,46.59 79.56,46.09 79.56,45.95 79.39,45.79 v1(79.14,45.79)
  IN4 w0.089: v1(287.52,68.19) 287.42,68.29 287.24,68.29 286.52,67.57 285.85,67.57 285.28,66.99 284.02,66.99 278.01,60.98 214.07,60.98 214.05,60.97 211.8,60.97 211.06,60.22 209.77,60.22 207.51,57.96 206.55,57.96 202.93,54.35 198.79,54.35 198.48,54.66 197.35,54.66 197.03,54.35 192.01,54.35 191.54,54.81 183.35,54.81 183.06,54.53 178.81,54.53 178.03,53.74 177.37,53.74 176.05,52.42 175.08,52.42 172.99,50.33 97.57,50.33 95.38,48.13 91.65,48.13 90.13,46.62 87.57,46.62 85.92,44.97 79.94,44.97 79.62,45.29 79.62,45.66 79.5,45.79 v1(79.14,45.79)
PCIE11_SATA_TXP_C: length 5.8
  TOP w0.14: U13147.9 73.34,45.04 73.21,45.18 73.21,45.39 73.87,46.05 75.59,46.05 76.1,46.56 76.58,46.56 76.81,46.78 76.97,46.78 77.27,46.49 C95845.1
PCIE11_SATA_TXP_C_RE: length 23.9
  TOP w0.14: C95563.1 64.4,23.7 64.4,23.96 v1(64.66,24.22) ; v1(73.72,38.96) 73.34,39.33 U13147.40
  IN5 w0.089: v1(64.66,24.22) 64.43,24.45 64.43,25 64.66,25.22 69.02,25.22 72.58,28.79 72.58,36.86 73.5,37.78 73.5,38.74 v1(73.72,38.96)
PCIE11_SATA_TXP_C_RE_C: length 4.3
  TOP w0.14: CN2069.25 62.74,20.93 62.62,21.05 62.62,21.24 63.6,22.22 64,22.22 64.29,22.51 64.29,22.87 C95563.2
PCIE12_SATA_RXN: length 244.1
  TOP w0.14: v1(84.44,47.38) 84.6,47.21 84.6,46.91 84.44,46.75 83.69,46.75 83.21,47.23 83.21,48.34 83.21,48.34 83.21,48.38 80.78,50.8 80.78,51.52 v1(80.77,51.53) 80.06,51.53 79.83,51.76 77.79,51.76 77.06,52.49 74.21,52.49 72.46,50.74 71.15,50.74 69.86,49.46 69.15,49.46 68.72,49.03 68.72,48.37 C95839.2 ; U13113.G33 294.51,68.82 v2(294.23,69.1)
  IN4 w0.089: v2(294.23,69.1) 294.39,69.27 294.39,69.39 294.28,69.5 283.88,69.5 280.29,65.91 210.88,65.91 210.38,66.41 205.88,66.41 205.54,66.07 198.77,66.07 198.22,65.52 197.81,65.52 194.12,61.83 190.77,61.83 189.45,60.5 185.38,60.5 185.23,60.35 179.22,60.35 178.58,59.72 178.58,59.24 176.84,57.5 174.02,57.5 172.56,56.03 171.79,56.03 168.16,52.4 131.15,52.4 130.84,52.71 128.33,52.71 128.01,52.39 116.58,52.39 116.29,52.1 96.47,52.1 94.23,49.85 90.85,49.85 89.41,48.41 86.98,48.41 85.27,46.69 84.92,46.69 84.71,46.9 84.71,47.11 v1(84.44,47.38)
PCIE12_SATA_RXN_C: length 3.3
  TOP w0.14: C95839.1 68.71,47.43 68.71,47 68.79,46.92 68.79,45.38 68.94,45.23 U13147.20
PCIE12_SATA_RXN_C_RE: length 28.9
  TOP w0.14: v1(58.35,24.74) 58.36,24.74 58.85,24.25 58.85,23.48 58.74,23.37 R21730.1 ; v1(66.63,39.64) 66.82,39.83 66.82,40.34 67.1,40.62 68.08,40.62 68.62,40.08 68.83,40.08 68.94,40.18 U13147.29
  IN5 w0.089: v1(66.63,39.64) 66.87,39.4 66.87,39.11 68.94,37.04 68.94,33.84 65.82,30.72 65.82,28.45 65.41,28.05 61.16,28.05 60.62,27.5 59.96,27.5 58.67,26.2 58.67,25.06 v1(58.35,24.74)
PCIE12_SATA_RXN_C_RE_C: length 3.2
  TOP w0.14: CN2069.5 57.74,20.93 57.86,21.05 57.86,21.25 58.69,22.09 58.69,22.23 R21730.2
PCIE12_SATA_RXP: length 244.2
  TOP w0.14: v2(294.91,69.1) 295.28,68.74 U13113.H33 ; v1(85.11,47.34) 84.87,47.1 84.87,46.8 84.55,46.48 83.58,46.48 82.94,47.12 82.94,48.23 82.94,48.23 82.94,48.27 80.59,50.62 80.59,50.61 v1(79.85,50.61) 79.85,51.35 79.72,51.49 77.68,51.49 76.95,52.23 74.32,52.23 72.57,50.47 71.26,50.47 69.98,49.19 69.26,49.19 68.99,48.92 68.99,48.37 C95840.2
  IN4 w0.089: v1(85.11,47.34) 84.87,47.1 84.87,46.97 84.99,46.86 85.2,46.86 86.91,48.57 89.34,48.57 90.78,50.02 94.16,50.02 96.4,52.27 116.22,52.27 116.51,52.56 127.94,52.56 128.26,52.88 130.91,52.88 131.22,52.57 168.09,52.57 171.72,56.2 172.49,56.2 173.95,57.66 176.77,57.66 178.41,59.31 178.41,59.79 179.15,60.52 185.16,60.52 185.31,60.67 189.38,60.67 190.7,61.99 194.05,61.99 197.74,65.69 198.15,65.69 198.7,66.23 205.47,66.23 205.81,66.58 210.45,66.58 210.95,66.08 280.22,66.08 283.81,69.67 294.35,69.67 v2(294.91,69.1)
PCIE12_SATA_RXP_C: length 3.3
  TOP w0.14: C95840.1 68.98,47.42 68.98,47.11 69.06,47.03 69.06,45.49 69.34,45.21 U13147.19
PCIE12_SATA_RXP_C_RE: length 28.9
  TOP w0.14: U13147.30 69.34,40.2 68.95,39.81 68.51,39.81 67.97,40.35 67.21,40.35 67.08,40.22 67.08,39.78 67.22,39.64 v1(67.48,39.64) ; v1(59,24.76) 59,24.48 59.11,24.36 59.11,23.61 R21726.1
  IN5 w0.089: v1(67.48,39.64) 67.12,39.64 67.04,39.55 67.04,39.18 69.11,37.11 69.11,33.77 65.98,30.65 65.98,28.38 65.48,27.88 61.23,27.88 60.69,27.33 60.03,27.33 58.84,26.13 58.84,24.92 v1(59,24.76)
PCIE12_SATA_RXP_C_RE_C: length 3.3
  TOP w0.14: R21726.2 58.96,22.19 58.96,21.98 58.12,21.14 58.12,21.05 58.24,20.93 CN2069.7
PCIE12_SATA_TXN: length 239.3
  TOP w0.14: C95838.2 70.24,48.36 70.24,48.72 71.4,49.88 72.79,49.88 74.62,51.71 76.73,51.71 80.02,48.42 80.02,47.53 v1(80.26,47.29) ; U13113.B35 291.92,69.62 291.28,69.62 291,69.89 288.52,69.89 288.35,69.73 285.94,69.73 284.91,68.7 v1(284.91,68.55)
  IN4 w0.089: v1(80.26,47.29) 79.99,47.02 79.99,46.75 80.16,46.58 83.15,46.58 83.51,46.22 83.97,45.77 84.01,45.73 85.65,45.73 87.27,47.35 89.83,47.35 91.34,48.86 94.89,48.86 97.08,51.05 117.95,51.05 118.33,51.44 128.55,51.44 128.8,51.68 130.17,51.68 130.4,51.45 173.07,51.45 174.77,53.15 175.75,53.15 177.07,54.47 177.7,54.47 179.24,56.01 180.97,56.01 181.18,56.23 188.49,56.23 188.9,55.81 194.15,55.81 194.27,55.69 196.79,55.69 196.92,55.56 198.87,55.56 199.23,55.21 202.76,55.21 206.61,59.06 207.4,59.06 209.53,61.18 210.91,61.18 211.52,61.79 277.64,61.79 283.58,67.72 284.5,67.72 285.04,68.27 285.04,68.41 v1(284.91,68.55)
PCIE12_SATA_TXN_C: length 3.4
  TOP w0.14: U13147.17 70.14,45.07 70.24,45.17 70.24,46.18 70.51,46.45 70.51,46.88 70.24,47.15 70.24,47.43 C95838.1
PCIE12_SATA_TXN_C_RE: length 25.7
  TOP w0.14: v1(60.2,24.21) 60.47,23.94 60.47,23.81 C95558.1 ; U13147.32 70.14,39.7 69.04,38.61 69.04,36.3 69.42,35.93 69.67,35.93 v1(69.9,35.7)
  IN5 w0.089: v1(60.2,24.21) 60.42,24.43 60.42,24.71 60.58,24.87 60.58,26.67 61.4,27.49 65.65,27.49 66.44,28.28 66.44,30.55 69.54,33.65 69.54,34.56 70.36,35.38 70.36,35.84 70.29,35.91 70.1,35.91 v1(69.9,35.7)
PCIE12_SATA_TXN_C_RE_C: length 3.8
  TOP w0.14: C95558.2 60.47,22.85 60.47,22.52 59.36,21.4 59.36,21.05 59.24,20.93 CN2069.11
PCIE12_SATA_TXP: length 239.3
  TOP w0.14: U13113.A35 291.69,69.35 291.17,69.35 290.89,69.63 288.63,69.63 288.46,69.46 286.05,69.46 285.37,68.79 285.37,68.38 285.51,68.24 v1(285.69,68.24) ; C95841.2 70.51,48.37 70.51,48.62 71.51,49.61 72.91,49.61 74.73,51.44 76.62,51.44 79.75,48.31 79.75,47.44 v1(79.6,47.29)
  IN4 w0.089: v1(285.69,68.24) 285.85,68.4 285.85,68.57 285.77,68.65 285.41,68.65 285.31,68.54 285.31,68.38 285.29,68.37 285.29,68.28 284.57,67.56 283.65,67.56 277.71,61.62 211.58,61.62 210.98,61.01 209.6,61.01 207.47,58.89 206.68,58.89 202.83,55.04 199.16,55.04 198.8,55.4 196.85,55.4 196.72,55.53 194.2,55.53 194.08,55.64 188.84,55.64 188.42,56.06 181.25,56.06 181.04,55.85 179.31,55.85 177.77,54.3 177.14,54.3 175.82,52.98 174.84,52.98 173.14,51.28 130.33,51.28 130.1,51.51 128.87,51.51 128.62,51.27 118.4,51.27 118.02,50.89 97.15,50.89 94.96,48.7 91.41,48.7 89.9,47.18 87.34,47.18 85.72,45.56 83.94,45.56 83.39,46.1 83.08,46.41 80.09,46.41 79.83,46.68 79.83,47.06 v1(79.6,47.29)
PCIE12_SATA_TXP_C: length 3.4
  TOP w0.14: C95841.1 70.51,47.42 70.51,47.26 70.77,46.99 70.77,46.34 70.51,46.07 70.51,45.34 70.54,45.3 U13147.16
PCIE12_SATA_TXP_C_RE: length 25.7
  TOP w0.14: v1(60.87,24.24) 60.73,24.1 60.73,23.81 C95555.1 ; U13147.33 70.54,40.12 70.41,39.99 70.41,39.59 69.31,38.5 69.31,36.42 69.51,36.21 69.87,36.21 v1(70.02,36.36)
  IN5 w0.089: v1(70.02,36.36) 70.31,36.07 70.36,36.07 70.53,35.91 70.53,35.31 69.71,34.49 69.71,33.58 66.61,30.48 66.61,28.21 65.72,27.32 61.47,27.32 60.75,26.6 60.75,24.8 60.59,24.64 60.59,24.3 60.65,24.24 v1(60.87,24.24)
PCIE12_SATA_TXP_C_RE_C: length 3.8
  TOP w0.14: CN2069.13 59.74,20.93 59.62,21.05 59.62,21.29 60.74,22.41 60.74,22.87 C95555.2
PCIE13_SATA_RXN: length 301
  TOP w0.14: U13113.D43 293.16,73.54 293.02,73.4 v2(292.81,73.4) ; v1(47.42,43.42) 47.71,43.13 47.71,42.48 C95866.2
  IN4 w0.089: v1(47.42,43.42) 47.72,43.42 47.81,43.51 47.81,43.79 47.57,44.03 47.34,44.03 46.95,43.64 46.95,42.9 45.94,41.89 43.08,41.89 42.45,42.52 42.45,49.75 41.43,50.76 41.43,54.49 42.89,55.95 42.89,58.74 44.59,60.44 45.89,60.44 46.41,59.93 48.79,59.93 49.35,59.37 51.95,59.37 52.71,58.61 55.22,58.61 56.99,56.85 60.39,56.85 61.17,56.07 62.16,56.07 64.44,53.79 65.37,53.79 65.6,54.02 68.5,54.02 68.73,53.79 72.54,53.79 73.66,52.66 80.8,52.66 83.95,55.81 92.94,55.81 94.85,57.72 107.21,57.72 108.9,59.4 113.96,59.4 114.32,59.76 117.59,59.76 118.21,59.14 123.17,59.14 124.26,58.05 129.54,58.05 130,58.5 133.76,58.5 134.11,58.85 144.33,58.85 144.77,58.42 152.45,58.42 153.03,58.99 153.87,58.99 154.47,58.4 158.81,58.4 159.25,58.84 161.79,58.84 162.58,59.63 166.49,59.63 170,63.14 170.4,63.14 172.41,65.15 172.41,65.83 174.42,67.84 175.51,67.84 178.28,70.6 179.54,70.6 180.54,71.61 190.05,71.61 191.09,72.65 199.96,72.65 202.8,75.49 203.43,75.49 206.55,78.6 206.55,79.41 209.93,82.8 273.57,82.8 280.81,75.55 287.09,75.55 287.49,75.15 289.53,75.15 291.36,73.32 291.96,73.32 292.18,73.1 292.74,73.1 292.81,73.16 v2(292.81,73.4)
PCIE13_SATA_RXN_C: length 3.6
  TOP w0.14: C95866.1 47.68,41.56 47.68,41.48 47.5,41.29 47.34,41.29 47.11,41.05 47.11,40.5 46.45,39.84 46.45,39.59 46.34,39.48 U13149.13
PCIE13_SATA_RXN_C_RE: length 15.9
  TOP w0.14: R21799.1 41.63,23.88 41.63,24.1 41.76,24.24 41.76,24.86 v1(41.94,25.04) ; v1(46.59,31.74) 46.78,31.93 46.78,32.2 46.25,32.73 46.25,33.69 46.36,33.81 46.36,34.13 46.34,34.15 U13149.36
  IN5 w0.089: v1(41.94,25.04) 41.69,24.78 41.69,24.57 41.84,24.43 42.15,24.43 42.58,24.85 42.58,26.42 46.87,30.71 46.87,31.46 v1(46.59,31.74)
PCIE13_SATA_RXN_C_RE_C: length 3.2
  TOP w0.14: R21799.2 41.43,22.09 41.43,21.67 41.2,21.44 41.2,20.83 41.24,20.79 CN2070.43
PCIE13_SATA_RXP: length 301
  TOP w0.14: C95870.2 47.98,42.48 47.98,43.13 v1(48.27,43.42) ; v2(293.75,72.91) 293.49,73.17 U13113.E42
  IN4 w0.089: v1(48.27,43.42) 48,43.69 48,43.83 47.64,44.2 47.27,44.2 46.78,43.7 46.78,42.97 45.87,42.05 43.15,42.05 42.62,42.59 42.62,49.82 41.6,50.83 41.6,54.42 43.06,55.88 43.06,58.67 44.66,60.28 45.82,60.28 46.34,59.76 48.73,59.76 49.28,59.2 51.89,59.2 52.64,58.45 55.15,58.45 56.92,56.68 60.32,56.68 61.1,55.91 62.09,55.91 64.37,53.62 65.44,53.62 65.67,53.85 68.43,53.85 68.66,53.62 72.47,53.62 73.6,52.49 80.87,52.49 84.02,55.64 93.01,55.64 94.92,57.55 107.28,57.55 108.97,59.23 114.03,59.23 114.39,59.59 117.52,59.59 118.14,58.97 123.1,58.97 124.19,57.88 129.61,57.88 130.07,58.34 133.83,58.34 134.18,58.69 144.26,58.69 144.7,58.25 152.52,58.25 153.1,58.82 153.8,58.82 154.4,58.23 158.88,58.23 159.32,58.68 161.86,58.68 162.65,59.46 166.56,59.46 170.07,62.97 170.47,62.97 172.58,65.08 172.58,65.76 174.49,67.67 175.58,67.67 178.35,70.44 179.61,70.44 180.61,71.44 190.12,71.44 191.16,72.48 200.03,72.48 202.87,75.32 203.5,75.32 206.72,78.53 206.72,79.34 210,82.63 273.5,82.63 280.74,75.38 287.02,75.38 287.42,74.98 289.46,74.98 291.29,73.15 291.89,73.15 292.11,72.93 293.73,72.93 v2(293.75,72.91)
PCIE13_SATA_RXP_C: length 3.6
  TOP w0.14: C95870.1 47.95,41.5 47.95,41.37 47.61,41.03 47.45,41.03 47.37,40.94 47.37,40.39 46.71,39.73 46.71,39.5 46.74,39.48 U13149.12
PCIE13_SATA_RXP_C_RE: length 15.9
  TOP w0.14: v1(47.31,31.74) 47.05,32.01 47.05,32.31 46.51,32.84 46.51,33.58 46.63,33.7 46.63,34.26 46.74,34.37 U13149.37 ; v1(41.28,24.76) 41.49,24.55 41.49,24.34 41.36,24.21 41.36,23.81 R21798.1
  IN5 w0.089: v1(41.28,24.76) 41.52,24.52 41.52,24.5 41.77,24.26 42.22,24.26 42.74,24.78 42.74,26.35 47.04,30.64 47.04,31.46 v1(47.31,31.74)
PCIE13_SATA_RXP_C_RE_C: length 3
  TOP w0.14: CN2070.41 40.74,20.75 40.93,20.94 40.93,21.55 41.17,21.78 41.17,22.54 R21798.2
PCIE13_SATA_TXN: length 298.1
  TOP w0.14: U13113.A41 291.57,72.53 291.44,72.65 289.44,72.65 288.91,73.18 288.91,73.59 v1(289.11,73.8) ; C95860.2 51.43,40.68 51.63,40.68 51.86,40.9 v1(51.86,41.18)
  IN4 w0.089: v1(51.86,41.18) 51.86,40.85 51.62,40.61 51.13,40.61 50.94,40.8 50.94,42.09 51.12,42.27 51.9,42.27 52.28,42.65 52.28,43.22 52.16,43.34 52.16,48.88 51.52,49.51 49.41,49.51 47.52,51.4 46.66,51.4 45.18,52.88 45.18,54.51 44.74,54.95 44.74,56.64 46.14,58.04 46.46,58.04 48.77,55.73 51.6,55.73 53.82,53.51 56.81,53.51 56.97,53.67 59.18,53.67 59.46,53.94 59.88,53.94 60.2,53.62 60.2,53.09 60.63,52.65 61.4,52.65 62.87,51.18 64.79,51.18 65.08,50.89 66.18,50.89 66.78,51.49 69.07,51.49 70.17,50.39 77.64,50.39 78.03,50.78 81.55,50.78 84.32,53.55 93.68,53.55 95.22,55.08 99.82,55.08 100.41,55.67 108.06,55.67 108.93,56.54 115.39,56.54 115.71,56.23 117.88,56.23 118.42,56.77 122.74,56.77 123.51,56 128.26,56 128.54,55.72 133.78,55.72 134.72,56.66 139.25,56.66 139.91,56 149.27,56 149.38,56.11 165.79,56.11 169.07,59.39 170.46,59.39 172.49,61.41 172.49,62.45 175.93,65.89 178.22,65.89 180.06,67.73 181.77,67.73 182.31,68.27 188.48,68.27 189.1,68.89 193.89,68.89 194.56,69.55 195.51,69.55 196.61,70.65 202.72,70.65 209.06,77 209.06,79 210.71,80.65 272.45,80.65 275.23,77.87 275.23,75.65 276.03,74.85 278.54,74.85 280.14,73.24 288.67,73.24 288.82,73.4 288.82,73.71 288.9,73.8 v1(289.11,73.8)
PCIE13_SATA_TXN_C: length 4.5
  TOP w0.14: C95860.1 50.23,40.91 49.6,40.27 49.6,40.27 49.36,40.03 47.81,40.03 47.54,39.76 U13149.10
PCIE13_SATA_TXN_C_RE: length 14.6
  TOP w0.14: U13149.39 47.54,34.35 47.61,34.29 47.61,33.99 48.19,33.41 48.19,31.86 v1(48.05,31.72) ; C95636.1 42.88,23.52 v1(42.9,23.54)
  IN5 w0.089: v1(48.05,31.72) 48.24,31.53 48.24,31.13 43.24,26.12 43.24,23.88 v1(42.9,23.54)
PCIE13_SATA_TXN_C_RE_C: length 3.1
  TOP w0.14: CN2070.47 42.24,20.79 42.36,20.91 42.36,21.25 43.13,22.02 43.13,22.22 C95636.2
PCIE13_SATA_TXP: length 298.1
  TOP w0.14: v1(288.43,73.82) 288.64,73.6 288.64,73.07 289.32,72.39 291.33,72.39 U13113.A40 ; v1(51.86,40.26) 51.72,40.4 51.45,40.4 C95871.2
  IN4 w0.089: v1(288.43,73.82) 288.65,73.61 288.65,73.47 288.6,73.41 280.21,73.41 278.61,75.01 276.1,75.01 275.4,75.72 275.4,77.94 272.52,80.82 210.64,80.82 208.89,79.07 208.89,77.07 202.65,70.82 196.54,70.82 195.44,69.72 194.49,69.72 193.82,69.05 189.03,69.05 188.41,68.43 182.24,68.43 181.7,67.9 179.99,67.9 178.15,66.06 175.86,66.06 172.32,62.52 172.32,61.48 170.39,59.55 169,59.55 165.72,56.27 149.31,56.27 149.2,56.17 139.98,56.17 139.32,56.83 134.65,56.83 133.71,55.89 128.61,55.89 128.33,56.17 123.58,56.17 122.81,56.94 118.35,56.94 117.81,56.39 115.78,56.39 115.46,56.71 108.86,56.71 107.99,55.84 100.34,55.84 99.75,55.25 95.15,55.25 93.61,53.71 84.25,53.71 81.48,50.95 77.96,50.95 77.57,50.56 70.24,50.56 69.14,51.66 66.71,51.66 66.11,51.06 65.15,51.06 64.86,51.35 62.94,51.35 61.47,52.82 60.7,52.82 60.37,53.16 60.37,53.69 59.95,54.11 59.39,54.11 59.11,53.83 56.9,53.83 56.74,53.68 53.89,53.68 51.67,55.9 48.84,55.9 46.53,58.21 46.07,58.21 44.58,56.71 44.58,54.88 45.01,54.44 45.01,52.81 46.59,51.23 47.45,51.23 49.34,49.34 51.46,49.34 51.99,48.81 51.99,43.27 52.12,43.15 52.12,42.72 51.83,42.43 51.05,42.43 50.77,42.16 50.77,40.73 51.06,40.45 51.67,40.45 v1(51.86,40.26)
PCIE13_SATA_TXP_C: length 4.5
  TOP w0.14: C95871.1 50.75,40.32 50.42,40.64 50.34,40.64 49.71,40.01 49.47,39.77 47.92,39.77 47.81,39.65 47.81,39.46 47.94,39.33 U13149.9
PCIE13_SATA_TXP_C_RE: length 14.7
  TOP w0.14: v1(48.72,31.72) 48.46,31.98 48.46,33.52 47.87,34.1 47.87,34.29 47.94,34.35 U13149.40 ; C95637.1 43.6,23.51 v1(43.55,23.56)
  IN5 w0.089: v1(43.55,23.56) 43.4,23.7 43.4,26.05 48.41,31.06 48.41,31.4 v1(48.72,31.72)
PCIE13_SATA_TXP_C_RE_C: length 3
  TOP w0.14: C95637.2 43.4,22.27 43.4,21.91 42.62,21.14 42.62,20.91 42.74,20.79 CN2070.49
PCIE14_SATA_RXN: length 293.6
  TOP w0.14: U13113.F41 293.92,72.23 v2(294.28,71.87) ; v1(43.26,43.42) 43.55,43.13 43.55,42.45 C95847.2
  IN4 w0.089: v1(43.26,43.42) 43.62,43.78 43.62,46.02 43.29,46.35 43.29,49.93 41.99,51.23 41.99,54.11 43.45,55.57 43.45,58.51 44.75,59.81 45.49,59.81 45.95,59.34 47.23,59.34 47.83,58.74 51.79,58.74 53.28,57.24 55.77,57.24 56.93,56.07 57.43,56.07 58.05,55.45 61.88,55.45 64.18,53.15 65.53,53.15 65.84,53.46 68.27,53.46 68.49,53.23 68.5,53.23 68.57,53.15 72.28,53.15 73.37,52.07 81.01,52.07 84.02,55.09 93.15,55.09 95.13,57.07 107.54,57.07 108.59,58.12 114.25,58.12 115.16,59.04 117.39,59.04 118.31,58.12 123.37,58.12 124.08,57.41 129.7,57.41 130.09,57.8 133.92,57.8 134.31,58.19 139.76,58.19 140.63,57.32 145.34,57.32 145.74,57.72 159.05,57.72 159.61,58.28 163.05,58.28 163.79,59.02 166.68,59.02 170.23,62.58 170.68,62.58 173.04,64.94 173.04,65.66 174.65,67.28 175.75,67.28 178.45,69.98 181.59,69.98 181.76,70.14 182.47,70.14 182.77,70.45 190.21,70.45 191.77,72.02 201.86,72.02 203.73,73.88 203.73,74.9 207.39,78.55 207.39,79.24 210.23,82.09 273.12,82.09 280.22,74.99 286.85,74.99 287.33,74.51 289.26,74.51 291.09,72.68 291.62,72.68 291.76,72.53 293.86,72.53 294.08,72.31 294.08,72.08 v2(294.28,71.87)
PCIE14_SATA_RXN_C: length 3
  TOP w0.14: C95847.1 43.61,41.5 43.61,39.66 43.54,39.59 U13149.20
PCIE14_SATA_RXN_C_RE: length 16.7
  TOP w0.14: v1(38.5,24.81) 38.68,24.63 38.68,24.45 38.55,24.32 38.35,24.32 38.02,24 38.02,23.57 37.93,23.47 R21794.1 ; v1(40.7,33.54) 40.89,33.74 40.89,34.18 41.17,34.46 42.49,34.46 42.78,34.17 43.22,34.17 43.54,34.49 U13149.29
  IN5 w0.089: v1(40.7,33.54) 41,33.24 41,32.86 40.81,32.67 40.81,31.3 41.23,30.88 41.23,28.35 38.71,25.83 38.71,25.02 v1(38.5,24.81)
