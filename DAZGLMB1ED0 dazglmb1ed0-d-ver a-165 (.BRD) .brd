# Allegro board DAZGLMB1ED0 dazglmb1ed0-d-ver a-165 (.BRD) .brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on TOP (solid shape): 78.43,60.7 78.43,58.7 78.37,58.64 77.69,58.64 77.55,58.51 77.55,58.07 77.41,57.93 75.39,57.93 75.31,58.01 75.31,59.9 75.62,60.21 76.58,60.21 77.26,60.9 78.23,60.9
GND on TOP (solid shape): 113.16,106.25 113.16,104.53 113.48,104.21 113.48,101.29 113.38,101.18 110.15,101.18 109.37,101.97 109.37,103.01 111.5,105.15 111.5,106.14 111.86,106.49 112.92,106.49
GND on TOP (solid shape): 340.38,77.71 340.38,77.68 340.37,77.56 340.38,77.45 340.38,76.8 340.23,76.64 339.36,76.64 338.93,77.07 338.93,77.74 338.98,77.79 340.3,77.79
GND on TOP (solid shape): 224.68,139.67 224.68,134.2 224.3,133.82 223.29,133.82 222.91,134.2 222.91,135.88 222.98,135.95 222.98,136.32 222.91,136.39 222.91,137.87 222.51,138.27 222.51,139.66 222.65,139.79 224.56,139.79
GND on TOP (solid shape): 47.62,25.74 47.62,23.44 47.54,23.36 46.1,23.36 46.04,23.42 46.03,23.45 46.01,23.62 45.94,23.78 45.94,25.75 46.04,25.85 47.51,25.85
GND on TOP (solid shape): 140.61,129.25 140.61,128.36 139.72,127.47 139.72,124.3 139.34,123.92 137.69,123.92 137.05,123.28 137.05,122.52 136.93,122.39 134.64,122.39 134.26,122.77 134.26,123.16 139.09,127.98 139.09,129.51 139.21,129.63 140.23,129.63
GND on TOP (solid shape): 158.67,60.98 158.67,60.47 158.52,60.32 158.06,60.32 157.93,60.19 157.93,59.72 156.93,58.72 155.21,58.72 155.09,58.84 155.09,60.62 155.21,60.75 157.88,60.75 158.21,61.08 158.57,61.08
GND on TOP (solid shape): 187.1,180.29 185.9,180.29 185.9,180.8 124.3,180.8 124.3,157.4 112.6,157.4 112.6,122.98 112.38,122.76 112.38,112.75 111.4,112.75 111.4,158.6 123.1,158.6 123.1,182 187.1,182
GND on TOP (solid shape): 98.04,46.55 98.04,44.7 97.94,44.59 92.81,44.59 92.63,44.77 92.63,44.79 92.65,44.92 92.63,45.05 92.63,45.06 92.63,45.97 92.96,46.3 96.39,46.3 96.82,46.73 97.86,46.73
GND on TOP (solid shape): 128.06,92.7 128.06,92.14 128.66,91.55 129.06,91.55 129.1,91.51 129.66,91.51 129.81,91.36 129.81,87.9 129.79,87.9 129.61,87.72 128.87,87.72 125.98,90.62 122.47,90.62 122.02,91.08 122.02,94.71 122.42,95.11 125.65,95.11
GND on TOP (solid shape): 57.41,21.45 57.41,21.23 57.29,21.12 57.29,19.8 57.38,19.71 57.38,19.24 57.16,19.02 56.03,19.02 55.9,19.14 57.1,19.14 57.1,20.74 56.88,20.74 56.88,19.14 55.9,19.14 55.62,19.42 55.62,21.41 55.72,21.51 57.35,21.51
GND on TOP (solid shape): 102.13,71.72 102.13,70.83 102.26,70.7 106.57,70.7 106.83,70.96 106.83,71.21 106.95,71.34 108.35,71.34 108.61,71.09 108.61,69.82 108.22,69.43 106.95,69.43 106.57,69.82 103.14,69.82 102.89,69.56 101.37,69.56 101.11,69.82 101.11,71.72 101.24,71.85 102,71.85
GND on TOP (solid shape): 128.29,108.13 127.66,107.5 125.38,107.5 124.4,106.53 124.4,102.73 123.9,102.23 123.9,100.85 123.85,100.8 122.58,100.8 122.45,100.93 122.45,102.96 122.42,102.99 122.42,108.22 122.24,108.4 121.75,108.4 121.75,109.6 128.29,109.6
GND on TOP (solid shape): 173.27,67.32 173.27,67.29 173.25,67.27 173.25,66.05 173.23,66.02 173.19,66 172.31,66 172.16,65.85 171.68,65.85 171.38,66.15 169.17,66.15 168.93,66.39 168.93,67.66 169.06,67.78 172.8,67.78
GND on TOP (solid shape): 257.28,142.73 257.28,141.48 257.58,141.19 258.13,141.19 258.39,140.94 258.39,138.98 258.01,138.6 253.18,138.6 252.39,137.81 252.39,134.31 252.13,134.04 248.27,134.04 247.95,134.36 247.95,137.79 248.25,138.09 249.38,138.09 249.4,138.09 254.48,143.17 256.84,143.17
GND on TOP (solid shape): 50.73,21.21 50.73,21.2 51.07,20.86 51.07,20.54 50.73,20.2 50.73,20 49.95,19.21 49.1,19.21 49.1,20.74 48.88,20.74 48.88,19.21 48.6,19.21 48.6,20.74 48.38,20.74 48.38,19.21 48.1,19.21 48.1,20.74 48.1,20.74 48.1,21.26 48.45,21.61 50.34,21.61
GND on TOP (solid shape): 102.46,58.13 102.46,52.65 102.15,52.34 98.62,52.34 98.37,52.59 98.37,54.92 97.58,55.7 97.61,55.85 97.58,55.99 97.58,56.89 98.01,57.32 99.82,57.32 100.12,57.62 100.12,58.41 100.43,58.72 101.87,58.72
GND on TOP (solid shape): 189.12,113.38 189.28,113.38 189.3,113.36 191.55,113.36 192.04,112.87 192.04,112.36 191.66,111.98 189.12,111.98 188.36,112.74 187.35,112.74 186.33,113.76 185.82,113.76 185.57,114.01 185.57,115.41 185.06,115.92 181.88,115.92 180.23,117.57 180.23,118.92 181.17,119.85 182.65,119.85
GND on TOP (solid shape): 251.94,159.17 251.94,157.37 251.07,156.51 251.07,153.76 250.41,153.1 250.41,151.53 251.07,150.87 251.07,149.32 250.32,148.57 249.59,148.57 249.26,148.9 249.26,152.66 249.02,152.9 249.02,155.03 248.89,155.16 247.24,155.16 247.24,156.76 248.69,156.76 248.91,156.99 248.91,159.16 249.12,159.37 251.74,159.37
GND on TOP (solid shape): 273.65,156.13 273.65,146.7 273.35,146.4 271.85,146.4 271.57,146.68 271.57,149.49 270.83,150.22 270.86,150.25 270.86,152.57 270.78,152.65 269.06,152.65 269.06,154.22 269.11,154.27 270.43,154.27 270.71,154.55 270.71,156.15 271.11,156.56 273.22,156.56
GND on TOP (solid shape): 76.42,32.27 76.45,32.26 76.47,32.22 76.47,32.02 75.5,32.02 75.5,31.78 76.47,31.78 76.47,31.52 75.5,31.52 75.5,31.28 76.47,31.28 76.47,31.08 76.45,31.05 76.42,31.03 73.86,31.03 73.76,31.13 73.76,32.15 73.88,32.27
GND on TOP (solid shape): 173.77,75.82 173.77,73.54 172.13,71.9 165.35,71.9 165.27,71.82 165.27,70.5 165.2,70.43 163.9,70.43 163.82,70.5 163.82,71.47 163.9,71.54 164.59,71.54 164.71,71.67 164.71,72.81 164.69,72.84 163.9,72.84 163.85,72.89 163.85,73.8 164.03,73.98 167.61,73.98 167.74,74.11 168.3,74.11 170.47,76.28 173.31,76.28
GND on TOP (solid shape): 162.45,75.77 162.45,72.33 162.11,71.99 161.55,71.99 161.44,71.87 153.59,71.87 153.54,71.82 153.54,70.43 153.51,70.4 152.12,70.4 152.12,71.52 152.52,71.52 152.9,71.9 152.98,71.9 152.98,72.71 152.93,72.76 152.9,72.74 152.19,72.74 152.12,72.81 152.12,73.91 152.27,74.06 157.27,74.06 159.52,76.31 161.92,76.31
GND on TOP (solid shape): 233.81,163.94 233.81,163.66 233.83,163.64 233.83,162.32 233.98,162.17 236.09,162.17 236.24,162.02 236.24,160.49 235.99,160.24 235.1,160.24 234.77,159.91 234.77,159.22 234.31,158.77 233.29,158.77 232.96,159.1 232.96,161.13 232.61,161.48 229.18,161.48 229.03,161.64 229.03,162.37 228.75,162.65 228.11,162.65 227.86,162.91 227.86,164.05 227.99,164.18 233.57,164.18
GND on TOP (solid shape): 369.34,88.37 369.34,85.56 369.18,85.4 368.28,85.4 368.02,85.14 368.02,84.7 367.71,84.39 365.22,84.39 365.21,84.38 364.01,84.38 363.48,84.92 362.94,84.92 362.72,85.14 362.72,86.55 362.79,86.62 363.85,86.62 364.34,86.13 367.53,86.13 367.79,86.39 367.79,88.18 368.27,88.66 369.05,88.66
GND on TOP (solid shape): 19.66,40.68 19.66,40.53 19.66,40.52 19.44,40.52 19.13,40.21 19.03,40.07 19,39.89 19,39.72 18.79,39.51 18.22,39.51 18.19,39.55 18.17,39.55 18.16,39.56 17.43,39.56 17.38,39.62 17.38,40.7 17.42,40.74 18.86,40.74 18.89,40.78 19.06,40.78 19.15,40.87 19.48,40.87
GND on TOP (solid shape): 131.36,84.42 131.36,83.81 131.54,83.63 132.4,83.63 132.51,83.74 132.51,84.4 132.58,84.47 133.65,84.47 133.73,84.4 133.73,80.74 133.85,80.61 133.85,79.75 136.6,77 136.6,74.67 133.8,71.87 132.94,71.87 132.84,71.97 132.84,78.99 131.67,80.15 131.67,82.54 131.3,82.91 130.23,82.91 130.14,83 130.14,84.4 130.22,84.47 131.31,84.47
GND on TOP (solid shape): 178.58,106.32 178.58,105.71 179.73,104.56 179.73,101.82 178.71,100.8 176.27,100.8 174.72,99.25 174.72,98.42 173.04,96.74 154.5,96.74 154.05,97.2 154.05,99.53 154.48,99.97 170.53,99.97 172.84,102.28 172.84,104.06 172.85,104.07 172.85,104.4 173.78,105.33 175.94,105.33 177.11,106.49 178.4,106.49
GND on TOP (solid shape): 244.88,158.37 244.88,157.37 244.42,156.91 244.16,156.91 243.78,156.53 243.78,155.13 243.91,155.01 243.91,153.86 243.15,153.1 243.15,151.63 243.91,150.87 243.91,149.22 243.61,148.91 242.62,148.91 242.21,149.32 242.21,152.24 241.57,152.87 241.57,155.03 241.47,155.13 239.77,155.13 239.77,156.68 239.82,156.73 241.14,156.73 241.32,156.91 241.32,158.21 241.56,158.45 244.8,158.45
GND on TOP (solid shape): 258.82,157.67 258.82,154.73 258.34,154.25 258.34,151.81 258.08,151.55 258.08,150.61 257.91,150.44 257.91,148.78 257.64,148.52 256.86,148.52 256.66,148.72 256.66,152.52 256.26,152.92 256.26,154.91 255.98,155.19 254.48,155.19 254.48,156.76 256.3,156.76 256.55,157.01 256.55,158.28 256.71,158.44 258.06,158.44
GND on TOP (solid shape): 343.41,66.97 343.46,66.97 345.73,66.97 345.73,66.97 346.66,66.97 346.76,66.87 346.76,65.86 346.7,65.8 346.7,65.3 346.55,65.15 346.21,65.15 346.07,65.29 346.07,65.63 345.92,65.78 345.66,65.78 345.56,65.79 345.46,65.78 343.1,65.78 342.7,66.17 342.7,66.63 342.56,66.78 342.56,66.79 342.45,66.89 342.45,67.17 342.47,67.18 343.2,67.18
GND on TOP (solid shape): 91.21,75.53 91.23,75.53 91.48,75.45 91.74,75.53 94.89,75.53 95.4,75.02 95.4,73.24 95.14,72.99 90.44,72.99 89.94,73.5 89.94,74.64 89.56,75.02 88.79,75.02 88.41,74.64 88.41,73.5 88.16,73.24 88.16,72.23 88.05,72.12 87.11,72.12 86.61,72.63 86.61,74.92 88.11,76.42 90.32,76.42
GND on TOP (solid shape): 233.95,147.31 233.95,139.95 235.83,138.07 235.83,135.07 235.61,134.84 233.32,134.84 232.54,134.07 231.53,134.07 231.26,134.33 231.26,137.51 230.93,137.84 229.38,137.84 229.15,138.07 229.15,143.2 228.8,143.55 228.29,143.55 228.24,143.6 228.24,144.19 228.34,144.29 228.57,144.29 229.04,144.76 229.04,145.17 229.13,145.25 232.76,145.25 233.09,145.58 233.09,147.24 233.33,147.48 233.79,147.48
GND on TOP (solid shape): 291.52,54.31 292.08,54.31 292.14,54.37 292.41,54.37 292.57,54.21 292.57,53.62 293.21,52.98 293.21,52.72 293.07,52.58 292.74,52.58 292.56,52.4 292.56,51.98 292.42,51.83 291.59,51.83 291.34,52.09 291.34,52.8 291.57,53.04 291.57,53.78 291.37,53.99 290.89,53.99 290.77,53.87 290.12,53.87 289.89,53.65 289.72,53.65 289.63,53.74 289.63,53.97 289.99,54.32 290.72,54.32 290.88,54.47 291.35,54.47
GND on TOP (solid shape): 136.52,96.51 136.52,92.78 136.65,92.65 136.65,90.36 138.73,88.28 138.73,87.55 138.53,87.34 134.56,87.34 134.44,87.47 134.44,94.89 134.23,95.09 133.01,95.09 132.79,94.86 131.8,94.86 131.77,94.89 131.77,95.06 131.85,95.14 132.74,95.14 132.89,95.29 132.89,96.46 133.04,96.61 134.08,96.61 134.18,96.51 134.18,95.95 134.41,95.72 135.2,95.72 135.29,95.81 135.29,96.47 135.48,96.66 136.37,96.66
GND on TOP (solid shape): 117.67,85.54 117.67,84.8 118.03,84.45 121,84.45 121.33,84.12 121.33,81.2 121.1,80.97 116.83,80.97 115.82,81.98 114.8,81.98 113.69,80.86 111.17,80.86 110.48,80.18 110.48,78.2 110.24,77.96 110.2,77.95 110.16,77.94 109.49,77.94 109.11,78.32 109.11,81.22 108.81,81.53 108.15,81.53 107.26,82.41 107.26,85.11 107.67,85.51 110.87,85.51 111.2,85.18 111.2,84.65 111.6,84.24 113,84.24 113.33,84.57 113.33,85.49 113.66,85.82 117.39,85.82
GND on TOP (solid shape): 207.51,84.29 207.51,80.81 204.19,77.49 201.64,77.49 201.49,77.58 201.31,77.6 201.28,77.59 201.14,77.74 200.63,77.74 200.62,77.77 200.5,77.94 200.3,78.03 200.29,78.03 198.5,79.82 198.5,83.1 200.36,84.96 200.45,85.03 200.52,85.12 200.86,85.46 204.46,85.46 204.85,85.84 205.96,85.84
GND on TOP (solid shape): 359.72,62.59 361.75,62.59 361.77,62.58 361.79,62.57 362.1,62.27 362.1,61.3 361.84,61.05 358.16,61.05 358.03,60.93 357.4,60.93 357.27,60.8 357.27,60.49 355.33,58.55 355.33,58.22 355.19,58.08 354.91,58.08 354.78,57.95 354.78,57.7 354.71,57.62 354.6,57.62 354.54,57.69 354.54,59.16 356.05,60.67 356.43,60.67 356.52,60.76 356.53,60.76 356.53,60.77 356.66,60.9 356.66,61.15 357.44,61.93 357.58,61.93 357.6,61.94 357.78,61.94 358.03,62.2 358.03,62.96 358.21,63.14 359.17,63.14
GND on TOP (solid shape): 316.25,49.11 316.31,49.11 316.32,49.1 316.69,49.1 316.7,49.11 316.83,49.11 316.94,49 316.94,48.88 316.96,48.86 316.96,48.72 316.96,48.72 316.96,48.56 317.23,48.29 317.23,47.82 317.17,47.75 315.37,47.75 315.33,47.78 315.32,47.79 315.19,47.92 315.02,47.98 315,47.99 314.95,48.03 314.38,48.03 314.37,48.05 314.37,48.4 314.42,48.45 314.44,48.49 314.47,48.5 314.85,48.5 315.11,48.76 315.11,49.24 315.31,49.44 315.92,49.44
GND on TOP (solid shape): 68.14,35.3 68.14,32.16 68.16,32.14 68.16,31.32 68.42,31.06 69.72,31.06 70.02,30.75 70.02,30.16 70.02,30.15 69.99,30.05 69.99,29.95 69.99,29.94 69.98,29.92 69.83,29.77 69.82,29.77 69.69,29.68 69.61,29.55 69.6,29.54 69.49,29.43 67.65,29.43 67.64,29.43 67.48,29.47 67.32,29.43 67.31,29.43 66.34,29.43 66.14,29.63 66.14,35.37 66.82,36.06 67.38,36.06
GND on TOP (solid shape): 270.53,140.05 270.53,138.9 269.26,137.63 269.26,135.79 269.13,135.67 268.74,135.22 269.23,134.89 269.34,134.89 269.56,134.66 269.56,134.54 269.64,134.46 269.64,133.65 269.49,133.49 267.63,133.49 267.46,133.67 267.46,138.37 267.56,138.47 268.6,138.47 269.01,138.88 269.01,140.3 269.13,140.43 270.15,140.43
GND on TOP (solid shape): 125.64,71.69 125.93,71.46 126.28,71.56 126.35,71.59 126.42,71.56 126.51,71.47 126.51,70.95 126.48,70.94 126.25,70.58 126.48,70.22 126.51,70.2 126.51,68.16 125.88,67.53 122.58,67.53 122.45,67.66 122.45,71.21 122.94,71.71 122.97,71.72 125.63,71.72
GND on TOP (solid shape): 166.64,61.69 166.64,58.34 166.76,58.22 166.76,57.48 166.59,57.32 165.97,57.32 165.61,57.68 164.59,57.68 164.32,57.41 164.32,56.97 164.21,56.86 163.8,56.86 162.99,57.67 162.99,58.49 162.99,58.51 163,58.53 163.2,58.73 163.2,59.06 163,59.26 162.99,59.27 162.99,59.29 162.99,60.42 163.09,60.52 163.95,60.52 164,60.47 165.22,60.47 165.48,60.72 165.48,61.79 165.63,61.94 165.88,61.94 166.39,61.94
GND on TOP (solid shape): 369.33,38.13 369.33,35.07 369.31,35.04 369.3,35.03 369.08,34.8 369.1,34.49 369.17,34.35 369.3,34.25 369.32,34.24 369.33,34.21 369.33,33.27 369.1,33.04 368.52,33.04 367.92,32.43 366.91,32.43 366.76,32.58 366.76,34.58 367.02,34.84 367.67,34.84 367.89,35.06 367.9,35.25 367.89,35.4 367.84,35.46 367.78,35.52 367.71,35.58 367.6,35.7 367.6,35.7 367.6,37.95 367.91,38.27 369.18,38.27
GND on TOP (solid shape): 265.75,155.77 265.75,155.46 265.74,155.36 265.75,155.27 265.75,153.89 265.66,153.64 265.75,153.38 265.75,152.03 265.75,151.54 265.75,150.82 265.39,150.45 265.39,150.37 265.37,150.36 265.37,149.14 265.75,148.76 265.75,148.02 265.74,148 265.74,146.71 265.42,146.4 264.76,146.4 264.36,146.8 264.36,149.42 263.49,150.28 263.49,152.7 261.74,152.7 261.71,152.71 261.69,152.75 261.69,154.25 261.74,154.3 262.72,154.3 262.73,154.3 262.98,154.3 262.99,154.3 263.19,154.3 263.39,154.5 263.39,155.87 263.67,156.15 265.37,156.15
GND on TOP (solid shape): 313.03,53.31 313.03,53.21 312.98,53.16 312.96,53.16 312.59,52.91 312.68,52.47 312.86,52.47 313.15,52.18 313.15,51.8 313.02,51.67 312.42,51.67 312.13,51.97 312.13,52.25 311.92,52.46 311.58,52.46 311.34,52.7 311.34,53.07 311.42,53.15 311.5,53.18 311.57,53.15 311.93,53.03 312.21,53.28 312.4,53.31 312.56,53.41 312.93,53.41
GND on TOP (solid shape): 200,77.94 199.97,77.36 200.55,77.39 200.6,77.44 200.64,77.5 200.72,77.55 200.8,77.52 200.99,77.33 200.98,77.3 201.09,76.93 201.46,76.82 201.49,76.83 202.37,75.95 202.37,75.11 201.84,74.58 201.28,74.58 201.28,74.56 201.06,74.56 200.93,74.44 200.43,74.44 199.61,75.25 199.61,75.71 199.37,75.95 198.94,75.95 198.5,76.39 198.5,78.2 198.62,78.32 199.61,78.32
GND on TOP (solid shape): 64.79,28.77 64.8,28.75 64.81,28.72 65,28.32 65.45,28.36 66.87,28.36 67.28,27.96 68.14,27.96 68.24,27.86 68.24,27.35 68.05,27.16 64.93,27.16 64.92,27.14 61.67,27.14 61.56,27.25 61.56,28.52 61.74,28.69 61.83,28.69 61.84,28.69 62.07,28.62 62.3,28.69 62.31,28.69 62.45,28.69 62.61,28.85 63.02,28.85 63.24,28.76 63.47,28.79 63.48,28.79 63.85,28.79 63.86,28.79 64.04,28.75 64.22,28.79 64.23,28.79 64.28,28.79 64.36,28.87 64.69,28.87
GND on TOP (solid shape): 159.24,132.17 159.27,132.14 159.27,132.06 159.29,132 159.27,131.98 159.27,131.96 159.18,131.89 159.13,131.82 159.09,131.78 159.09,131.6 159.36,131.34 160.77,131.34 161.33,130.78 161.33,130.78 161.39,130.72 161.36,130.68 161.36,130.58 161.17,130.39 161.04,130.39 160.74,130.69 160.74,130.8 160.54,131 160.27,131 159.97,130.7 159.97,130.6 159.76,130.4 159.63,130.4 159.34,130.69 159.34,130.81 158.78,131.37 155.72,131.37 155.3,130.95 155.27,130.9 155.22,130.87 155.04,130.69 155.04,130.63 154.84,130.44 154.8,130.43 154.7,130.44 154.51,130.62 153.71,130.62 153.51,130.43 153.3,130.43 153.16,130.57 152.95,130.57 152.78,130.4 152.64,130.4 152.17,130.87 152.17,131.24 152.24,131.31 152.31,131.31 152.31,131.31 155.16,131.31 155.43,131.58 155.43,131.8 155.66,132.02 157.87,132.02 157.88,132.04 157.95,132.04 158.22,132.31 158.4,132.31 158.55,132.16 158.77,132.16 158.93,132.32 159.09,132.32
GND on TOP (solid shape): 292.78,72.95 292.94,72.97 292.97,72.97 293,72.94 293.05,72.88 293.1,72.82 293.14,72.74 293.11,72.67 292.96,72.34 293.09,72.02 293.17,71.94 293.17,71.89 293.15,71.85 293.12,71.83 293,71.83 292.99,71.84 292.78,71.88 292.58,71.82 292.55,71.82 292.52,71.83 292.46,71.88 292.37,71.93 292.12,72.18 292.09,72.25 292.08,72.28 292.09,72.3 292.13,72.42 292.15,72.56 292.14,72.57 292.15,72.59 292.52,72.96 292.56,72.96 292.63,72.98
GND on TOP (solid shape): 78.64,72.38 78.68,72.36 78.69,72.32 78.69,71.37 78.78,71.37 78.82,71.35 78.83,71.32 78.83,70.82 79.15,70.5 80.59,70.5 81.05,70.96 83.24,70.96 83.32,70.93 83.35,70.85 83.74,70.45 84.13,70.85 84.16,70.93 84.24,70.96 85.34,70.96 85.68,70.62 85.68,67.46 85.5,67.29 85.48,67.27 85.45,67.27 85.07,67.17 84.97,66.79 84.98,66.77 84.97,66.75 84.86,66.63 84.86,66.6 83.88,65.63 82.25,65.63 80.55,67.32 80.06,67.32 79.83,67.55 77.43,67.55 77.41,67.56 77.39,67.57 77.06,67.91 77.06,71.48 77.94,72.37 77.97,72.38
GND on TOP (solid shape): 167,122.81 167.09,122.81 167.28,122.61 167.53,122.61 167.78,122.86 168.44,122.86 168.66,122.63 168.95,122.63 169.17,122.85 169.84,122.85 170.07,122.63 170.21,122.63 170.26,122.58 170.26,122.56 170.29,122.5 170.34,122.45 170.44,122.29 170.39,122.12 170.33,122.07 170.27,122.04 170.15,122.04 170.08,122.07 170.03,122.12 169.88,122.2 169.72,122.14 169.68,122.09 168.97,122.09 168.94,122.07 168.91,122.05 168.87,122.04 168.75,122.04 168.71,122.05 168.68,122.07 168.65,122.09 167.57,122.09 167.54,122.07 167.51,122.05 167.47,122.04 167.35,122.04 167.26,122.09 167.2,122.16 167.17,122.22 166.46,122.22 166.33,122.36 166.29,122.43 166.24,122.5 166.2,122.53 166.2,122.65 166.22,122.68 166.25,122.72 166.29,122.75 166.31,122.76 166.41,122.86 166.95,122.86
GND on TOP (solid shape): 155.36,57.08 155.36,56.05 154.69,55.38 154.45,55.37 154.27,55.2 154.27,54.74 154.45,54.57 154.84,54.57 155.85,55.57 155.85,56.98 156.08,57.21 157.38,57.21 157.66,56.93 157.66,55.5 157.94,55.22 158.13,55.22 158.26,55.09 158.26,53.56 157.8,53.1 149.12,53.1 148.2,54.03 147.55,54.03 147.38,54.2 147.38,54.89 147.45,54.97 148.69,54.97 149,55.28 149.29,55.28 149.43,55.13 149.43,54.83 149.62,54.64 150.01,54.64 150.23,54.86 150.23,55.27 149.69,55.81 148.83,55.81 148.48,55.46 147.93,55.46 147.88,55.51 147.88,56.25 147.95,56.32 149.74,56.32 149.76,56.32 150.04,56.32 150.21,56.39 150.28,56.56 150.28,56.86 150.27,56.9 150.3,56.98 150.37,57.01 151.44,57.01 151.53,56.92 151.53,55.25 151.67,55.11 151.67,54.77 151.86,54.57 152.31,54.57 152.48,54.75 152.48,55.1 152.43,55.15 152.43,55.16 152.35,55.26 152.25,55.34 152.24,55.34 152.07,55.51 152.07,56.66 152.15,56.74 153.32,56.74 153.79,57.21 155.22,57.21
GND on TOP (solid shape): 54.17,17.68 54.3,17.5 54.48,17.37 54.48,17.36 54.64,17.2 54.64,17 54.63,16.99 54.47,16.29 54.86,15.7 54.86,13.01 51.12,13.01 51.12,15.7 51.47,16.15 51.48,16.73 51.48,16.74 51.48,16.98 51.66,17.16 51.81,17.28 51.94,17.42 52.27,17.42 52.53,16.33 52.14,15.28 52.14,14.02 53.84,14.02 53.84,15.28 53.44,16.51 53.92,17.72 54.12,17.72
GND on TOP (solid shape): 335.37,58.45 335.37,58.45 335.35,58.3 335.37,58.16 335.37,58.15 335.37,58.05 335.37,58.04 335.35,57.9 335.37,57.76 335.37,57.75 335.37,57.25 335.37,57.24 335.35,57.1 335.37,56.96 335.37,56.95 335.37,56.85 335.37,56.84 335.35,56.7 335.37,56.56 335.37,56.55 335.37,56.05 335.37,56.04 335.35,55.9 335.37,55.76 335.37,55.75 335.37,55.65 335.37,55.64 335.35,55.5 335.37,55.36 335.37,55.35 335.37,54.85 335.37,54.84 335.35,54.7 335.37,54.56 335.37,54.55 335.37,54.45 335.37,54.44 335.35,54.3 335.37,54.16 335.37,54.15 335.37,53.8 335.3,53.73 332.74,53.73 332.67,53.8 332.67,54.09 332.67,54.1 332.71,54.3 332.67,54.5 332.71,54.7 332.67,54.9 332.67,54.9 332.67,56.49 332.67,56.5 332.71,56.7 332.67,56.9 332.71,57.1 332.67,57.3 332.67,57.3 332.67,57.7 332.67,57.7 332.71,57.9 332.67,58.1 332.7,58.24 332.7,58.37 332.73,58.46 332.8,58.49 335.34,58.49
GND on TOP (solid shape): outline of 91 points within 161.28,130.42 170.44,132.29
GND on TOP (solid shape): outline of 143 points within 68.41,59.49 74.87,66.34
GND on TOP (solid shape): 383,69.39 385,69.39 385,69.39 386.49,69.39 386.49,65.11 381.7,65.11 380.73,64.36 381.19,63.23 381.19,57.77 380.73,56.64 381.7,55.89 386.49,55.89 386.49,37.55 386.06,36.5 385,36.06 379.67,36.06 379.48,36.25 379.48,36.78 380.96,38.27 382.85,38.27 384.6,40.02 384.6,47.08 382.87,48.81 381.43,48.81 380.23,50 380.23,55.51 379.68,56.86 380.18,58.23 380.18,62.77 379.83,63.34 379.68,63.99 377.41,66.26 374.37,66.26 373.3,67.33 373.3,67.51 374.85,69.06 375.33,69.1 375.71,69.39 383,69.39
GND on TOP (solid shape): outline of 101 points within 161.3,138.51 170.44,139.3
GND on TOP (solid shape): 21.84,72.28 21.84,69.46 21.13,68.75 16.05,68.75 13.3,66.01 13.3,65.17 12.24,64.1 10.26,64.1 8.76,62.6 8.76,35.83 6.4,33.47 6.4,31.18 5.81,30.6 0.99,30.6 0.51,31.08 0.51,36.39 5.3,36.39 6.27,37.14 5.81,38.27 5.81,43.73 6.27,44.86 5.3,45.61 0.51,45.61 0.51,54.39 5.3,54.39 6.27,55.14 5.81,56.27 5.81,61.73 6.27,62.86 5.3,63.61 0.51,63.61 0.51,66.2 0.65,66.55 1,66.69 8.14,66.69 9.21,67.13 9.65,68.2 9.65,70.74 18.59,70.74 19.56,71.49 19.1,72.62 19.1,73.02 21.1,73.02
GND on TOP (solid shape): outline of 115 points within 152.17,138.13 160.9,139.29
GND on TOP (solid shape): outline of 149 points within 152.17,122.04 165.79,123.19
GND on TOP (solid shape): 28.4,16.85 28.48,16.81 28.5,16.72 28.51,16.15 28.86,15.7 28.86,13.01 28.5,13.01 27.43,12.57 26.99,11.5 26.99,5.25 26.56,4.19 25.5,3.76 15.5,3.76 14.43,3.32 13.99,2.25 13.99,0.51 7.04,0.51 7.01,0.54 7.01,0.56 5,2.52 2.99,0.56 2.99,0.51 1,0.51 0.65,0.65 0.51,1 0.51,5.02 6.93,5.02 10.26,1.7 12.03,1.7 13.69,2.8 13.31,4.76 13.57,5.02 16.15,5.02 16.5,5.38 16.5,5.96 16.61,6.06 24.55,6.06 25.98,7.48 25.98,11.5 26.47,12.99 27.74,13.91 27.84,13.94 27.84,15.28 27.49,16.02 27.48,16.85
GND on TOP (solid shape): outline of 144 points within 152.17,127.61 170.44,128.79
GND on TOP (solid shape): outline of 195 points within 152.17,124.82 170.05,125.7
GND on TOP (solid shape): outline of 196 points within 152.17,128.95 170,130.18
GND on TOP (solid shape): outline of 165 points within 152.18,139.87 170.42,140.69
GND on TOP (solid shape): outline of 87 points within 345.31,52.98 348.28,56.56
GND on TOP (solid shape): outline of 203 points within 152.18,132.83 170.44,133.76
GND on TOP (solid shape): outline of 215 points within 152.2,137.09 170.44,137.89
GND on TOP (solid shape): outline of 201 points within 152.17,135.72 170.48,136.53
GND on TOP (solid shape): outline of 194 points within 152.17,133.93 170.43,135.12
GND on TOP (solid shape): outline of 194 points within 152.17,123.39 170.44,124.27
GND on TOP (solid shape): outline of 248 points within 152.17,126.17 170.05,127.38
GND on TOP (solid shape): outline of 607 points within 176.06,85.56 220.7,109.8
GND on TOP (solid shape): outline of 165 points within 76.98,0.51 384.99,48.28
GND on TOP (solid shape): outline of 1663 points within 0.51,77.31 386.49,182.49
GND on TOP (solid shape): outline of 2360 points within 293.54,63.23 311.17,74.03
GND on TOP (solid shape): outline of 2189 points within 345.68,48.4 354.4,58.44
GND on TOP (solid shape): outline of 2458 points within 292.6,53.57 306.95,70.13
GND on BOTTOM (solid shape): 56.66,21.37 56.66,19.35 56.62,19.31 55.83,19.31 55.69,19.46 55.69,21.36 55.78,21.45 56.58,21.45
GND on BOTTOM (solid shape): 105.18,67.28 105.18,65.37 104.8,64.99 103.91,64.99 103.65,65.24 103.65,67.28 103.78,67.4 105.05,67.4
GND on BOTTOM (solid shape): 121.36,59.4 121.36,58.13 121.23,58 120.54,58 120.31,58.23 120.31,58.77 120.97,59.43 121.33,59.43
GND on BOTTOM (solid shape): 124.53,61.05 124.53,58.49 124.48,58.44 123.64,58.44 123.62,58.46 123.62,61 123.79,61.18 124.4,61.18
GND on BOTTOM (solid shape): 140.53,122.34 140.53,121.2 140.2,120.87 137.13,120.87 136.77,121.23 136.77,122.39 136.93,122.55 140.33,122.55
GND on BOTTOM (solid shape): 213.99,63.95 213.99,62.5 213.81,62.32 212.84,62.32 212.74,62.42 212.74,63.95 212.8,64 213.94,64
GND on BOTTOM (solid shape): 223.57,152.29 223.57,150.59 222.68,149.7 220.75,149.7 219.98,150.46 219.98,151.43 221.69,153.13 222.73,153.13
GND on BOTTOM (solid shape): 18.81,45.08 18.81,43.21 18.58,42.99 17.29,42.99 17.11,43.17 17.11,45.81 17.11,45.81 17.17,45.86 18.02,45.86
GND on BOTTOM (solid shape): 29.56,20.72 29.56,19.39 29.45,19.28 29.15,19.28 28.4,20.03 28.4,21.31 28.46,21.37 28.91,21.37
GND on BOTTOM (solid shape): 82.93,78.86 82.93,78.02 82.7,77.79 81.88,77.79 81.38,77.28 80.84,77.28 80.72,77.41 80.72,78.93 81.05,79.26 82.52,79.26
GND on BOTTOM (solid shape): 160.04,98.95 160.04,97.1 159.68,96.74 155.72,96.74 154.07,98.39 154.07,100.17 154.2,100.3 158.69,100.3
GND on BOTTOM (solid shape): 207.9,65.87 207.9,55.42 207.84,55.37 206.55,55.37 206.31,55.61 206.31,65.87 206.45,66.01 207.77,66.01
GND on BOTTOM (solid shape): 237.59,66.97 237.59,66.59 237.45,66.44 235.07,66.44 235.02,66.5 235.02,67.02 235.11,67.11 237.45,67.11
GND on BOTTOM (solid shape): 244.75,125.57 244.75,113.12 244.62,113 243.61,113 243.35,113.25 243.35,126.28 243.4,126.33 243.99,126.33
GND on BOTTOM (solid shape): 247.54,127.22 247.54,113.25 247.29,113 246.78,113 246.65,113.12 246.65,127.22 246.78,127.35 247.42,127.35
GND on BOTTOM (solid shape): 363.47,80.71 363.47,78.45 362.78,77.77 359.81,77.77 359.63,77.94 359.63,79.57 359.4,79.8 359.4,80.81 359.86,81.27 362.91,81.27
GND on BOTTOM (solid shape): 82.9,66.95 84.02,66.95 84.09,66.87 84.09,65.75 83.97,65.62 81.68,65.62 81.17,66.13 81.17,67.66 81.43,67.91 81.94,67.91
GND on BOTTOM (solid shape): 169.06,129.38 169.06,129.18 168.9,129.02 166.62,129.02 166.47,129.18 166.47,129.35 166.62,129.51 168.93,129.51
GND on BOTTOM (solid shape): 224.18,141.32 224.18,137.86 224.07,137.76 222.85,137.76 222.42,138.19 222.42,141.19 222.68,141.44 224.05,141.44
GND on BOTTOM (solid shape): 75.56,75.38 75.56,72.89 75.25,72.58 72.79,72.58 72.61,72.76 72.61,73.65 72.23,74.03 71.06,74.03 70.68,74.41 70.68,75.46 70.81,75.59 75.35,75.59
GND on BOTTOM (solid shape): 127.68,63.36 127.68,62.22 127.43,61.97 126.49,61.97 126.33,62.12 126.33,62.63 126.46,62.75 126.92,62.75 126.99,62.83 126.99,63.44 127.12,63.57 127.48,63.57
GND on BOTTOM (solid shape): 165.84,129.52 165.84,128.86 165.68,128.69 163.75,128.69 163.42,129.02 162.43,129.02 162.3,129.15 162.3,129.4 162.4,129.51 163.49,129.51 163.55,129.56 165.81,129.56
GND on BOTTOM (solid shape): 169.06,128.01 169.06,127.78 168.9,127.63 168.57,127.63 168.24,127.3 167.84,127.3 167.51,127.63 166.62,127.63 166.47,127.78 166.47,127.96 166.62,128.11 168.96,128.11
GND on BOTTOM (solid shape): 181,123.92 184.55,123.92 184.81,123.66 184.81,122.39 184.68,122.27 181.76,122.27 180.61,123.41 179.85,123.41 179.73,123.54 179.73,124.55 179.85,124.68 180.23,124.68
GND on BOTTOM (solid shape): 190.52,84.47 190.52,81.75 190.27,81.5 186.91,81.5 186.48,81.93 186.48,82.82 185.97,83.33 183.61,83.33 183.45,83.49 183.45,85.55 183.59,85.69 189.3,85.69
GND on BOTTOM (solid shape): 235.99,126.84 235.99,111.85 235.86,111.73 234.59,111.73 234.46,111.85 234.46,111.98 234.72,112.23 234.72,114.39 234.08,115.03 234.08,126.84 234.21,126.97 235.86,126.97
GND on BOTTOM (solid shape): 241.07,126.71 241.07,122.14 241.19,122.01 241.19,113.38 241.07,113.25 239.29,113.25 239.03,113.5 239.03,125.82 239.29,126.08 239.67,126.08 240.43,126.84 240.94,126.84
GND on BOTTOM (solid shape): 287.45,55.49 287.45,55.21 287.11,54.87 287.11,52.94 286.84,52.68 284.87,52.68 284.68,52.87 284.68,53.51 284.55,53.64 284.55,55.19 284.98,55.62 287.32,55.62
GND on BOTTOM (solid shape): 355.9,44.34 355.9,41.69 355.9,41.52 355.42,41.04 353.92,41.04 353.13,41.83 353.13,43.25 352.72,43.65 352.72,44.24 353.05,44.57 355.67,44.57
GND on BOTTOM (solid shape): 74.05,67.28 74.05,65.28 73.76,64.99 71.47,64.99 70.45,66.01 70.45,67.43 70.61,67.58 73.75,67.58
GND on BOTTOM (solid shape): 213.1,77.33 213.1,74.74 212.62,74.26 212.38,74.26 212.37,74.25 210.95,74.25 210.86,74.34 210.86,76.67 211.37,77.18 211.37,77.18 211.7,77.51 212.92,77.51
GND on BOTTOM (solid shape): 250.01,126.31 252.48,126.31 252.53,126.25 252.53,114.18 252.37,114.01 250.34,114.01 250.08,114.27 250.08,115.57 249.68,115.98 249.68,126.36 249.73,126.41 249.91,126.41
GND on BOTTOM (solid shape): 353.74,65.85 353.74,64.18 352.92,63.35 352.45,63.35 352.4,63.35 352.34,63.34 350.72,63.34 350.31,63.75 350.31,66.23 350.44,66.36 353.23,66.36
GND on BOTTOM (solid shape): 171.14,122.39 171.14,121.35 171.08,121.29 170.77,121.29 170.68,121.38 170.68,121.78 170.42,122.05 170.4,122.03 168.67,122.03 168.56,122.13 168.56,122.45 168.63,122.52 170.3,122.52 170.31,122.53 171,122.53
GND on BOTTOM (solid shape): 233.95,144.19 233.95,141.57 233.07,140.68 230.02,140.68 229.64,140.3 229,140.3 228.87,140.43 228.87,143.25 228.14,143.98 228.14,144.95 228.24,145.05 233.09,145.05
GND on BOTTOM (solid shape): 147.34,109.01 147.34,108.12 148.66,106.8 148.66,104.54 148.53,104.41 145.26,104.41 145.21,104.46 145.21,106.77 145.69,107.26 145.69,108.98 146.12,109.41 146.93,109.41
GND on BOTTOM (solid shape): 138.63,93.54 138.63,90.31 139.03,89.91 139.75,89.91 139.95,89.7 139.95,88.23 138.63,86.91 135.25,86.91 133.61,88.55 133.61,91.48 134.01,91.88 134.01,94.71 133.01,95.7 133.01,96.03 133.24,96.26 135.91,96.26
GND on BOTTOM (solid shape): 135.91,84.52 135.91,78.76 136.37,78.3 137.61,78.3 137.82,78.1 137.82,76.52 134.67,73.37 133.29,73.37 131.97,74.69 131.97,80.26 131.39,80.84 131.39,82.52 130.22,83.68 130.22,83.94 131.34,85.06 135.38,85.06
GND on BOTTOM (solid shape): 273.62,155.99 273.62,146.79 273.45,146.63 272.44,146.63 271.88,147.18 271.88,149.09 271.11,149.85 271.11,150.31 270.44,150.99 270.44,152.48 270.58,152.63 270.58,154.18 270.93,154.53 270.93,154.82 270.94,154.83 270.94,155.72 271.55,156.33 273.27,156.33
GND on BOTTOM (solid shape): 251.91,158.51 251.91,157.34 251.18,156.61 251.18,156.56 251.07,156.46 251.07,149.27 250.36,148.56 249.6,148.56 249.12,149.04 249.12,152.98 248.81,153.28 248.43,153.28 248.38,153.34 248.38,154.81 248.54,154.97 248.54,156.15 248.96,156.58 248.96,158.33 249.27,158.64 251.78,158.64
GND on BOTTOM (solid shape): 243.32,158.46 243.45,158.46 243.45,158.46 244.8,158.46 244.9,158.36 244.9,157.42 244.39,156.91 244.16,156.91 243.85,156.6 243.85,149.18 243.5,148.84 242.51,148.84 242.11,149.24 242.11,152.92 241.9,153.13 241.64,153.13 241.48,153.29 241.48,154.75 241.67,154.95 241.67,158.19 241.94,158.46 243.31,158.46
GND on BOTTOM (solid shape): 257.74,158.18 258.34,158.18 258.77,157.75 258.77,154.68 258.24,154.14 258.24,151.68 258.08,151.53 258.08,149.11 257.5,148.53 256.94,148.53 256.64,148.84 256.64,153 256.46,153.18 255.9,153.18 255.83,153.25 255.83,153.58 255.98,153.74 256.23,153.74 256.51,154.02 256.51,158.24 256.58,158.31 257.62,158.31
GND on BOTTOM (solid shape): 258.63,125.31 258.63,112.27 257.96,111.6 257.14,111.6 257.13,111.61 256.9,111.61 256.78,111.66 256.66,111.66 256.64,111.66 256.62,111.66 256.56,111.73 256.56,113.02 256,113.58 256,120.92 256.09,121.01 256.09,125.19 256.34,125.44 258.5,125.44
GND on BOTTOM (solid shape): 152.73,131.28 153.51,131.28 153.6,131.37 154.57,131.37 155.04,130.91 155.04,130.54 154.93,130.44 154.69,130.44 154.5,130.63 153.7,130.63 153.5,130.43 152.54,130.43 152.49,130.49 151.59,130.49 151.51,130.57 151.51,131.06 151.05,131.51 151.05,131.79 151.07,131.82 152.19,131.82
GND on BOTTOM (solid shape): 30.32,34.15 30.32,32.45 30.07,32.2 30.07,29.48 30.35,29.2 30.86,29.2 30.98,29.07 30.98,28.67 30.86,28.54 30.25,28.54 29.87,28.16 29.36,28.16 29.23,28.29 29.23,28.92 28.85,29.3 27.71,29.3 27.58,29.43 27.58,33.37 27.83,33.62 29.08,33.62 29.51,34.05 29.51,34.33 29.59,34.41 30.07,34.41
GND on BOTTOM (solid shape): 151.68,108.66 151.78,108.68 152.55,108.68 152.79,108.44 152.79,107.39 152.72,107.32 152.02,107.32 151.68,106.98 151.45,106.98 151.28,107.15 151.28,108.5 151.29,108.54 151.33,108.55 151.4,108.55 151.53,108.68
GND on BOTTOM (solid shape): 254.2,141.8 254.2,138.75 253.31,137.86 252.24,137.86 251.99,138.12 251.99,138.47 251.86,138.6 251.63,138.6 251.58,138.65 251.58,139.49 251.59,139.5 251.59,139.88 251.48,139.99 251.48,140.17 251.5,140.2 251.5,141.57 251.49,141.59 251.48,141.61 251.48,141.7 251.73,141.95 253.71,141.95 253.77,142 253.99,142
GND on BOTTOM (solid shape): 265.73,155.77 265.73,153.86 265.66,153.64 265.73,153.41 265.73,147.13 265.73,147.13 265.73,146.37 265.27,145.91 264.68,145.91 264.28,146.53 264.28,150.28 264.03,150.54 263.7,150.54 263.2,151.04 263.2,155.77 263.48,156.05 265.45,156.05
GND on BOTTOM (solid shape): 131.82,60.11 131.82,59.86 131.73,59.61 131.82,59.35 131.82,56.3 131.72,56.2 130.4,56.2 130.25,56.35 130.25,56.96 130.78,57.5 130.78,59.76 130.14,60.39 128.32,60.39 128.06,60.14 128.06,59.27 127.96,59.17 127.63,59.17 127.48,59.33 127.48,60.7 127.63,60.85 131.08,60.85
GND on BOTTOM (solid shape): 234.57,54.35 234.57,51.79 234.42,51.65 233.48,51.65 233.32,51.81 233.32,52.09 232.98,52.42 232.98,52.78 233.21,53 233.39,53 233.64,53.11 233.75,53.36 233.75,53.64 233.74,53.72 233.71,53.8 233.7,53.81 233.7,53.99 234.11,54.4 234.51,54.4
GND on BOTTOM (solid shape): 110.38,62.5 110.38,61.12 110.37,61.11 110.37,60.79 110.16,60.57 110.14,60.56 110.12,60.56 110.07,60.56 109.86,60.35 109.86,59.47 109.88,59.46 109.88,57.95 109.86,57.94 109.86,57.06 110.24,56.68 110.24,56.3 110.25,56.29 110.25,56.17 110.88,55.54 110.88,55.16 110.76,55.04 108.73,55.04 108.49,55.27 108.49,56.75 108.99,57.24 108.99,60.42 108.49,60.91 108.49,62.41 108.49,62.54 108.71,62.75 110.13,62.75
GND on BOTTOM (solid shape): 352.97,73.82 352.97,69.24 352.61,68.88 348.89,68.88 348.44,69.32 348.28,69.32 348.08,69.52 348.08,70.01 347.87,70.22 347.87,73.29 347.93,73.36 347.95,73.36 348.25,73.5 348.36,73.91 348.44,73.95 348.63,73.95 348.66,73.98 352.81,73.98
GND on BOTTOM (solid shape): 118.71,87.82 118.71,84.57 118.94,84.34 121.23,84.34 121.36,84.47 122.17,84.47 122.27,84.37 122.27,81.75 121.53,81.02 116.94,81.02 115.95,82.01 114.5,82.01 113.13,80.64 111.3,80.64 110.69,80.03 110.69,78.81 110.15,78.27 108.73,78.27 108.43,78.58 108.43,81.25 107.36,82.31 107.36,84.4 108.02,85.06 111.53,85.06 112.29,84.29 113.3,84.29 114.4,85.39 114.4,87.72 115.08,88.41 118.13,88.41
GND on BOTTOM (solid shape): 164.13,75.28 168.02,75.28 168.52,75.78 168.52,76.42 168.63,76.52 172.82,76.52 173.81,75.53 173.81,73.84 173.45,73.49 173.18,73.49 171.86,72.17 171.86,71.73 171.5,71.37 165.73,71.37 165.73,71.34 164.99,70.6 164.18,70.6 163.42,71.37 163.09,71.37 163.04,71.31 157.14,71.31 156.87,71.59 153.97,71.59 153.03,70.65 152.47,70.65 151.35,71.77 151.35,75.4 151.73,75.78 156.59,75.78 157.73,76.93 157.68,76.98 157.68,77.79 157.7,77.79 157.88,77.97 161.44,77.97
GND on BOTTOM (solid shape): 192.02,115.05 193.51,115.05 193.88,114.99 194.09,115.31 194.12,115.38 194.19,115.41 194.46,115.41 194.67,115.19 194.67,114.96 194.84,114.8 194.84,109.06 194.48,108.7 190.7,108.7 190.52,108.88 190.52,109.82 190.14,110.2 189.89,110.2 189.63,110.46 189.63,110.96 189,111.6 189,112.23 188.36,112.87 188.36,114.77 189,115.41 191.66,115.41
GND on BOTTOM (solid shape): 140.58,128.87 140.67,128.83 140.68,128.74 141,128.28 141.33,128.74 141.34,128.83 141.42,128.87 141.75,128.87 141.94,128.69 141.93,128.66 141.94,128.53 142.01,128.41 142.01,127.73 141.12,126.84 137.56,126.84 137.43,126.97 137.43,127.35 138.96,128.87
GND on BOTTOM (solid shape): 71.27,32.1 71.29,32.09 71.31,32.08 71.39,32 71.39,30.62 71.38,30.59 71.34,30.57 71.28,30.57 71.14,30.59 71,30.57 70.99,30.57 70.12,30.57 69.82,30.27 69.82,30.14 69.82,30.13 69.8,29.99 69.82,29.85 69.82,29.79 69.69,29.66 69.27,29.66 68.92,29.78 68.57,29.67 68.56,29.66 68.49,29.66 68.48,29.67 68.31,29.75 68.13,29.78 67.76,29.78 67.74,29.78 67.71,29.81 67.71,30.09 67.3,30.5 67.3,31.92 67.48,32.1
GND on BOTTOM (solid shape): 232.46,125.16 232.46,119.5 232.68,119.27 232.68,115.15 232.56,115.03 232.18,115.03 232.05,115.15 232.05,118.77 232.05,118.77 232.05,119.09 231.92,119.22 231.29,119.22 230.78,119.73 230.78,120.16 230.84,120.25 230.95,120.23 231.6,120.53 230.95,120.83 230.84,120.82 230.78,120.91 230.78,121.76 231.41,122.39 231.41,124.2 231.59,124.37 231.59,125.17 231.72,125.3 232.32,125.3
GND on BOTTOM (solid shape): 269.64,165.95 269.64,165.17 269.63,165.14 269.59,165.12 269.26,165.12 269.21,165.12 269.11,165.11 268.94,165.04 268.87,164.87 268.87,164.73 268.87,163.78 268.87,163.64 268.94,163.47 269.11,163.4 269.26,163.39 269.41,163.4 269.46,163.4 269.5,163.42 269.6,163.41 269.64,163.32 269.64,160.87 269.26,160.49 268.59,160.49 268.57,160.51 268.1,160.51 267.99,160.62 267.99,160.87 267.86,161 263.67,161 263.42,161.26 263.42,166.21 263.55,166.34 269.26,166.34
GND on BOTTOM (solid shape): 361.54,88.23 361.54,83 361.49,82.95 360.41,82.95 360.37,82.96 360.36,83 359.6,83.76 358.84,83 358.83,82.96 358.79,82.95 345.35,82.95 345.17,83.12 344.61,83.12 344.42,83.31 344.42,83.71 344.45,83.89 344.42,84.05 344.42,84.05 344.42,86.01 344.48,86.22 344.42,86.44 344.42,87.98 344.49,88.05 349.26,88.05 349.37,88.04 349.47,88.05 349.92,88.05 350.03,88.04 350.13,88.05 353.64,88.05 353.84,88 354.04,88.05 358.24,88.05 359.23,89.04 360.73,89.04
GND on BOTTOM (solid shape): 54.21,17.61 54.33,17.48 54.48,17.36 54.68,17.17 54.68,17.04 54.66,17.03 54.47,16.32 54.86,15.7 54.86,13.01 51.12,13.01 51.12,15.7 51.49,16.21 51.43,16.84 51.43,16.85 51.43,16.91 51.75,17.23 51.81,17.28 51.87,17.34 52.32,17.34 52.53,16.28 52.14,15.28 52.14,14.02 53.84,14.02 53.84,15.28 53.44,16.44 53.83,17.61
GND on BOTTOM (solid shape): 356.22,57.59 356.22,51.76 355.93,51.4 356,50.94 355.89,50.5 356.12,50.12 356.12,49.66 355.98,49.3 356.1,48.94 356.12,48.92 356.12,48.79 356.1,48.78 355.98,48.47 356.04,48.15 355.21,47.32 351.44,47.32 351.2,47.4 350.96,47.32 350.74,47.32 350.55,47.13 349.03,47.13 348.96,47.06 347.59,47.06 347.34,47.15 347.1,47.06 345.77,47.06 345.6,47.23 345.6,48.01 345.78,48.19 354.26,48.19 354.74,48.68 354.74,49.36 354.73,49.37 354.73,50.76 354.74,50.78 354.74,51.51 354.58,51.68 354.58,56.2 354.89,56.5 354.89,57.1 355.46,57.68 356.14,57.68
GND on BOTTOM (solid shape): outline of 128 points within 154.71,122.01 160.63,123.99
GND on BOTTOM (solid shape): outline of 164 points within 198.44,74.9 206.5,85.44
GND on BOTTOM (solid shape): 22.12,73.98 22.12,69.33 21,68.22 16.12,68.22 12.26,64.35 11.17,64.35 9.04,62.22 9.04,33.11 5.96,30.04 0.93,30.04 0.51,30.47 0.51,36.39 5.3,36.39 6.27,37.14 5.81,38.27 5.81,43.73 6.27,44.86 5.3,45.61 0.51,45.61 0.51,54.39 5.3,54.39 6.27,55.14 5.81,56.27 5.81,61.73 6.27,62.86 5.3,63.61 0.51,63.61 0.51,66.2 0.65,66.55 1,66.69 8.14,66.69 9.21,67.13 9.65,68.2 9.65,70.74 18.59,70.74 19.56,71.49 19.1,72.62 19.1,75.38 20.72,75.38
GND on BOTTOM (solid shape): outline of 239 points within 161.56,121.58 170.47,124.65
GND on BOTTOM (solid shape): outline of 208 points within 161.4,138.81 171.15,141.75
GND on BOTTOM (solid shape): 28.34,17.47 28.45,17.38 28.57,17.31 28.67,17.21 28.67,17.04 28.66,17.02 28.47,16.32 28.86,15.7 28.86,13.01 28.5,13.01 27.43,12.57 26.99,11.5 26.99,5.25 26.56,4.19 25.5,3.76 15.5,3.76 14.43,3.32 13.99,2.25 13.99,0.51 7.01,0.51 7.01,0.56 5,2.52 2.99,0.56 2.99,0.51 1,0.51 0.65,0.65 0.51,1 0.51,4.97 6.98,4.97 10.26,1.7 11.99,1.7 12.03,1.7 13.68,2.78 13.35,4.73 13.31,4.76 13.52,4.97 16.99,4.97 17.75,5.73 17.75,7 18.64,7.89 24.15,7.89 25.98,9.72 25.98,11.5 26.47,12.99 27.74,13.91 27.84,13.94 27.84,15.28 27.44,16.35 27.73,17.47
GND on BOTTOM (solid shape): outline of 227 points within 161.28,124.4 171.75,128.36
GND on BOTTOM (solid shape): outline of 174 points within 199.01,51.38 231.46,54.16
GND on BOTTOM (solid shape): outline of 281 points within 162.29,133.98 171.4,138.95
GND on BOTTOM (solid shape): outline of 362 points within 151.47,127.09 170.89,135.19
GND on BOTTOM (solid shape): outline of 447 points within 150.79,121.68 160.61,128.16
GND on BOTTOM (solid shape): outline of 469 points within 150.92,132.22 160.95,141.57
GND on BOTTOM (solid shape): outline of 238 points within 76.98,0.51 386.49,69.39
GND on BOTTOM (solid shape): outline of 1582 points within 0.51,79.06 386.49,182.49
GND on SGND1 (solid shape): outline of 3778 points within 0.51,0.51 386.49,182.49
GND on IN1 (solid shape): 353.72,65.69 353.72,63.77 353.26,63.31 350.54,63.31 350.29,63.57 350.29,65.9 350.54,66.16 353.25,66.16
GND on IN1 (solid shape): 147.87,108.98 147.87,107.59 148.66,106.8 148.66,104.54 148.53,104.41 145.26,104.41 145.21,104.46 145.21,106.77 145.69,107.26 145.69,108.98 146.12,109.41 147.44,109.41
GND on IN1 (solid shape): 287.52,55.29 287.52,52.85 287.29,52.62 285.17,52.62 285.15,52.64 285.15,53.53 284.64,54.04 284.5,54.04 284.46,54.05 284.45,54.09 284.45,55.31 284.51,55.37 287.44,55.37
GND on IN1 (solid shape): 118.41,84.29 119.58,84.29 120.09,83.79 120.09,81.55 119.78,81.25 117.98,81.25 117.98,81.27 116.99,82.26 114.75,82.26 113.18,80.69 108.96,80.69 107.34,82.31 107.34,84.4 108.07,85.13 110.1,85.13 110.87,84.37 113.51,84.37 114.52,85.39 117.32,85.39
GND on IN1 (solid shape): 52.28,17.42 52.53,16.33 52.14,15.28 52.14,14.02 53.84,14.02 53.84,15.28 53.45,16.25 53.63,17.28 53.74,17.39 54.44,17.39 54.56,17.32 54.7,17.26 54.71,17.26 54.74,17.23 54.74,17.11 54.72,17.09 54.46,16.36 54.86,15.7 54.86,13.01 51.12,13.01 51.12,15.7 51.49,16.21 51.44,16.84 51.42,16.87 51.97,17.42
GND on IN1 (solid shape): 22.02,74.74 22.02,69.69 20.44,68.11 16,68.11 11.98,64.1 10.38,64.1 9.19,62.91 9.19,33.27 8.1,32.18 0.51,32.18 0.51,36.39 5.3,36.39 6.27,37.14 5.81,38.27 5.81,43.73 6.27,44.86 5.3,45.61 0.51,45.61 0.51,54.39 5.3,54.39 6.27,55.14 5.81,56.27 5.81,61.73 6.27,62.86 5.3,63.61 0.51,63.61 0.51,66.2 0.65,66.55 1,66.69 8.14,66.69 9.21,67.13 9.65,68.2 9.65,70.74 18.59,70.74 19.56,71.49 19.1,72.62 19.1,75.78 20.98,75.78
GND on IN1 (solid shape): 28.48,17.36 28.56,17.32 28.66,17.28 28.71,17.23 28.71,17.08 28.69,17.06 28.46,16.34 28.86,15.7 28.86,13.01 28.5,13.01 27.43,12.57 26.99,11.5 26.99,5.25 26.56,4.19 25.5,3.76 15.5,3.76 14.43,3.32 13.99,2.25 13.99,0.51 7.01,0.51 5,2.52 2.99,0.51 1,0.51 0.65,0.65 0.51,1 0.51,5 6.95,5 10.25,1.7 10.97,1.7 11.01,1.7 12.03,1.7 13.68,2.78 13.34,4.73 13.32,4.76 13.56,5 15.39,5 15.61,4.77 25.5,4.77 25.84,4.91 25.98,5.25 25.98,11.5 26.47,12.99 27.74,13.91 27.84,13.94 27.84,15.28 27.45,16.26 27.64,17.3 27.71,17.36
GND on IN1 (solid shape): outline of 893 points within 353.96,40.29 382.01,52.76
GND on IN1 (solid shape): outline of 1195 points within 76.98,0.51 386.49,69.39
GND on IN1 (solid shape): outline of 1575 points within 0.51,77.49 386.49,182.49
GND on SGND2 (solid shape): outline of 3609 points within 0.51,0.51 386.49,182.49
GND on IN2 (solid shape): 147.87,108.98 147.87,107.59 148.66,106.8 148.66,104.54 148.53,104.41 145.26,104.41 145.21,104.46 145.21,106.77 145.69,107.26 145.69,108.98 146.12,109.41 147.44,109.41
GND on IN2 (solid shape): 356.23,44.39 356.23,41.57 355.62,40.96 354.1,40.96 353.21,41.85 353.21,43.07 352.85,43.43 352.83,43.47 352.85,43.5 352.9,43.55 352.9,44.41 353.13,44.64 355.98,44.64
GND on IN2 (solid shape): 353.66,65.78 353.66,64.47 353.52,64.33 353.52,63.68 353.13,63.29 352.54,63.29 352.45,63.3 352.35,63.29 350.84,63.29 350.64,63.49 350.64,65.88 350.95,66.18 353.26,66.18
GND on IN2 (solid shape): 287.45,55.47 287.45,52.77 287.29,52.62 284.93,52.62 284.58,52.97 284.57,52.99 284.57,53.02 284.59,53.15 284.56,53.28 284.55,53.29 284.55,55.19 284.98,55.62 287.3,55.62
GND on IN2 (solid shape): 54.05,17.8 54.13,17.74 54.36,17.45 54.69,17.27 54.76,17.19 54.73,17.1 54.46,16.37 54.86,15.7 54.86,13.01 51.12,13.01 51.12,15.7 51.49,16.19 51.45,16.8 51.45,16.81 51.45,17.01 51.52,17.09 51.62,17.14 51.71,17.19 51.88,17.35 52.03,17.54 52.04,17.56 52.19,17.56 52.54,16.41 52.14,15.28 52.14,14.02 53.84,14.02 53.84,15.28 53.44,16.54 53.96,17.77
GND on IN2 (solid shape): 22.12,73.96 22.12,69.33 21.1,68.32 12.09,68.32 8.12,64.35 8.12,33.39 6.88,32.15 0.51,32.15 0.51,36.39 5.3,36.39 6.27,37.14 5.81,38.27 5.81,43.73 6.27,44.86 5.3,45.61 0.51,45.61 0.51,54.39 5.3,54.39 6.27,55.14 5.81,56.27 5.81,61.73 6.27,62.86 5.3,63.61 0.51,63.61 0.51,66.2 0.65,66.55 1,66.69 8.14,66.69 9.21,67.13 9.65,68.2 9.65,70.74 18.59,70.74 19.56,71.49 19.1,72.62 19.1,75.23 20.85,75.23
GND on IN2 (solid shape): outline of 215 points within 141.44,98.2 146.73,100.98
GND on IN2 (solid shape): 28.4,17.42 28.46,17.38 28.52,17.34 28.63,17.23 28.63,16.98 28.62,16.97 28.47,16.28 28.86,15.7 28.86,13.01 28.5,13.01 27.43,12.57 26.99,11.5 26.99,5.25 26.56,4.19 25.5,3.76 15.5,3.76 14.43,3.32 13.99,2.25 13.99,0.51 7.01,0.51 7.01,0.56 5,2.52 2.99,0.56 2.99,0.51 1,0.51 0.65,0.65 0.51,1 0.51,5 6.65,5 6.65,4.99 6.96,4.99 10.26,1.69 11.46,1.69 11.46,1.7 12.03,1.7 13.68,2.78 13.34,4.73 13.31,4.77 13.54,5 15.41,5 15.63,4.77 25.5,4.77 25.84,4.91 25.98,5.25 25.98,11.5 26.47,12.99 27.74,13.91 27.84,13.94 27.84,15.28 27.45,16.32 27.7,17.42
GND on IN2 (solid shape): outline of 210 points within 76.98,0.51 386.49,69.39
GND on IN2 (solid shape): outline of 1606 points within 0.51,78.68 386.49,182.49
GND on SGND3 (solid shape): outline of 3563 points within 0.51,0.51 386.49,182.49
GND on SVCC (solid shape): 119.4,79.64 119.44,79.36 119.65,79.17 119.65,73.58 118.68,72.61 111.48,72.61 109.88,74.22 109.88,78.88 111.23,80.23 118.81,80.23
GND on SVCC (solid shape): 143.94,99.53 146.5,99.53 146.63,99.4 146.63,98.32 146.52,98.21 141.5,98.21 141.4,98.32 141.4,100.48 141.64,100.67 141.64,100.97 141.73,101.06 142.41,101.06
GND on SVCC (solid shape): 148.99,74.3 148.99,68.5 146.49,66.01 142.16,66.01 141.85,66.21 141.53,66.01 133.96,66.01 132.99,66.98 132.99,71.38 137.39,75.78 147.51,75.78
GND on SVCC (solid shape): 375.28,95.95 375.7,94.92 376.73,94.48 386.07,94.48 386.48,94.08 386.48,93.62 386.49,93.56 386.49,93.5 386.49,87.01 375.71,87.01 374.75,87.32 374.16,86.5 374.16,83.87 373.82,83.53 368.2,83.53 368,83.49 367.83,83.38 365.42,80.97 365.31,80.8 365.27,80.61 365.27,80.34 365.04,80.1 364.85,80.1 359.15,85.8 358.99,85.91 358.79,85.95 341.08,85.95 340.76,86.16 340.44,85.95 339.56,85.95 339.24,86.16 338.92,85.95 337.8,85.95 337.46,86.2 337.12,85.95 333.71,85.95 333.4,86.16 333.08,85.95 332.13,85.95 332.13,87.21 332.12,87.26 333.29,87.79 334.44,88.36 339.58,91.57 344.14,95.57 344.61,95.88 345.16,95.99 361.42,95.99 375.28,95.99
GND on SVCC (solid shape): 15.89,5.58 15.91,5.2 15.97,5.12 16.15,4.94 16.15,4.01 15.9,3.76 15.5,3.76 14.43,3.32 13.99,2.25 13.99,0.51 7.01,0.51 7.01,0.56 5,2.51 2.99,0.56 2.99,0.51 1,0.51 0.65,0.65 0.51,1 0.51,4.79 0.76,5.05 9.77,5.05 9.86,4.98 9.32,2.87 11.01,1.7 12.03,1.7 13.72,2.87 13.2,4.87 13.18,4.88 13.18,5.05 13.35,5.05 13.45,5.06 13.53,5.12 14.22,5.81 15.66,5.81
GND on SVCC (solid shape): outline of 376 points within 29.23,55.59 77.74,95.99
GND on SVCC (solid shape): outline of 125 points within 193.31,88.74 286.66,182.49
GND on SVCC (solid shape): outline of 759 points within 195.47,60.29 314.09,80.61
GND on IN3 (solid shape): 355.95,44.16 355.95,41.44 355.57,41.06 353.82,41.06 353.03,41.85 353.03,43.12 352.55,43.6 352.55,44.19 352.95,44.59 355.51,44.59
GND on IN3 (solid shape): 287.45,55.49 287.45,52.77 287.29,52.62 284.93,52.62 284.55,53 284.58,53.13 284.55,53.26 284.55,55.19 284.98,55.62 287.32,55.62
GND on IN3 (solid shape): 147.87,108.98 147.87,107.59 148.66,106.8 148.66,104.54 148.53,104.41 145.26,104.41 145.21,104.46 145.21,106.77 145.69,107.26 145.69,108.98 146.12,109.41 147.44,109.41
GND on IN3 (solid shape): 353.64,65.78 353.64,63.75 353.03,63.14 352.75,63.14 352.73,63.14 352.71,63.16 352.45,63.29 352.18,63.16 352.16,63.14 352.14,63.14 350.54,63.14 350.11,63.57 350.11,65.85 350.57,66.31 353.11,66.31
GND on IN3 (solid shape): 54.2,17.62 54.33,17.48 54.48,17.36 54.62,17.22 54.62,16.97 54.47,16.29 54.86,15.7 54.86,13.01 51.12,13.01 51.12,15.7 51.49,16.21 51.43,16.84 51.43,16.85 51.43,16.93 51.66,17.16 51.81,17.28 51.94,17.42 52.26,17.42 52.3,17.37 52.53,16.3 52.14,15.28 52.14,14.02 53.84,14.02 53.84,15.28 53.44,16.45 53.84,17.62
GND on IN3 (solid shape): 21.91,74.36 21.91,69.49 21.03,68.6 15.34,68.6 13.13,66.39 13.13,64.84 12.47,64.18 10.13,64.18 8.78,62.83 8.78,32.96 8.05,32.22 0.51,32.22 0.51,36.39 5.3,36.39 6.27,37.14 5.81,38.27 5.81,43.73 6.27,44.86 5.3,45.61 0.51,45.61 0.51,54.39 5.3,54.39 6.27,55.14 5.81,56.27 5.81,61.73 6.27,62.86 5.3,63.61 0.51,63.61 0.51,66.2 0.65,66.55 1,66.69 8.14,66.69 9.21,67.13 9.65,68.2 9.65,70.74 18.59,70.74 19.56,71.49 19.1,72.62 19.1,75.3 20.98,75.3
GND on IN3 (solid shape): 28.48,17.36 28.56,17.32 28.66,17.28 28.66,17.27 28.66,17.02 28.65,17.01 28.47,16.31 28.86,15.7 28.86,13.01 28.5,13.01 27.43,12.57 26.99,11.5 26.99,5.25 26.56,4.19 25.5,3.76 15.5,3.76 14.43,3.32 13.99,2.25 13.99,0.51 7.01,0.51 7.01,0.56 5,2.51 2.99,0.56 2.99,0.51 1,0.51 0.65,0.65 0.51,1 0.51,5.02 6.93,5.02 10.26,1.7 10.98,1.7 11.01,1.7 12.03,1.7 13.68,2.78 13.34,4.73 13.31,4.77 13.57,5.02 15.36,5.02 15.61,4.77 25.5,4.77 25.84,4.91 25.98,5.25 25.98,11.5 26.47,12.99 27.74,13.91 27.84,13.94 27.84,15.28 27.45,16.3 27.67,17.36
GND on IN3 (solid shape): outline of 189 points within 76.98,0.51 386.49,69.39
GND on IN3 (solid shape): outline of 1599 points within 0.51,79.09 386.49,182.49
GND on SGND4 (solid shape): outline of 3585 points within 0.51,0.51 386.49,182.49
GND on IN4 (solid shape): 274.44,122.9 274.44,115.08 274.06,114.7 270.76,114.7 267.96,117.49 267.96,121.25 269.95,123.23 274.11,123.23
GND on IN4 (solid shape): 356.31,44.39 356.31,41.6 355.82,41.11 353.99,41.11 352.98,42.13 352.98,43.27 352.67,43.58 352.67,44.21 353.08,44.62 356.08,44.62
GND on IN4 (solid shape): 148.33,108.88 148.33,107.19 148.63,106.89 148.63,104.54 148.5,104.41 145.4,104.41 145.16,104.65 145.16,106.84 145.63,107.31 145.64,107.31 145.74,107.41 145.74,109.01 146.17,109.44 147.77,109.44
GND on IN4 (solid shape): 353.5,65.87 353.5,65.54 353.52,65.51 353.53,65.5 353.54,65.48 353.54,65.24 353.65,65.13 353.65,63.84 353.12,63.3 352.48,63.3 352.46,63.3 352.37,63.29 352.3,63.27 352.29,63.26 350.51,63.26 350.26,63.52 350.26,65.78 350.59,66.11 353.26,66.11
