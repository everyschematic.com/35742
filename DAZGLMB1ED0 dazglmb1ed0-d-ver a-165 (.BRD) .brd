# Allegro board DAZGLMB1ED0 dazglmb1ed0-d-ver a-165 (.BRD) .brd (continued)
## Nets (continued)
VMA_DQ59: U13114.AN46(FBA_D59) U13136.U3(DQ27)
VMA_DQ60: U13114.AR48(FBA_D60) U13136.P4(DQ28)
VMA_DQ61: U13114.AN47(FBA_D61) U13136.P3(DQ29)
VMA_DQ62: U13114.AR47(FBA_D62) U13136.N4(DQ30)
VMA_DQ63: U13114.AR46(FBA_D63) U13136.N3(DQ31)
VMA_WCK01: U13114.U45(FBA_WCK01) U13135.T4(WCK01_T)
VMA_WCK01#: U13114.U44(FBA_WCK01_N) U13135.T5(WCK01_C)
VMA_WCK23: U13114.AC45(FBA_WCK23) U13135.D4(WCK23_T)
VMA_WCK23#: U13114.AC44(FBA_WCK23_N) U13135.D5(WCK23_C)
VMA_WCK45: U13114.AV47(FBA_WCK45) U13136.D4(WCK01_T)
VMA_WCK45#: U13114.AV46(FBA_WCK45_N) U13136.D5(WCK01_C)
VMA_WCK67: U13114.AR45(FBA_WCK67) U13136.T4(WCK23_T)
VMA_WCK67#: U13114.AR44(FBA_WCK67_N) U13136.T5(WCK23_C)
VMB_CLK0: U13114.H42(FBB_CLK0) U13137.K11(CLK_T)
VMB_CLK0#: U13114.G42(FBB_CLK0_N) U13137.K10(CLK_C)
VMB_CLK1: U13114.F47(FBB_CLK1) U13138.K11(CLK_T)
VMB_CLK1#: U13114.E47(FBB_CLK1_N) U13138.K10(CLK_C)
VMB_DQ0: U13114.H32(FBB_D0) U13137.V4(DQ0)
VMB_DQ1: U13114.D32(FBB_D1) U13137.V3(DQ1)
VMB_DQ2: U13114.A33(FBB_D2) U13137.U4(DQ2)
VMB_DQ3: U13114.B32(FBB_D3) U13137.U3(DQ3)
VMB_DQ4: U13114.E32(FBB_D4) U13137.P4(DQ4)
VMB_DQ5: U13114.G32(FBB_D5) U13137.P3(DQ5)
VMB_DQ6: U13114.J30(FBB_D6) U13137.N4(DQ6)
VMB_DQ7: U13114.F32(FBB_D7) U13137.N3(DQ7)
VMB_DQ8: U13114.H36(FBB_D8) U13137.V11(DQ8)
VMB_DQ9: U13114.G36(FBB_D9) U13137.V12(DQ9)
VMB_DQ10: U13114.J36(FBB_D10) U13137.U11(DQ10)
VMB_DQ11: U13114.F36(FBB_D11) U13137.U12(DQ11)
VMB_DQ12: U13114.F33(FBB_D12) U13137.P11(DQ12)
VMB_DQ13: U13114.D33(FBB_D13) U13137.P12(DQ13)
VMB_DQ14: U13114.J32(FBB_D14) U13137.N11(DQ14)
VMB_DQ15: U13114.G33(FBB_D15) U13137.N12(DQ15)
VMB_DQ16: U13114.E45(FBB_D16) U13137.B11(DQ16)
VMB_DQ17: U13114.D45(FBB_D17) U13137.B12(DQ17)
VMB_DQ18: U13114.F45(FBB_D18) U13137.C11(DQ18)
VMB_DQ19: U13114.G45(FBB_D19) U13137.C12(DQ19)
VMB_DQ20: U13114.D42(FBB_D20) U13137.F11(DQ20)
VMB_DQ21: U13114.E42(FBB_D21) U13137.F12(DQ21)
VMB_DQ22: U13114.F42(FBB_D22) U13137.G11(DQ22)
VMB_DQ23: U13114.H41(FBB_D23) U13137.G12(DQ23)
VMB_DQ24: U13114.E41(FBB_D24) U13137.B4(DQ24)
VMB_DQ25: U13114.F39(FBB_D25) U13137.B3(DQ25)
VMB_DQ26: U13114.E39(FBB_D26) U13137.C4(DQ26)
VMB_DQ27: U13114.D39(FBB_D27) U13137.C3(DQ27)
VMB_DQ28: U13114.F38(FBB_D28) U13137.F4(DQ28)
VMB_DQ29: U13114.E38(FBB_D29) U13137.F3(DQ29)
VMB_DQ30: U13114.D36(FBB_D30) U13137.G4(DQ30)
VMB_DQ31: U13114.E36(FBB_D31) U13137.G3(DQ31)
VMB_DQ32: U13114.M50(FBB_D32) U13138.B4(DQ0)
VMB_DQ33: U13114.P48(FBB_D33) U13138.B3(DQ1)
VMB_DQ34: U13114.M51(FBB_D34) U13138.C4(DQ2)
VMB_DQ35: U13114.M49(FBB_D35) U13138.C3(DQ3)
VMB_DQ36: U13114.P47(FBB_D36) U13138.F4(DQ4)
VMB_DQ37: U13114.P52(FBB_D37) U13138.F3(DQ5)
VMB_DQ38: U13114.R46(FBB_D38) U13138.G4(DQ6)
VMB_DQ39: U13114.P46(FBB_D39) U13138.G3(DQ7)
VMB_DQ40: U13114.L50(FBB_D40) U13138.B11(DQ8)
VMB_DQ41: U13114.L51(FBB_D41) U13138.B12(DQ9)
VMB_DQ42: U13114.L52(FBB_D42) U13138.C11(DQ10)
VMB_DQ43: U13114.L49(FBB_D43) U13138.C12(DQ11)
VMB_DQ44: U13114.M46(FBB_D44) U13138.F11(DQ12)
VMB_DQ45: U13114.L47(FBB_D45) U13138.F12(DQ13)
VMB_DQ46: U13114.M48(FBB_D46) U13138.G11(DQ14)
VMB_DQ47: U13114.M47(FBB_D47) U13138.G12(DQ15)
VMB_DQ48: U13114.D48(FBB_D48) U13138.V11(DQ16)
VMB_DQ49: U13114.C50(FBB_D49) U13138.V12(DQ17)
VMB_DQ50: U13114.C48(FBB_D50) U13138.U11(DQ18)
VMB_DQ51: U13114.C49(FBB_D51) U13138.U12(DQ19)
VMB_DQ52: U13114.E49(FBB_D52) U13138.P11(DQ20)
VMB_DQ53: U13114.E50(FBB_D53) U13138.P12(DQ21)
VMB_DQ54: U13114.F49(FBB_D54) U13138.N11(DQ22)
VMB_DQ55: U13114.F48(FBB_D55) U13138.N12(DQ23)
VMB_DQ56: U13114.F50(FBB_D56) U13138.V4(DQ24)
VMB_DQ57: U13114.D52(FBB_D57) U13138.V3(DQ25)
VMB_DQ58: U13114.J50(FBB_D58) U13138.U4(DQ26)
VMB_DQ59: U13114.H48(FBB_D59) U13138.U3(DQ27)
VMB_DQ60: U13114.H51(FBB_D60) U13138.P4(DQ28)
VMB_DQ61: U13114.J51(FBB_D61) U13138.P3(DQ29)
VMB_DQ62: U13114.H49(FBB_D62) U13138.N4(DQ30)
VMB_DQ63: U13114.H52(FBB_D63) U13138.N3(DQ31)
VMB_WCK01: U13114.J33(FBB_WCK01) U13137.T4(WCK01_T)
VMB_WCK01#: U13114.H33(FBB_WCK01_N) U13137.T5(WCK01_C)
VMB_WCK23: U13114.J39(FBB_WCK23) U13137.D4(WCK23_T)
VMB_WCK23#: U13114.H39(FBB_WCK23_N) U13137.D5(WCK23_C)
VMB_WCK45: U13114.L46(FBB_WCK45) U13138.D4(WCK01_T)
VMB_WCK45#: U13114.L45(FBB_WCK45_N) U13138.D5(WCK01_C)
VMB_WCK67: U13114.H47(FBB_WCK67) U13138.T4(WCK23_T)
VMB_WCK67#: U13114.H46(FBB_WCK67_N) U13138.T5(WCK23_C)
VMC_CLK0: U13114.G15(FBC_CLK0) U13139.K11(CLK_T)
VMC_CLK0#: U13114.F15(FBC_CLK0_N) U13139.K10(CLK_C)
VMC_CLK1: U13114.H21(FBC_CLK1) U13140.K11(CLK_T)
VMC_CLK1#: U13114.J21(FBC_CLK1_N) U13140.K10(CLK_C)
VMC_DQ0: U13114.C6(FBC_D0) U13139.V4(DQ0)
VMC_DQ1: U13114.D6(FBC_D1) U13139.V3(DQ1)
VMC_DQ2: U13114.A6(FBC_D2) U13139.U4(DQ2)
VMC_DQ3: U13114.B6(FBC_D3) U13139.U3(DQ3)
VMC_DQ4: U13114.B4(FBC_D4) U13139.P4(DQ4)
VMC_DQ5: U13114.A4(FBC_D5) U13139.P3(DQ5)
VMC_DQ6: U13114.B3(FBC_D6) U13139.N4(DQ6)
VMC_DQ7: U13114.C4(FBC_D7) U13139.N3(DQ7)
VMC_DQ8: U13114.D9(FBC_D8) U13139.V11(DQ8)
VMC_DQ9: U13114.C9(FBC_D9) U13139.V12(DQ9)
VMC_DQ10: U13114.E9(FBC_D10) U13139.U11(DQ10)
VMC_DQ11: U13114.B9(FBC_D11) U13139.U12(DQ11)
VMC_DQ12: U13114.B8(FBC_D12) U13139.P11(DQ12)
VMC_DQ13: U13114.A8(FBC_D13) U13139.P12(DQ13)
VMC_DQ14: U13114.F6(FBC_D14) U13139.N11(DQ14)
VMC_DQ15: U13114.E6(FBC_D15) U13139.N12(DQ15)
VMC_DQ16: U13114.F18(FBC_D16) U13139.B11(DQ16)
VMC_DQ17: U13114.G18(FBC_D17) U13139.B12(DQ17)
VMC_DQ18: U13114.E18(FBC_D18) U13139.C11(DQ18)
VMC_DQ19: U13114.H18(FBC_D19) U13139.C12(DQ19)
VMC_DQ20: U13114.D15(FBC_D20) U13139.F11(DQ20)
VMC_DQ21: U13114.E15(FBC_D21) U13139.F12(DQ21)
VMC_DQ22: U13114.G17(FBC_D22) U13139.G11(DQ22)
VMC_DQ23: U13114.H17(FBC_D23) U13139.G12(DQ23)
VMC_DQ24: U13114.J15(FBC_D24) U13139.B4(DQ24)
VMC_DQ25: U13114.H15(FBC_D25) U13139.B3(DQ25)
VMC_DQ26: U13114.E14(FBC_D26) U13139.C4(DQ26)
VMC_DQ27: U13114.F14(FBC_D27) U13139.C3(DQ27)
VMC_DQ28: U13114.H11(FBC_D28) U13139.F4(DQ28)
VMC_DQ29: U13114.G11(FBC_D29) U13139.F3(DQ29)
VMC_DQ30: U13114.F11(FBC_D30) U13139.G4(DQ30)
VMC_DQ31: U13114.E11(FBC_D31) U13139.G3(DQ31)
VMC_DQ32: U13114.J29(FBC_D32) U13140.B4(DQ0)
VMC_DQ33: U13114.F30(FBC_D33) U13140.B3(DQ1)
VMC_DQ34: U13114.H29(FBC_D34) U13140.C4(DQ2)
VMC_DQ35: U13114.G30(FBC_D35) U13140.C3(DQ3)
VMC_DQ36: U13114.B30(FBC_D36) U13140.F4(DQ4)
VMC_DQ37: U13114.A30(FBC_D37) U13140.F3(DQ5)
VMC_DQ38: U13114.H30(FBC_D38) U13140.G4(DQ6)
VMC_DQ39: U13114.C30(FBC_D39) U13140.G3(DQ7)
VMC_DQ40: U13114.D27(FBC_D40) U13140.B11(DQ8)
VMC_DQ41: U13114.J26(FBC_D41) U13140.B12(DQ9)
VMC_DQ42: U13114.F27(FBC_D42) U13140.C11(DQ10)
VMC_DQ43: U13114.G27(FBC_D43) U13140.C12(DQ11)
VMC_DQ44: U13114.C27(FBC_D44) U13140.F11(DQ12)
VMC_DQ45: U13114.B27(FBC_D45) U13140.F12(DQ13)
VMC_DQ46: U13114.A27(FBC_D46) U13140.G11(DQ14)
VMC_DQ47: U13114.G29(FBC_D47) U13140.G12(DQ15)
VMC_DQ48: U13114.H20(FBC_D48) U13140.V11(DQ16)
VMC_DQ49: U13114.D18(FBC_D49) U13140.V12(DQ17)
VMC_DQ50: U13114.G20(FBC_D50) U13140.U11(DQ18)
VMC_DQ51: U13114.E20(FBC_D51) U13140.U12(DQ19)
VMC_DQ52: U13114.F23(FBC_D52) U13140.P11(DQ20)
VMC_DQ53: U13114.E21(FBC_D53) U13140.P12(DQ21)
VMC_DQ54: U13114.D21(FBC_D54) U13140.N11(DQ22)
VMC_DQ55: U13114.E23(FBC_D55) U13140.N12(DQ23)
VMC_DQ56: U13114.G24(FBC_D56) U13140.V4(DQ24)
VMC_DQ57: U13114.H26(FBC_D57) U13140.V3(DQ25)
VMC_DQ58: U13114.F24(FBC_D58) U13140.U4(DQ26)
VMC_DQ59: U13114.G26(FBC_D59) U13140.U3(DQ27)
VMC_DQ60: U13114.F26(FBC_D60) U13140.P4(DQ28)
VMC_DQ61: U13114.D26(FBC_D61) U13140.P3(DQ29)
VMC_DQ62: U13114.B26(FBC_D62) U13140.N4(DQ30)
VMC_DQ63: U13114.C26(FBC_D63) U13140.N3(DQ31)
VMC_WCK01: U13114.F8(FBC_WCK01) U13139.T4(WCK01_T)
VMC_WCK01#: U13114.G8(FBC_WCK01_N) U13139.T5(WCK01_C)
VMC_WCK23: U13114.H12(FBC_WCK23) U13139.D4(WCK23_T)
VMC_WCK23#: U13114.G12(FBC_WCK23_N) U13139.D5(WCK23_C)
VMC_WCK45: U13114.J27(FBC_WCK45) U13140.D4(WCK01_T)
VMC_WCK45#: U13114.H27(FBC_WCK45_N) U13140.D5(WCK01_C)
VMC_WCK67: U13114.G23(FBC_WCK67) U13140.T4(WCK23_T)
VMC_WCK67#: U13114.H23(FBC_WCK67_N) U13140.T5(WCK23_C)
VMD_CLK0: U13114.Y8(FBD_CLK0) U13141.K11(CLK_T)
VMD_CLK0#: U13114.Y7(FBD_CLK0_N) U13141.K10(CLK_C)
VMD_CLK1: U13114.R8(FBD_CLK1) U13142.K11(CLK_T)
VMD_CLK1#: U13114.R7(FBD_CLK1_N) U13142.K10(CLK_C)
VMD_DQ0: U13114.AK8(FBD_D0) U13141.V4(DQ0)
VMD_DQ1: U13114.AK4(FBD_D1) U13141.V3(DQ1)
VMD_DQ2: U13114.AK2(FBD_D2) U13141.U4(DQ2)
VMD_DQ3: U13114.AK3(FBD_D3) U13141.U3(DQ3)
VMD_DQ4: U13114.AK5(FBD_D4) U13141.P4(DQ4)
VMD_DQ5: U13114.AK6(FBD_D5) U13141.P3(DQ5)
VMD_DQ6: U13114.AK9(FBD_D6) U13141.N4(DQ6)
VMD_DQ7: U13114.AK7(FBD_D7) U13141.N3(DQ7)
VMD_DQ8: U13114.AG4(FBD_D8) U13141.V11(DQ8)
VMD_DQ9: U13114.AF9(FBD_D9) U13141.V12(DQ9)
VMD_DQ10: U13114.AG6(FBD_D10) U13141.U11(DQ10)
VMD_DQ11: U13114.AG7(FBD_D11) U13141.U12(DQ11)
VMD_DQ12: U13114.AJ4(FBD_D12) U13141.P11(DQ12)
VMD_DQ13: U13114.AJ5(FBD_D13) U13141.P12(DQ13)
VMD_DQ14: U13114.AJ6(FBD_D14) U13141.N11(DQ14)
VMD_DQ15: U13114.AG5(FBD_D15) U13141.N12(DQ15)
VMD_DQ16: U13114.Y6(FBD_D16) U13141.B11(DQ16)
VMD_DQ17: U13114.Y5(FBD_D17) U13141.B12(DQ17)
VMD_DQ18: U13114.V5(FBD_D18) U13141.C11(DQ18)
VMD_DQ19: U13114.Y4(FBD_D19) U13141.C12(DQ19)
VMD_DQ20: U13114.AA6(FBD_D20) U13141.F11(DQ20)
VMD_DQ21: U13114.AA5(FBD_D21) U13141.F12(DQ21)
VMD_DQ22: U13114.AC5(FBD_D22) U13141.G11(DQ22)
VMD_DQ23: U13114.AC4(FBD_D23) U13141.G12(DQ23)
VMD_DQ24: U13114.AD7(FBD_D24) U13141.B4(DQ24)
VMD_DQ25: U13114.AC6(FBD_D25) U13141.B3(DQ25)
VMD_DQ26: U13114.AF6(FBD_D26) U13141.C4(DQ26)
VMD_DQ27: U13114.AD6(FBD_D27) U13141.C3(DQ27)
VMD_DQ28: U13114.AF7(FBD_D28) U13141.F4(DQ28)
VMD_DQ29: U13114.AF8(FBD_D29) U13141.F3(DQ29)
VMD_DQ30: U13114.AF2(FBD_D30) U13141.G4(DQ30)
VMD_DQ31: U13114.AF3(FBD_D31) U13141.G3(DQ31)
VMD_DQ32: U13114.F4(FBD_D32) U13142.B4(DQ0)
VMD_DQ33: U13114.E1(FBD_D33) U13142.B3(DQ1)
VMD_DQ34: U13114.F3(FBD_D34) U13142.C4(DQ2)
VMD_DQ35: U13114.F5(FBD_D35) U13142.C3(DQ3)
VMD_DQ36: U13114.D2(FBD_D36) U13142.F4(DQ4)
VMD_DQ37: U13114.D1(FBD_D37) U13142.F3(DQ5)
VMD_DQ38: U13114.C3(FBD_D38) U13142.G4(DQ6)
VMD_DQ39: U13114.C2(FBD_D39) U13142.G3(DQ7)
VMD_DQ40: U13114.J5(FBD_D40) U13142.B11(DQ8)
VMD_DQ41: U13114.J4(FBD_D41) U13142.B12(DQ9)
VMD_DQ42: U13114.L8(FBD_D42) U13142.C11(DQ10)
VMD_DQ43: U13114.J2(FBD_D43) U13142.C12(DQ11)
VMD_DQ44: U13114.F1(FBD_D44) U13142.F11(DQ12)
VMD_DQ45: U13114.F2(FBD_D45) U13142.F12(DQ13)
VMD_DQ46: U13114.H4(FBD_D46) U13142.G11(DQ14)
VMD_DQ47: U13114.H5(FBD_D47) U13142.G12(DQ15)
VMD_DQ48: U13114.V7(FBD_D48) U13142.V11(DQ16)
VMD_DQ49: U13114.V8(FBD_D49) U13142.V12(DQ17)
VMD_DQ50: U13114.V6(FBD_D50) U13142.U11(DQ18)
VMD_DQ51: U13114.V9(FBD_D51) U13142.U12(DQ19)
VMD_DQ52: U13114.U4(FBD_D52) U13142.P11(DQ20)
VMD_DQ53: U13114.R5(FBD_D53) U13142.P12(DQ21)
VMD_DQ54: U13114.R6(FBD_D54) U13142.N11(DQ22)
VMD_DQ55: U13114.U8(FBD_D55) U13142.N12(DQ23)
VMD_DQ56: U13114.P6(FBD_D56) U13142.V4(DQ24)
VMD_DQ57: U13114.R9(FBD_D57) U13142.V3(DQ25)
VMD_DQ58: U13114.P4(FBD_D58) U13142.U4(DQ26)
VMD_DQ59: U13114.P5(FBD_D59) U13142.U3(DQ27)
VMD_DQ60: U13114.L7(FBD_D60) U13142.P4(DQ28)
VMD_DQ61: U13114.L6(FBD_D61) U13142.P3(DQ29)
VMD_DQ62: U13114.L4(FBD_D62) U13142.N4(DQ30)
VMD_DQ63: U13114.L5(FBD_D63) U13142.N3(DQ31)
VMD_WCK01: U13114.AJ8(FBD_WCK01) U13141.T4(WCK01_T)
VMD_WCK01#: U13114.AJ7(FBD_WCK01_N) U13141.T5(WCK01_C)
VMD_WCK23: U13114.AD8(FBD_WCK23) U13141.D4(WCK23_T)
VMD_WCK23#: U13114.AD9(FBD_WCK23_N) U13141.D5(WCK23_C)
VMD_WCK45: U13114.J6(FBD_WCK45) U13142.D4(WCK01_T)
VMD_WCK45#: U13114.J7(FBD_WCK45_N) U13142.D5(WCK01_C)
VMD_WCK67: U13114.P8(FBD_WCK67) U13142.T4(WCK23_T)
VMD_WCK67#: U13114.P7(FBD_WCK67_N) U13142.T5(WCK23_C)
VR_SVID_ALERT#: PR43.2 PR66861.1 R538.2 R545.2
VR_SVID_CLK: PR44.2 PR66865.1 R539.2 R540.2
VR_SVID_CLK_R: R540.1 U41.BH32(VIDSCK)
VR_SVID_DATA: PR41.2 PR66863.1 R543.2
VR_SYNC: PR66854.2 PR66940.1 PR66943.1 PR66947.1 PR66950.1 PR66953.1 PR66956.1
VREF_CA_DIMM0: C94863.2 C94866.1 CN2063.164(VREFCA) R21405.1 R21406.2 R21407.1 R21408.2
VREF_CA_DIMM1: C94906.2 C94908.1 CN2062.164(VREFCA) R21432.1 R21433.2 R21434.1 R21435.2
VRON: PR66848.1 R20893.1 U49.69(ADC3/GPI3(3))
VSTBY_FSPI: R22145.2 R22146.2 U49.106(VSTBY_FSPI)
WIGIG_DP_AUXN: C95888.2 CN2068.20(DP_AUXN) R22001.1
WIGIG_DP_AUXP: C95889.2 CN2068.22(DP_AUXP) R22002.1
WIGIG_DP_HPD: CN2068.31(DP_HPD) R22000.1
WIGIG_DP_ML0N: C95880.2 CN2068.32(DP_ML0N)
WIGIG_DP_ML0P: C95881.2 CN2068.34(DP_ML0P)
WIGIG_DP_ML1N: C95882.2 CN2068.26(DP_ML1N)
WIGIG_DP_ML1P: C95883.2 CN2068.28(DP_ML1P)
WIGIG_DP_ML2N: C95884.2 CN2068.25(DP_ML2N)
WIGIG_DP_ML2P: C95908.2 CN2068.27(DP_ML2P)
WIGIG_DP_ML3N: C95886.2 CN2068.19(DP_ML3N)
WIGIG_DP_ML3P: C95887.2 CN2068.21(DP_ML3P)
WIGIG_LED: CN2068.6(WIGIG/WI-FI LED) TP13125.1
WIGIG_MLDIR: CN2068.17(MLDIR SENSE (I)) R22097.1
WIGIG_PCIE_RXN1: CN2068.67(PERN1) R21999.1
WIGIG_PCIE_RXP1: CN2068.65(PERP1) R21998.1
WIGIG_PCIE_TXN1: C95897.1 U13113.B19(PCIE2_TXN/USB3_8_TXN)
WIGIG_PCIE_TXP1: C95898.1 U13113.C19(PCIE2_TXP/USB3_8_TXP)
WLAN_CLKREQ#: CN2068.53(CLKREQ#) Q7888.1(S) R21709.1
WLAN_RST#: CN2068.52(PERST0#) R21713.1
WLAN_WAKE_R#: CN2068.55(PEWAKE0#) Q7889.1(S) R21710.1
WP#_3: R21559.2 U13116.3(W\P\(IO2)) U13117.3(W\P\)
WRST#: C889.1 D19.2(ANODE) Q42.6(D) R816.1 U49.14(WRST#)
XCLK_RBIAS: R21196.2 U13113.E1(XCLK_BIASREF)
XDP_PRDY#: U41.BP27(PROC_PRDY#) U13113.AT4(PRDY#)
XDP_PREQ#: R20755.2 U41.BL30(PROC_PREQ#) U13113.AT3(PREQ#)
XDP_TCK: R20756.2 U41.BR28(PROC_TCK)
XDP_TDI_CPU: R20754.2 U41.BL32(PROC_TDI)
XDP_TDO_CPU: R578.2 U41.BT28(PROC_TDO)
XDP_TMS_CPU: R20753.2 U41.BP28(PROC_TMS)
XDP_TRST#: R564.2 U41.BP30(PROC_TRST#) U13113.AY5(CPU_TRST#)
XTAL24_IN: C94820.2 R21218.1 U13113.A6(XTAL24_IN) Y1002.1
XTAL24_OUT: C94822.2 R21218.2 U13113.A5(XTAL24_OUT) Y1002.3
XTALOUTBUFF: R21620.1 U13114.BK6(XTAL_OUTBUFF)
XTALSSIN: R21619.1 U13114.BJ6(XTAL_SSIN)
XTLI: C94991.2 U13143.8(XTLI) Y1003.1
XTLO: C94993.2 U13143.7(XTLO) Y1003.3
N259407: C94711.1 MR1.2(VCC) R20968.1
N16771972: Q7851.1(S) R21502.1 U13114.BL26(PEX_CLKREQ_N)
N16787949: C890.2 R817.1
N16788300: C891.1 U49.12(VCORE)
N16788343: R67291.2 R67306.2 U49.15(ECSMI#/GPD4(3))
N16788450: R67038.1 U49.3(GPH7)
N16788484: C94645.1 R20904.2 R67332.1 U49.66(ADC0/GPI0(3))
N16788554: C96219.2 R67312.2 R67335.1 U49.82(EGAD/GPE1)
N16788590: R67314.2 R67315.2 U49.122(DTR1#/SBUSY/GPG1/ID7)
N16788625: C94643.1 R20902.2 R67341.2 U49.98(ID5/GPH5)
N17045084: R67333.1 R67334.1 U49.2(GPJ7)
N17045098: C94646.1 R20905.2 U49.128(GPJ6)
N17086723: C95057.2 R21507.1 U13115.5(VCC)
N19293751: T27.1 U41.AU13(ZVM2#)
N19293753: T28.1 U41.AY13(MSM2#)
N19293755: T25.1 U41.AT13(ZVM#)
N19293757: T26.1 U41.AW13(MSM#)
N19641145: TP13093.1 U13113.BE5(GPP_I9/DDPD_CTRLCLK)
N19689710: T78.1 U13113.BC18(GPP_A14/SUS_STAT#/ESPI_RESET#)
N19748096: T23.1 U41.BM14(VCC_OPC_1P8#BM14)
N19748098: T24.1 U41.BL14(VCC_OPC_1P8#BL14)
N19799125: TP13148.1 U13113.BC23(GPP_B3/CPU_GP2)
N19801823: TP13083.1 U13113.D8(CLKOUT_PCIE_N5)
N19801825: TP13084.1 U13113.D7(CLKOUT_PCIE_P5)
N19940934: PC149.2 PR178.2
N19940984: PC131.1 PR168.2
N19941004: PR67005.2 PU9.14(VO1)
N19941046: PR180.2 PR181.1 PR183.1 PU9.7(PGOOD)
N19941188: PC130.1 PR167.2
N19941230: PC148.2 PR177.1
N20064057: R21087.1 U13113.AG2(USB2_ID)
N20175011: R67238.1 U13113.AU44(GPP_C11/UART0_CTS#)
N20685724: R180.1 R181.1 U41.BN1(PROC_SELECT#)
N20974301: PC260.1 PC261.1 PC262.1 PJ3007.1 PL15.2 PR303.2
N20974305: PC264.1 PR310.2 PU19.4(VIN)
N20974309: PR303.1 PR307.1
N20974321: PC263.2 PR306.1 PU19.1(EN)
N20974323: PR304.1 PR305.1 PR306.2
N20974337: PR307.2 PR308.1 PU19.6(VFB)
N20974362: PR309.1 PU19.5(PG)
N21037008: R578.1 R20753.1 R20754.1 R20755.1 R20757.1 R20758.1
N21715576: PC103.1 PR130.2 PU5.1(VIN1#1) PU5.2(VIN1#2)
N21715610: PC98.1 PC102.1 PR127.1 PU5.8(OUT2#1) PU5.9(OUT2#2)
N21715628: PC108.1 PR136.1 PU5.4(VBIAS)
N21715632: PC100.1 PU5.12(CT1)
N21715634: PC101.1 PU5.10(CT2)
N21715638: PC97.1 PC99.1 PR128.2 PU5.13(VOUT1#1) PU5.14(VOUT1#2)
N21715675: PC107.1 PR132.2 PU5.5(ON2)
N21715683: PC106.1 PR131.1 PU5.3(ON1)
N21716526: PC143.1 PR172.2 PU8.1(VIN1#1) PU8.2(VIN1#2)
N21716528: PC144.1 PR173.2 PU8.6(VIN2#1) PU8.7(VIN2#2)
N21716560: PC134.1 PC138.1 PR6413.1 PU8.8(OUT2#1) PU8.9(OUT2#2)
N21716568: PC145.1 PR175.1 PU8.4(VBIAS)
N21716582: PC129.1 PU8.12(CT1)
N21716584: PC132.1 PU8.10(CT2)
N21716588: PC133.1 PC137.1 PR169.2 PU8.13(VOUT1#1) PU8.14(VOUT1#2)
N21716627: PC146.1 PR176.2 PU8.5(ON2)
N21716633: PC147.1 PR174.1 PU8.3(ON1)
N22430008: R21086.1 U13113.AD10(USB2_VBUSSENSE)
N22944814: C94919.2 R21436.2
N23334321: PC2030.1 PR2023.2 PU2001.4(VTTREF)
N23334329: PC2029.2 PR2022.1
N23334357: PC2031.1 PC2032.1 PC2033.1 PC2035.1 PC2036.1 PC2037.1 PJ2003.1 PL2001.2 PR2026.1
N23334507: PR2028.1 PU2001.3(GND)
N23334555: PC2039.1 PR2025.2
N24995566: PC6228.1 PR3020.2 PU3002.5(VCC)
N24995570: PR3021.1 PU3002.1(SET)
N24995581: PR3022.1 PU3002.3(O\T\)
N25175376: PC9484.2 PR66983.1
N25176926: PR66994.1 PR67000.2 PR67001.2
N25176932: PR66986.1 PU9014.5(BOOT)
N25176937: PC9487.1 PR66986.2
N25176943: PC9490.2 PR66989.2 PU9014.3(VCC) PU9014.29(PVCC)
N25176945: PR66995.2 PU9014.1(PWM)
N25176947: PR66994.2 PU9014.2(FCCM)
N25195796: PC5583.1 PR66837.1 PU37.26(VDD18)
N25195989: PC5584.1 PR66838.1 PU37.44(VDD33)
N25196021: PR66849.1 T9005.1
N25196023: PR66856.1 T9006.1
N25196027: PR66850.1 T9007.1
N25200237: PC5635.2 PL8002.1 PR66917.1 PU46.2(SW#1) PU46.3(SW#2) PU46.4(SW#3)
N25200251: PC5646.2 PL9019.1 PR66922.1 PU45.2(SW#1) PU45.3(SW#2) PU45.4(SW#3)
N25200989: PC5654.2 PL6.1 PR66927.1 PU43.2(SW#1) PU43.3(SW#2)
N25200997: PC5654.1 PU43.13(BST)
N25201029: PC5635.1 PU46.21(BST)
N25201083: PC5646.1 PU45.21(BST)
N25248500: PC5594.1 PR66897.2
N25248502: PC5588.1 PR66880.2
N25248512: PC5586.1 PR66867.2
N25255287: PR5.1 PU1.20(SRP)
N25255291: PR6.1 PU1.19(SRN)
N25255306: PC17.1 PL5.2 PQ2.1(S1) PQ2.2(S2) PQ2.3(S3) PR7.1 PR209.1 PR210.1
N25255314: PC1.2 PC2.2 PQ1.4(G) PR29.1
N25255394: PC19.1 PR33.2
N25255413: PC15.2 PR11.1
N25255465: PC17.2 PQ2.4(G) PR4.1
N25255510: PR19.2 PU1.11(SDA)
N25255512: PR17.2 PU1.12(SCL)
N25255513: PR32.2 PU1.7(IADP)
N25255515: PR25.2 PU1.9(PMON)
N25255534: PR30.2 PU1.5(ACOK)
N25255538: PR8.1 PR205.1 PU1.15(B\A\T\P\R\E\S\)
N25255547: PR26.2 PU1.8(IDCHG)
N25272043: PC9375.1 PR66969.2
N25272069: JP10.1 PC9374.1 PC9380.1 PL1.2 PR104.1
N25275939: PC9063.1 PR9225.2 PU9004.1(VIN1#1) PU9004.2(VIN1#2)
N25275943: PC9064.1 PR9226.2 PU9004.6(VIN2#1) PU9004.7(VIN2#2)
N25275965: PC9073.1 PU9004.10(CT2)
N25275966: PC9072.1 PU9004.12(CT1)
N25275967: PC9069.1 PR9223.1 PU9004.4(VBIAS)
N25275980: PC9071.1 PR9057.1 PU9004.5(ON2)
N25275989: PC9070.1 PR9056.2 PU9004.3(ON1)
N25276006: PD9003.2(ANODE) PQ9034.3(D) PR9165.2
N25276014: PQ9010.2(G) PQ9011.3(D) PQ9034.2(G) PR9061.2 PR9062.1
N25276025: PC9074.1 PC9075.1 PJ9003.2 PQ9009.5(D)
N25276027: PR9077.1 PU9005.3(PGD)
N25276032: PQ9010.3(D) PR9059.2
N25276035: PC9081.1 PQ9011.2(G) PR9065.2 PR67002.2 PU9005.4(EN)
N25276054: PR9066.1 PR67010.2
N25276055: PC9080.1 PR9064.2
N25318217: PC5638.1 PR66917.2
N25320279: PC5647.1 PR66922.2
N25324032: PC5660.1 PR66927.2
N25329170: PQ9000.3(D) PQ9001.2(G) PR9003.2 PR9007.1
N25329172: PC9003.1 PC9005.1 PC9006.2 PR9009.1 PR9012.2 PR9017.1
N25329191: PR9236.1 PR9241.1 PR9244.1
N25329192: PR9244.2 PU9001.27(TP1)
N25329193: PR9236.2 PU9001.28(TP2)
N25329218: PC9008.2 PC9009.2 PR9027.1 PR9028.2
N25329239: PC9007.1 PR9029.1 PR9030.1 PR9031.1
N25329279: PR9000.1 PR9045.2 PR9052.2
N25329280: PC9000.1 PC9015.2 PC9016.2 PR9000.2 PR9048.2 PR9052.1 PR9058.1 PR9060.1 PR9238.1 PR9240.1 PR9242.1
N25329287: PC9002.1 PD9000.2(ANODE) PQ9000.2(G) PR9002.1 PR9006.2
N25329351: PR9039.1 PU9001.5(FSW)
N25329395: PR9040.2 PR9041.2
N25329401: PR9036.1 PR9037.1
N25329418: PC9010.1 PR9033.1 PR9038.2
N25329440: PC9008.1 PR9034.2
N25329447: PC9006.1 PR9020.2
N25331202: PR9070.2 PR9071.1 PR9072.2
N25331224: PC9027.1 PR9068.2
N25331230: PC9030.2 PR9073.1
N25331270: PR66992.1 PR66998.2 PR66999.2
N25331273: PR66985.1 PU9013.5(BOOT)
N25331274: PC9486.1 PR66985.2
N25331278: PC9489.2 PR66988.2 PU9013.3(VCC) PU9013.29(PVCC)
N25331279: PR66993.2 PU9013.1(PWM)
N25331280: PR66992.2 PU9013.2(FCCM)
N25331384: PC9483.2 PR66982.1
N25331424: PR66990.1 PR66996.2 PR66997.2
N25331427: PR66984.1 PU9012.5(BOOT)
N25331428: PC9485.1 PR66984.2
N25331432: PC9488.2 PR66987.2 PU9012.3(VCC) PU9012.29(PVCC)
N25331433: PR66991.2 PU9012.1(PWM)
N25331434: PR66990.2 PU9012.2(FCCM)
N25331454: PC9482.2 PR66981.1
N25331490: PC9026.2 PR9256.2 PU9011.3(VCC) PU9011.29(PVCC)
N25331491: PR9069.2 PU9011.1(PWM)
N25331493: PR9071.2 PU9011.2(FCCM)
N25430953: PQ14.3(D) PR111.2
N25430988: PQ12.3(D) PR106.2
N25430994: PQ19.3(D) PR126.2
N25431044: PQ41.3(D) PR298.2
N25431520: PQ9050.3(D) PR9227.2
N25504610: PC5616.1 PR66907.2
N25504615: PC5626.1 PR66912.2
N25504770: PC5606.1 PR66902.2
N25504898: PC5605.2 PL9021.1 PR66902.1 PU38.2(SW#1) PU38.3(SW#2) PU38.4(SW#3)
N25504902: PC5605.1 PU38.21(BST)
N25504904: PC5614.2 PL9020.1 PR66907.1 PU39.2(SW#1) PU39.3(SW#2) PU39.4(SW#3)
N25504908: PC5614.1 PU39.21(BST)
N25504978: PC5624.2 PL9022.1 PR66912.1 PU44.2(SW#1) PU44.3(SW#2) PU44.4(SW#3)
N25504982: PC5624.1 PU44.21(BST)
N25506822: PC222.2 PR264.1
N25506913: PC81.1 PR112.2
N25506978: PQ8.3(COLLECTOR) PQ9054.2(G) PQ9059.2(G) PR83.1 PR84.2
N25507004: PQ9059.3(D) PR86.2
N25507051: PR67003.2 PR67007.2
N25629762: T18.1 U41.E1(RSVD_TP#E1)
N25629765: T17.1 U41.D1(RSVD_TP#D1)
N25629774: T19.1 U41.E3(RSVD_TP#E3)
N25629777: T20.1 U41.E2(RSVD_TP#E2)
N25629792: T21.1 U41.BR1(RSVD_TP#BR1)
N25629798: T22.1 U41.BT2(RSVD_TP#BT2)
N27902963: C94889.2 R21409.1
N27904651: CN2063.165(CS3#/C1/NC) T62.1
N27904653: CN2063.162(CS2#/C0/NC) T61.1
N28625551: CN2069.10 TP13118.1
N28683412: CN2076.8 R67339.2 R67340.2
N28683473: Q7892.3(D) R67258.1 R67274.2 R67275.2
N28683495: Q7892.6(D) R67259.1 R67276.2 R67277.2
N30107216: R67138.1 U13155.A6(PP_HV#1) U13155.A7(PP_HV#2) U13155.A8(PP_HV#3) U13155.B7(PP_HV#4)
N30638362: R21106.1 R21107.1 R21109.1 R21110.1 R21111.1
N30638583: R21133.1 U13113.AT2(ITP_PMODE)
N30641967: R21191.1 U13113.AK2(PLTRST_PROC#)
N30677152: C94846.1 R21359.2 U13113.BA15(VCCHDA)
N30677370: C94847.1 R67211.1 U13113.BD3(VCCPRIM_3P3#8-BD3) U13113.BE3(VCCPRIM_3P3#8-BE3) U13113.BE4(VCCPRIM_3P3)
N30680491: TP13078.1 U13113.BB13(SLP_SUS#)
N30710926: TP13090.1 U13113.AV44(GPP_C9/UART0_TXD)
N30773854: TP13141.1 U13113.BC26(GPP_B12/SLP_S0#)
N30774062: TP13075.1 U13113.AR15(GPD11/LANPHYPC)
N30774076: TP13076.1 U13113.AV13(GPD9/SLP_WLAN#)
N30774179: TP13091.1 U13113.AU43(GPP_C12/UART1_RXD/ISH_UART1_RXD)
N30809865: T7.1 U41.BM33(RSVD_TP#BM33)
N30809866: T8.1 U41.BL33(RSVD_TP#BL33)
N30809890: T9.1 U41.BJ14(RSVD_TP#BJ14)
N30809892: T10.1 U41.BJ13(RSVD_TP#BJ13)
N30809922: T11.1 U41.BJ16(RSVD_TP#BJ16)
N30809924: T12.1 U41.BK16(RSVD_TP#BK16)
N30809960: T13.1 U41.BK24(RSVD_TP#BK24)
N30809962: T14.1 U41.BJ24(RSVD_TP#BJ24)
N30809992: T15.1 U41.BJ34(RSVD_TP#BJ34)
N30809994: T16.1 U41.BJ33(RSVD_TP#BJ33)
N30861449: TP13088.1 U13113.BC36(GPP_H18/SML4ALERT#)
N30861493: TP13089.1 U13113.BB36(GPP_H15/SML3ALERT#)
N30861840: TP13087.1 U13113.BD17(GPP_A11/PME#)
N30878679: TP13094.1 U13113.BE6(GPP_I10/DDPD_CTRLDATA)
N31204434: TP13116.1 U13114.BA1(GPIO32)
N31204443: TP13115.1 U13114.BA2(GPIO31)
N31204854: Q7859.2(G) R67320.2 R67321.2
N31226995: D8591.1(CATHODE) D13088.2(ANODE) Q7861.3(D) Q7863.3(D) Q7943.1(S) R21602.1 R21603.2 R67323.1
N31226999: D8591.2(ANODE) D8592.2(ANODE) D8594.1(CATHODE) R21611.1 R21613.1
N31267415: D8595.3(COMMON ANODE) Q7867.2(G) R21616.2
N31267438: C95158.2 Q7866.2(G) Q7867.3(D) R21618.2
N31399389: C94633.1 Q42.2(G) Q42.3(D) R20897.1
N31399406: R251.2 R20897.2 R20898.2
N31579849: R20817.2 R20818.1
N31579856: R145.2 R20816.2
N31583921: TP13086.1 U13113.R7(CLKOUT_PCIE_P6)
N31583923: TP13085.1 U13113.R8(CLKOUT_PCIE_N6)
N31810763: Q7819.2(G) Q7820.3(D) R20948.1
N31810778: Q7822.2(G) Q7823.3(D) R20957.1
N31853816: D8568.2(CATHODE2) R67246.2 R67247.2
N31870197: C94739.1 C94741.1 Q7827.3(D) Q7831.3(D) Q7903.2(G) Q7903.5(G) Q7904.2(G) Q7904.5(G) R20987.2
N31870208: Q7903.1(S) Q7903.4(S)
N31870227: Q7904.1(S) Q7904.4(S)
N31870285: Q7831.2(G) Q7832.3(D) R20994.2
N31870300: Q7827.2(G) Q7828.3(D) R20988.2
N31931077: R21057.1 U13093.30(REXT)
N31931449: T33.1 U13025.27(SBU1)
N31931452: T29.1 U13025.26(SBU2)
N31931461: R67382.1 R67397.1 U13025.29(CAD_SNK/DCI_DAT)
N31931505: T31.1 U13025.35(EQ1)
N31931507: T32.1 U13025.3(SSEQ1)
N31931509: T30.1 U13025.38(EQ0)
N31995423: C94931.1 C94932.1 L4273.1 U13108.20(CPVDD/AVDD2)
N31995611: R21453.1 U13108.16(SDATA_IN)
N31996495: Q7845.2(G) Q7846.3(COLLECTOR) R21438.2
N32024602: R21861.2 U13135.H13(ZQ)
N32027102: C94992.1 U13112.1(TCT1) U13112.4(TCT2) U13112.7(TCT3) U13112.10(TCT4)
N32050492: R21863.2 U13136.H13(ZQ)
N32068560: R21865.2 U13137.H13(ZQ)
N32077141: R21868.2 U13138.H13(ZQ)
N32082063: R67200.2 U13139.H13(ZQ)
N32088630: R21873.2 U13140.H13(ZQ)
N32090895: TP13142.1 U13113.L2(CLKOUT_ITPXDP_P)
N32090898: TP13143.1 U13113.L1(C\L\K\O\U\T\_\I\T\P\X\D\P\)
N32092703: R21875.2 U13141.H13(ZQ)
N32098420: R67201.2 U13142.H13(ZQ)
N32113508: CN2069.56 TP13119.1
N32113521: CN2069.58 TP13120.1
N32125182: T9023.1 U13113.AW17(GPP_A7/PIRQA#/ESPI_ALERT0#)
N32178168: R67179.1 U13155.F10(BUSPOWERZ)
N32328076: TP13126.1 U13113.AN15(GPD8/SUSCLK)
N32337959: CN2070.58 TP13123.1
N32345066: CN2070.10 TP13121.1
N32372225: CN2070.56 TP13122.1
N32522422: R21915.1 U13147.15(RSV1)
N32522507: R21900.1 U13147.22(PWD)
N32522548: R21901.1 U13147.23(RSV2)
N32522591: R21902.1 U13147.27(A_SWING)
N32522606: C96202.2 U13147.14(VDD#2)
N32522766: R21908.1 U13147.7(B_SWING)
N32522794: R21916.1 U13147.1(REXT)
N32532892: R21972.1 U13149.15(RSV1)
N32533102: R21952.1 U13148.15(RSV1)
N32533214: R21936.1 U13148.22(PWD)
N32533261: R21937.1 U13148.23(RSV2)
N32533302: R21938.1 U13148.27(A_SWING)
N32533309: C96204.2 U13148.14(VDD#2)
N32533452: R21947.1 U13149.22(PWD)
N32533494: R21944.1 U13148.7(B_SWING)
N32533537: R21953.1 U13148.1(REXT)
N32533642: R21957.1 U13149.23(RSV2)
N32533766: R21958.1 U13149.27(A_SWING)
N32533781: C96203.2 U13149.14(VDD#2)
N32534005: R21964.1 U13149.7(B_SWING)
N32534049: R21973.1 U13149.1(REXT)
N32686297: R67039.2 R67264.1 U49.20(L80LLAT/GPE7)
N32869672: CN2068.36(GND#9) R21995.2
N33146604: R22050.2 R67072.2 U13113.AW4(GPP_I0/DDPB_HPD0)
N33266779: R67294.2 R67295.2 U49.87(PS2CLK1/DTR0#/GPF2)
N33277676: T77.1 U13113.AJ35(GPP_D19/DMIC_CLK0)
N33277677: T76.1 U13113.AH44(GPP_D20/DMIC_DATA0)
N33341392: TP13127.1 U13113.AU41(GPP_C15/UART1_CTS#/ISH_UART1_CT)
N33341397: TP13128.1 U13113.AT43(GPP_C13/UART1_TXD/ISH_UART1_TXD)
N33341415: TP13129.1 U13113.AT44(GPP_C14/UART1_RTS#/ISH_UART1_RT)
N33354874: Q7855.2(G) Q7856.3(D) Q7945.2(G) R21587.2
N33487842: TP13137.1 U13113.AR24(GPP_B15/GSPI0_CS#)
N33567226: T58.1 U13079.38(EQ0)
N33567227: T59.1 U13079.35(EQ1)
N33567228: T60.1 U13079.3(SSEQ1)
N33625973: T56.1 U13079.27(SBU1)
N33625978: T57.1 U13079.26(SBU2)
N33701634: C94723.2 R22073.1 U13081.1(OUT)
N33701636: C94725.2 R20973.2 U13081.4(IN#1) U13081.5(IN#2)
N33701676: R20974.2 U13081.3(EN)
N33739416: R21740.1 U13146.15(RSV1)
N33739501: R21984.1 U13146.22(PWD)
N33739542: R21979.1 U13146.23(RSV2)
N33739589: R21986.1 U13146.27(A_SWING)
N33739604: C96201.2 U13146.14(VDD#2)
N33739796: R21988.1 U13146.7(B_SWING)
N33739832: R21981.1 U13146.1(REXT)
N33795012: R22083.2 U13108.5(GPIO1/DMIC-CLK)
N33796046: R22084.1 U13108.4(GPIO0/DMIC-DATA-12)
N33796156: C94947.1 R21454.1 U13108.14(BCLK)
N33856405: R22090.2 R22091.2 U13108.33(5VSTB/AUX_MODE)
N33857304: TP13150.1 U13108.36(LINE1-L)
N33857317: TP13149.1 U13108.35(LINE1-R)
N33860479: TP13100.1 U13108.1(GPIO2/SPDIFO)
N34193347: PR188.1 PR67004.2
N34193617: PR184.2 PR67006.2
N34290079: TP13114.1 U13114.BB2(GPIO25)
N34291908: TP13138.1 U13113.AW31(SPI0_CS1#)
N34874002: Q7901.3(D) R22128.1 R22129.1 R22130.1 R22131.1 R22132.1 R22133.1 R22134.1 R22135.1
N34984408: Q16.2(BASE) R222.2
N34985582: Q7902.2(BASE) R22140.2
N34999680: TP13145.1 U13113.AR3(JTAGX)
N35181174: TP13139.1 U13113.BC15(GPD6/SLP_A#)
N35181196: TP13140.1 U13113.BA13(GPD10/SLP_S5#)
N35716714: R67163.2 U13113.AN38(GPP_D2/SPI1_MISO)
N35891430: R22185.1 U3.18(IREF)
N35891432: R22167.1 U3.10(SDATA)
N35891440: R22208.1 U3.2(SRCIN)
N35891446: R22209.1 U3.3(SRCIN#)
N35891448: R22163.1 R22164.2 U3.1(PLL_BW_SEL)
N35891500: C95988.1 C95989.2 R22171.1 U3.20(VDDA)
N35891518: R22168.1 U3.11(SCLK)
N35891538: R22166.1 R22211.2 U3.17(OE_1#)
N35891554: R22170.2 U3.13(CLK1#)
N35891556: R22169.2 U3.14(CLK1)
N35891568: R22210.2 R22213.1 U3.4(OE_0#)
N35927903: C95975.1 U13151.13(VEE)
N35927908: C95974.2 U13151.16(VREF)
N35928782: C95976.1 U13151.2(CP)
N35948693: C95984.2 U13150.2(INL+)
N35948694: C95985.2 U13150.3(INR+)
N35948729: C95982.1 U13150.11(CP)
N35948730: C95982.2 U13150.9(CN)
N35948737: C95978.1 U13150.8(PVSS)
N35948761: R67013.1 U13151.14(REXT)
N35948766: C95973.2 U13151.7(ADC_LDO)
N35948770: C95962.1 U13151.10(FLT)
N35948773: R67014.1 U13151.8(CH3)
N35948778: R67015.1 U13151.9(CH2)
N35952409: R22193.2 U3.8(CLK0#)
N35952413: R22192.2 U3.7(CLK0)
N36010424: R21450.1 R22159.1 R67205.2 R67207.1
N36010432: R21447.1 R21449.1 R67204.2 R67206.1
N36060148: C95976.2 U13151.15(CN)
N36087926: T71.1 U13113.AF5(USB2N_1)
N36087928: T72.1 U13113.AG7(USB2P_1)
N36183553: R67303.2 U13152.31(A0)
N36183599: R67023.1 U13152.30(REXT)
N36184365: CN2071.6 D8565.1 R21049.2
N36184511: D13042.1 R22150.2 SW3.2
N36196173: R67164.1 U49.24(PWM0/GPA0)
N36343328: C94922.2 U13108.32(MIC2-CAP)
N36343332: C94925.1 U13108.25(CPVEE)
N36343342: C94933.1 U13108.21(LDO2-CAP)
N36343351: C94937.1 U13108.19(LDO3-CAP)
N36343359: C94926.2 U13108.38(VREF)
N36343360: C94930.2 R21446.2 U13108.39(LDO1_CAP)
N36392478: Q7846.2(BASE) R21439.1 R21440.2
N36639740: CN2043.14(CONFIG2) R20972.2
N36754118: R67398.2 U13092.1(VCC)
N36762992: PR9068.1 PU9011.5(BOOT)
N36763078: PC9027.2 PU9011.7(PHASE)
N36765623: R67148.2 U13080.3(OCB)
N36766745: PC9485.2 PU9012.7(PHASE)
N36769397: PC9486.2 PU9013.7(PHASE)
N36770302: PC9487.2 PU9014.7(PHASE)
N36980981: R67166.1 U49.28(PWM2/GPA2)
N37464977: C96218.1 R21065.1 R67281.2 U49.70(ADC4/GPI4(3))
N37522594: PC8105.1 PC8106.1 PC8107.1 PC8108.1 PD40.1(CATHODE) PJ9020.2 PR9231.2
N37522596: PC8099.1 PC8100.1 PC8103.1 PL9.1 PQ17.3(D) PR9230.1 PR9234.2 PU8006.8(IN)
N37522685: PC8101.2 PR9233.1
N37550876: PQ9081.2(BASE) PR67171.1 PR67175.2
N37550890: PQ9080.3(D) PR67172.2
N37550892: PQ9080.2(G) PQ9081.3(COLLECTOR) PR67173.1 PR67174.2
N37551635: PC8109.2 PQ17.2(G) PR49.2 PR51.1
N37551639: PC8109.1 PQ17.1(S) PR49.1 PR67176.2
N37551712: PQ9082.3(D) PR51.2
N37551735: PQ9082.2(G) PR67223.2 PR67224.2 PR67225.2
N37571887: R67174.1 U49.25(PWM1/GPA1)
N37575832: T96.1 U13155.E10(GPIO_5)
N37576451: PQ9020.3(COLLECTOR) PQ9021.2(G) PR9132.2 PR9140.1
N37576488: PQ9020.2(BASE) PR9139.1 PR9141.1
N37576489: PC9186.1 PR9142.2 PR9145.2
N37576527: PQ9031.2(G) PQ9032.3(D) PR9209.2 PR9210.1
N37576543: PQ9021.3(D) PR9131.1
N37576561: PQ9031.3(D) PR9208.2
N37576565: PC9439.1 PR66970.1
N37576617: PC9113.1 PR9122.1
N38117819: T9019.1 U41.BN25(CFG[0])
N38117832: T9020.1 U41.BN27(CFG[1])
N38117858: T9021.1 U41.BR23(CFG[8])
N38117859: T9022.1 U41.BR22(CFG[9])
N38117884: T9010.1 U41.BT19(CFG[15])
N38117885: T9009.1 U41.BP19(CFG[14])
N38117910: T9011.1 U41.BN23(CFG[17])
N38117911: T9012.1 U41.BP23(CFG[16])
N38117936: T9014.1 U41.BN22(CFG[18])
N38117937: T9013.1 U41.BP22(CFG[19])
N38117962: T9015.1 U41.BR27(BPM#[0])
N38117963: T9016.1 U41.BT27(BPM#[1])
N38117988: T9018.1 U41.BT30(BPM#[3])
N38117989: T9017.1 U41.BM31(BPM#[2])
N38649202: PC182.2 PR138.1 PR139.1 PU12.12(IN+1)
N38649204: PC182.1 PR146.1 PU12.11(IN-1)
N38649215: PC184.1 PR67199.1 PR67217.1 PU12.4(VS)
N38649229: PR161.1 PR706.1 PR67217.2 PU12.5(A0)
N38649281: PC174.2 PR119.1 PU12.14(IN-2)
N38649283: PC174.1 PR124.1 PR67194.1 PU12.15(IN+2)
N38649292: PU12.10(PV) T9008.1
N38655762: PR416.2 PR417.2 PR705.2 PR67201.1
N38655784: PD101.2(ANODE) PD102.2(ANODE) PQ147.1(S)
N38655792: PQ147.2(G) PR705.1
N38784914: Q7844.2(BASE) R21411.2
N38791003: TP13144.1 U13113.AR17(GPP_A16/CLKOUT_48)
N39029594: Q20.1(S) R184.1 R191.1
N39029637: Q23.2(BASE) R191.2
N39882995: T9024.1 U13113.AB42(GPP_F6/DEVSLP4)
N39883008: T9025.1 U13113.AB43(GPP_F7/DEVSLP5)
N39885867: TP13146.1 U13113.AG35(GPP_E1/SATAXPCIE1/SATAGP1)
N39885880: TP13147.1 U13113.AG39(GPP_E2/SATAXPCIE2/SATAGP2)
N40227168: Q7843.3(D) R67255.1 R67271.2 R67272.2
N40589826: R67141.1 U13155.F11(RESETZ)
N40838180: R67267.2 R67268.1
N40838182: Q7935.3(COLLECTOR) R67267.1
N40966338: Q7937.3(COLLECTOR) Q7938.2(BASE) R67290.2
N42411396: Q7944.1(S) R67327.2
N42687628: R67336.2 R67337.2 U13151.6(NC)
N42752592: TP13101.1 U13114.BD21(IFPAB_PLLVDD)
N42926777: C96224.1 U13156.4(VCC)
N45101115: C96225.2 U13157.28(BYPASS#2)
N45105751: C96226.2 U13157.2(BYPASS#1)
N45109965: C96232.2 U13157.19(VREF)
N45110044: C96233.2 C96234.1 U13157.18(LDO_A1.5)
N45335220: CN11.8 TP13151.1
N45490354: PQ9084.3(D) PR67231.2
N45685102: R67369.1 R67370.1 SW3.3
N45750134: PQ9086.2(G) PQ9087.3(D) PR67234.1
N45750138: PQ9086.3(D) PR67236.1
N46189580: R67388.2 U13161.3(EN)
N46382419: C96250.2 U13159.12(CT1)
N46382439: C96251.2 U13159.10(CT2)
N46383446: R67389.1 U13159.13(VOUT1#1) U13159.14(VOUT1#2)
N46384360: R67391.1 U13159.8(OUT2#1) U13159.9(OUT2#2)
N46385421: C96260.1 R67393.1 U13159.4(VBIAS)
N46521490: PQ9088.3(D) PQ9089.2(G) PR67239.1
N46528749: PQ9089.3(D) PR67219.1
N46825791: C96269.2 U13158.12(CT1)
N46825793: C96270.2 U13158.10(CT2)
N46825849: T9036.1 U13158.6(VIN2#1) U13158.7(VIN2#2)
N46825877: T9034.1 U13158.5(ON2)
N46825921: R67402.2 U13158.13(VOUT1#1) U13158.14(VOUT1#2)
N46825967: T9035.1 U13158.8(OUT2#1) U13158.9(OUT2#2)
N46826030: C96279.1 R67401.1 U13158.4(VBIAS)
N46971490: Q7949.3(D) R67403.2 R67407.2
N46971526: Q7949.6(D) R67404.2 R67408.2
N323001010: CN2062.162(CS2#/C0/NC) T63.1
N323001110: CN2062.165(CS3#/C1/NC) T64.1
N402557870: T92.1 U13155.F4(SWD_DAT)
N4025593943: T93.1 U13155.G4(SWD_CLK)

Pads without a net: CN11 9 10 14 19; CN2042 37 38; CN2044 13 14; CN2049 6 7 8; CN2068 16 38 40 42 44 46 48 50 58 60 62; CN2069 6 8 20 22 24 26 28 30 32 34 36 40 42 44 46 48 54 67 68 77; CN2070 6 8 20 22 24 26 28 30 32 34 36 40 42 44 46 48 54 67 68; CN2071 2; CN2076 2 3 17 18; NOREF#2 1; NOREF#6 1; NOREF#7 1; NOREF#10 1; NOREF#11 1; NOREF#12 1; PJ2 7; PU9 19; PU12 1 2 13 16; PU9009 5 6; PU9011 6 27 30 31 33; PU9012 6 27 30 31 33; PU9013 6 27 30 31 33; PU9014 6 27 30 31 33; U21 A7 A9 A11 A13 A23 AB15 AB17 AB19 AB21 AB23 AC15 AC17 AC19 AC21 AC23 B7 B9 B11 B13 B23 D19 E18 E19 J1 J2 L1 L2 N1 N2 R1 R2 V18 W12 W16 W19 Y12 Y16 Y19; U41 A27 AA14 AD2 AD4 AE1 AE5 AE9 AE10 AE11 AE29 AF10 AF29 AF30 AF31 AF32 AF33 AF34 AG13 AG14 AG31 AG32 AG33 AG34 AG35 AG36 AH13 AH14 AH29 AH30 AH31 AH32 AH35 AH36 AJ8 AJ10 AJ11 AJ13 AJ14 AK3 AL1 AL2 AL3 AM10 AM11 AT3 AT5 AT7 AT11 AW7 AW8 AW9 AW10 AW11 AY1 AY2 AY3 AY4 AY5 AY7 AY8 AY9 AY10 AY11 B2 B27 B30 B33 B34 B36 B38 BA1 BA2 BA3 BA4 BA5 BH30 BJ17 BJ19 BJ20 BJ21 BJ23 BJ26 BJ27 BJ28 BJ35 BJ36 BK17 BK19 BK20 BK21 BK23 BK26 BK27 BK28 BL15 BL16 BL17 BL18 BL19 BL20 BL21 BL22 BL23 BL24 BL25 BL26 BL27 BL28 BL31 BL34 BM15 BM16 BM17 BM22 BM24 BN15 BN16 BN17 BN33 BN35 BP1 BP15 BP16 BP17 BR2 BR15 BR16 BR17 BR31 BR35 BT15 BT16 BT17 BT22 C1 C30 C33 C34 C38 D34 E26 E30 E33 E36 E37 F26 F30 F33 F34 F35 F37 G3 G13 G38 H24 H33 H34 J3 J24 N29 R14; U13025 4 5 7 8; U13064 1; U13079 4 5 7 8; U13092 6; U13093 12 13 19 20 21 22 28 29; U13108 8; U13113 A7 A16 AA44 AA45 AB13 AB33 AB35 AB36 AB39 AB44 AC43 AD2 AD3 AD31 AD38 AE17 AE44 AF17 AF41 AG14 AG15 AG44 AH43 AJ11 AJ13 AJ33 AJ38 AJ42 AJ44 AL27 AL39 AL42 AM43 AM44 AN17 AN24 AN29 AN36 AN41 AN42 AR19 AR27 AT31 AV2 AV3 AV15 AW2 B7 B11 B14 B15 B16 BB17 BB38 BC8 BC38 BD1 BD14 BD24 BD36 BD38 BE2 BE39 C11 C14 C15 E45 F45 G13 G15 G37 G44 G45 H13 H15 H40 H42 H43 H44 J45 K13 K15 K37 K44 L37 L39 L43 L44 M44 N2 N3 N29 N31 N38 N39 N42 N43 N44 P1 P2 P3 P24 P27 P29 P31 P43 P44 R2 R3 R4 R11 R13 R24 R27 R35 R36 R39 R41 R42 R43 R44 T44 T45 U2 U3 U13 U35 U36 U39 U41 U42 U43 V1 V2 V44 W2 W3 W7 W13 W39 Y5; U13114 A17 A42 AA44 AC7 AC8 AC9 AD45 AD46 AF49 AG8 AG9 AG52 AM1 AM2 AM3 AM5 AM6 AM7 AM8 AN1 AN2 AN3 AN6 AN7 AN9 AN44 AR1 AR2 AR3 AR5 AR6 AR7 AR8 AT1 AT2 AT3 AT6 AT7 AT9 AT44 AT45 AV1 AV2 AV3 AV5 AV6 AV7 AV8 AW1 AW2 AW3 AW6 AW7 AW9 AW47 AW48 BA6 BA7 BA8 BA9 BB3 BB6 BB7 BB8 BD14 BD23 BE7 BE12 BE23 BF21 BF23 BF24 BG1 BG4 BG6 BG11 BG12 BG21 BG23 BG24 BH6 BH11 BH12 BH23 BJ9 BJ11 BK18 BK20 BK21 BK44 BL18 BL20 BL21 BM20 BM21 D17 D41 E29 F9 F29 F41 G9 G14 G35 G41 H6 H7 H14 H24 H35 J14 J23 J24 J35 J41 J46 J47 M7 M8 M44 M45 P9 U1 V4 V44 V45; U13128 9; U13135 A12 H2 M2 M13; U13136 A12 H2 M2 M13; U13137 A12 H2 M2 M13; U13138 A12 H2 M2 M13; U13139 A12 H2 M2 M13; U13140 A12 H2 M2 M13; U13141 A12 H2 M2 M13; U13142 A12 H2 M2 M13; U13143 23 24 25 26 28 38; U13152 10 12 13 14 19 28 29; U13155 A9 B9 L11; U13157 1 9 10 27 29 31 32 33 34 35 36 37 48; U13161 4

## Via types
v1: diameter 0.508, hole 0.254, TOP to BOTTOM, 7091 vias
v2: diameter 0.457, hole 0.254, TOP to BOTTOM, 939 vias
v3: diameter 0.61, hole 0.356, TOP to BOTTOM, 1033 vias
v4: diameter 0.406, hole 0.203, TOP to BOTTOM, 2669 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
1V8_AON_EN: length 152.4
  TOP w0.254: v1(121.56,117.31) 121.56,117.06 122.56,116.06 U13119.4 ; PR9057.2 v1(103.65,76.24)
  IN1 w0.254: v1(132.13,59.61) 131.57,60.16 127.27,60.16 126.63,60.81 125.16,60.81 124.58,61.39 121.84,61.39 120.14,63.08 113.91,63.08 112.42,61.59 112.42,61.26 111.48,60.32 107.49,60.32 104.36,63.44 104.36,64.81 104.77,65.22 104.77,72 103.02,73.75 103.02,75.61 v1(103.65,76.24) 103.83,76.42 109.37,76.42 109.72,76.06 111.42,76.06 113.43,78.07 124.35,78.07 126.45,80.17 126.45,83.7 127.25,84.5 127.25,87.72 128.93,89.4 128.93,93.62 128.37,94.17 128.37,95.9 121.18,103.09 121.18,111.45 121.79,112.06 121.79,115.54 121.56,115.76 v1(121.56,117.31)
  IN2 w0.254: v1(165.37,57.27) 165.37,56.61 164.78,56.02 157.31,56.02 156.87,56.46 150.29,56.46 148.84,57.9 146.43,57.9 146.06,58.27 140.59,58.27 140.06,57.74 133.76,57.74 132.2,59.3 132.2,59.49 132.13,59.56 v1(132.13,59.61)
  BOTTOM w0.254: v1(165.37,57.27) 165.37,57.46 PR67002.1
1V8_AON_S:
  vias: v1(103.5,68.22)
1V8_MAIN_EN: length 170
  TOP w0.14: R21589.2 140.2,116.17 v1(140.63,116.6) 140.8,116.77 141.23,116.77 142.88,118.41 U13114.BE1
  TOP w0.203: v1(106.19,75.66) 105.69,75.16 PR9056.1
  TOP w0.254: v1(111.96,62.22) 111.48,62.22 110.83,61.58 110.83,60.63 109.04,58.84 107.41,58.84 106.65,58.08 106.29,58.08 106.07,57.85 PR67233.1 107.22,57.46 107.51,57.75 PQ9083.2 ; PR9006.1 146.71,69.82 146.04,69.15 PD9000.1 145.18,70.3 v1(144.44,71.04)
  IN1 w0.254: v1(130.07,107.46) 130.07,110.73 131.19,111.85 133.7,111.85 136.15,114.29 137.54,114.29 139.85,116.6 v1(140.63,116.6) ; v1(144.44,71.04) 144.46,71.04 144.79,70.7 144.79,65.62 144.17,65 144.17,61.48 143.43,60.75 130.4,60.75 130.17,60.52 127.4,60.52 125.99,61.94 121.87,61.94 120.21,63.59 113.33,63.59 v1(111.96,62.22) 111.32,62.22 110.05,60.95 108.76,60.95 107.74,61.97 107.74,65.85 106.19,67.4 106.19,69.56 105.94,69.82 105.94,71.09 106.19,71.34 v1(106.19,75.66)
  IN4 w0.254: v1(144.44,71.04) 145.16,70.32 147.47,70.32 148.03,69.77 149.19,69.77 149.5,70.07 149.5,71.09 149.25,71.34 149.25,74.37 147.1,76.51 136.98,76.51 136.63,76.85 136.63,78.34 135.42,79.56 133.99,79.56 131.77,77.33 129.13,77.33 128,78.46 128,86.74 129.84,88.58 129.84,106.87 130.07,107.1 v1(130.07,107.46)
  BOTTOM w0.254: v1(130.07,107.46) 128.72,108.8 R67323.2
1V8_MAIN_EN_G: length 4.8
  TOP w0.381: PR67232.1 106.41,61.34 105.63,62.12 105.13,62.12 104.92,62.32 104.92,63.16 104.21,63.87 PQ9084.2
  vias: v1(108.2,60.85)
1V8_MAIN_S:
  vias: v1(108.33,68.62)
3V_LDO: length 277.8
  TOP w0.14: v1(283.71,85.69) 284.78,85.69 285.38,85.09 PR3020.1
  IN1 w0.254: v1(83.74,70.84) 83.74,71.67 82.98,72.43 82.98,74.82 82.27,75.53 82.27,76.37 87.9,82.01 88.26,82.01 92.65,77.61 94.1,77.61 94.66,77.05 98.34,77.05 101.09,74.31 101.09,64.58 101.62,64.05 101.62,63.75 102.05,63.31 102.43,63.31 106.32,59.43 v1(106.65,59.43)
  IN1 w0.61: v3(70.12,63.9) 74.32,63.9 76.83,66.41 80.31,66.41 v3(80.54,66.64) 80.67,66.64 83.74,69.72 v1(83.74,70.84)
  IN3 w0.254: v1(283.71,85.69) 283.71,86.34 283.4,86.66 283.17,86.66 280.21,89.62 208.11,89.62 206.24,91.49 201.53,91.49 198.43,88.39 198.43,79.83 197.19,78.6 194.01,78.6 190.07,74.66 178.56,74.66 176.97,73.07 176.97,70.82 174.54,68.39 166.44,68.39 164.74,66.69 164.74,63.58 163.91,62.74 156.8,62.74 155.48,61.43 153.39,61.43 151.43,59.47 147.25,59.47 146.21,60.51 137.64,60.51 136.28,61.87 127.06,61.87 124.53,59.34 106.74,59.34 v1(106.65,59.43)
  BOTTOM w0.203: PU9.3 81.48,69.37 81.55,69.29 PC151.1 81.11,68.43 80.91,68.22 80.91,67.56 80.54,67.19 v3(80.54,66.64) ; v1(83.74,70.84) 83.83,70.84 84.6,70.07 PR186.1
5V_HSMBCK: length 3.7
  TOP w0.14: v1(229.86,166.06) 229.66,165.85 228.01,165.85 227.72,166.15 D8559.1
  TOP w0.305: R21010.2 227.73,166.51 D8559.1
5V_HSMBDT: length 2.1
  TOP w0.14: R21011.2 229.37,167.47 229.84,167.94 v1(229.94,167.94)
  TOP w0.381: D8559.2 229,166.51 R21011.2
12VL_EN: length 180.8
  TOP w0.14: v1(196.54,69.82) 196.54,68.88 196.67,68.75 199.41,68.75 v1(199.71,68.44) ; PR67225.1 344.44,92.52 343.38,92.52 342.21,91.36 v1(342.21,90.8)
  IN1 w0.089: v1(281.17,81.09) 285.09,81.09 286.77,82.77 307.23,82.77 307.65,82.36 328.82,82.36 330.72,84.26 331.32,84.26 332.12,85.05 333.78,85.05 335.19,86.45 336.37,86.45 337.43,87.52 338.43,87.52 340.71,89.8 340.84,89.8 341.83,90.8 v1(342.21,90.8)
  IN3 w0.079: v1(281.17,81.09) 280.72,81.09 277.26,84.55 211.65,84.55 206.09,78.99 204.87,78.99 202.72,76.84 202.72,75.16 200.97,73.4 200.97,72.67 199.11,70.81 197.53,70.81 v1(196.54,69.82)
  IN5 w0.089: v1(199.71,68.44) 199.7,68.44 197.17,65.92 197.17,65.32 195.62,63.76 195.62,63.39 194.61,62.38 194.61,59.68 v1(195.4,58.89)
  BOTTOM w0.14: R67313.1 194.53,59.53 195.17,58.89 v1(195.4,58.89)
51211V_DRVH: length 14
  TOP w0.254: PU9015.9 237.92,160.27 v3(237.66,160.01)
  TOP w0.508: v1(227.27,156.4) 227.29,156.42 PQ9053.1
  BOTTOM w0.508: v3(237.66,160.01) 237.47,160.01 237.26,159.8 232.06,159.8 228.67,156.4 v1(227.27,156.4)
51211V_DRVL: length 11.9
  TOP w0.508: PQ9053.8 v1(227.48,162.05)
  BOTTOM w0.508: v1(238.55,162.53) 238.42,162.4 236.82,162.4 236.58,162.15 227.58,162.15 v1(227.48,162.05)
51211V_EN: length 7.1
  TOP w0.14: PR114.1 247.14,159.81 v1(247.21,159.88)
  TOP w0.178: PU9015.3 242.45,160.77 242.73,161.05 245.15,161.05 245.37,160.82 PR266.2
  TOP w0.254: PR114.1 246.36,159.98 246.03,160.31 245.84,160.31 245.68,160.46 245.68,160.65 245.58,160.76 PR266.2 PR115.1
51211V_FB: length 2.6
  TOP w0.178: PU9015.4 242.45,161.27 242.71,161.54 PR267.1 PR67003.1
51211V_SW: length 16.7
  TOP w0.254: PC222.1 237.31,163.5 237.31,162.27 237.02,161.98 237.02,161.37 v3(237.61,160.77) PU9015.8
  BOTTOM w0.508: v3(237.61,160.77) 237.05,160.77 236.72,160.44 229.05,160.44 227.53,158.92 v3(226.99,158.92)
  vias: v1(223.41,164.13)
51211V_TRIP: length 1.6
  TOP w0.178: PR265.2 243.12,160.54 242.85,160.27 PU9015.2
51211V_TST: length 1.9
  TOP w0.254: PU9015.5 241.98,161.87 241.07,162.77 PR268.2
51211V_VBST:
  vias: v1(237.74,159.15)
+1.0V_PWRGD_G1: length 4.6
  TOP w0.14: Q7842.2 295.83,81.4 v1(295.88,81.35)
  BOTTOM w0.14: v1(295.88,81.35) 296.29,81.76 C94818.1 296.76,81.76 296.78,81.75 R21173.1 297.2,81.38 R21170.2 296.4,80.59 v1(295.73,80.59)
+1.0V_PWRGD_G2: length 4.9
  TOP w0.14: Q7842.3 295.68,83.43 v1(295.02,84.09)
  BOTTOM w0.14: R21165.2 v1(293.03,83.15) 293.76,83.15 294.4,83.79 Q7840.2 294.85,84.25 v1(295.02,84.09)
+1.2VSUS: length 247.2
  TOP w0.216: U41.L6 231.57,107.76 231.07,107.76 230.96,107.66 U41.K6 ; U41.T6 235.75,107.66 v1(235.4,107.3) 235.04,107.66 U41.R6
  TOP w0.229: v1(238.95,103.25) 239.1,103.25 239.64,103.8 239.64,107.25 239.24,107.66 U41.AA6
  TOP w0.254: U41.AJ12 246.39,111.57 v1(246.66,111.3) 247.04,110.92 U41.AL11 ; CN2062.33 270.19,75.95 v1(269.16,76.98) ; CN2062.199 226.69,75.76 226.66,75.79 226.66,76.39 v1(227.17,76.9) ; CN2062.241 216.18,76.22 v1(216.26,76.29) ; U41.J5 229.92,107.01 v1(229.6,106.69) ; CN2063.33 270.19,63.38 v1(269.11,64.46) ; v1(243.84,107.34) 243.62,107.13 243.54,107.13 U41.AF5 ; v1(243.84,107.34) 243.53,107.66 U41.AF6 ; v1(243.84,107.34) 243.97,107.34 U41.AG5 244.27,107.01 243.96,106.7 v1(243.85,106.7) ; v1(242.49,65.02) 242.93,65.46 CN2062.142 ; U41.AY6 254.22,107.66 v1(253.91,107.34) 253.6,107.66 U41.AW6 ; CN2062.163 235.69,75.79 235.76,75.86 235.76,76.37 v1(235.22,76.9) ; v1(237.1,77.05) 237.83,76.33 237.83,76.08 238.18,75.72 CN2062.153 ; v1(239.69,55.24) 239.44,54.98 CN2063.148 ; v1(216.18,63.08) CN2063.241 ; v1(248.97,76.17) 249.18,75.95 CN2062.117 ; v1(250.92,55.57) 250.44,55.08 CN2063.112 ; v1(258.85,77) 259.69,76.17 CN2062.75 ; CN2063.135 244.69,63 244.14,63.54 v1(243.68,63.54) ; v1(242.34,55.57) 242.93,54.97 CN2063.142 ; v1(221.43,55.03) CN2063.220 ; CN2063.117 249.18,62.84 v1(248.91,63.11) ; CN2062.178 231.94,65.26 v1(232.61,64.58) ; v1(242.41,63.64) 243.18,62.87 CN2063.141 ; v1(250.62,65.19) 250.44,65.37 CN2062.112 ; v1(246.91,55.67) 247.13,55.67 247.57,55.23 247.57,54.8 247.44,54.67 CN2063.124 ; CN2062.123 247.69,76.13 248.48,76.93 v1(248.97,76.93) ; v1(231.44,55.92) 231.94,55.43 CN2063.178 ; v1(227.15,63.87) 226.66,63.39 226.66,62.81 226.69,62.78 CN2063.199 ; CN2062.129 246.18,76.17 245.27,77.08 v1(243.83,77.08) ; v1(276.4,63.75) 275.44,64.71 CN2062.12 ; v1(242.11,111.27) 242.41,111.57 U41.AE12 ; v1(237.13,64.3) 237.94,65.11 CN2062.154 ; U41.K6 230.78,107.66 v1(230.42,107.3) 230.07,107.66 U41.J6 ; v1(242.59,78.17) 243.18,77.58 CN2062.141 ; U41.AR12 250.93,111.57 v1(251.23,111.26) 251.53,111.57 U41.AT12 ; v1(222.14,64.43) 221.43,65.14 CN2062.220 ; CN2063.12 v1(275.44,55.24) ; U41.AR6 250.89,107.66 v1(250.53,107.3) 250.18,107.66 U41.AP6 250.12,108.06 U41.AP7 ; U41.K12 230.74,111.84 v1(230.96,112.07) 231.08,112.07 U41.L12 ; CN2063.153 238.18,63.94 238.86,64.61 v1(239.44,64.61) 239.44,64.61 v1(239.44,65.26) CN2062.148 ; U41.AG9 244.23,109.62 v1(243.93,109.92) ; v1(248.93,54.9) CN2063.118 ; v1(239.44,63.95) 239.67,63.95 239.97,63.64 239.97,63.02 239.69,62.73 CN2063.147 ; CN2063.129 246.18,62.72 247.37,63.9 v1(247.37,64.51) 246.98,64.51 245.93,65.56 CN2062.130 ; v1(235.1,63.75) 235.3,63.75 235.69,63.36 CN2063.163 ; v1(248.94,77.64) 250.06,77.64 250.69,77.01 CN2062.111 ; CN2062.160 236.44,64.26 v1(237.13,63.57) 236.69,63.12 CN2063.159 ; CN2063.160 236.44,52.53 236.61,52.35 237.69,52.35 237.94,52.59 CN2063.154 237.94,55.66 v1(238.12,55.84) ; CN2062.159 236.69,75.9 v1(237.08,76.29) ; v1(243.66,65.02) 243.96,65.02 244.44,65.49 CN2062.136 ; v1(248.84,64.43) 247.69,63.28 CN2063.123 ; CN2063.54 264.93,55.62 v1(264.61,55.95) ; CN2062.147 239.69,76.53 v1(239.57,76.65) ; v1(243.89,76.32) 244.47,76.32 244.69,76.1 CN2062.135 ; v1(258.95,63.8) 259.69,63.06 CN2063.75 ; v1(245.44,56.36) 245.93,55.87 CN2063.130 ; v1(253.33,64.23) 254.44,65.33 CN2062.96 ; v1(250.69,63.08) CN2063.111 ; v1(263.82,64.1) 264.93,65.21 CN2062.54 ; U41.AA6 U41.W6 ; CN2062.124 247.44,65.24 v1(247.37,65.17) ; v1(254.76,55.82) 254.44,55.5 CN2063.96 ; v1(244.9,55.59) 244.88,55.59 244.37,55.08 244.37,54.73 244.44,54.66 CN2063.136 ; CN2062.118 248.93,65.35 v1(248.83,65.25)
  TOP w0.508: R20821.2 272.27,101.75 v1(273.17,100.85) ; R21108.1 323.5,57.66 v1(323.13,57.29) ; R21411.1 269.79,108.74 v1(269.63,108.57) 269.63,109.65 R21410.1
  IN3 w0.508: v1(323.13,57.29) 322.86,57.02 320.19,57.02 319.68,57.53 319.68,58.36 319.27,58.77 318.46,58.77 317.37,59.86 313.28,59.86 312.92,59.5 312.2,59.5 311.28,60.42 311.01,60.42 310.79,60.64 307.77,60.64 307.23,61.18 307.23,61.67 306.44,62.46 300.22,62.46 299.72,62.96 293.39,62.96 292.13,64.22 285.65,64.22 282.09,67.78 v1(279.93,67.78)
  BOTTOM w0.203: 181.67,79.96 181.45,80.19 PU2001.19
  BOTTOM w0.254: 200.93,87.34 199.54,87.34 198.06,85.87 198.06,79.65 197.23,78.81 190.09,78.81 188.84,77.56 184.55,77.56 182.94,79.18 PC2038.1 182.24,79.39 181.67,79.96 ; C94879.1 237.1,64.28 v1(237.13,64.3) ; C94868.1 238.81,63.6 239.16,63.95 v1(239.44,63.95) ; v1(235.1,63.75) C94870.1
  BOTTOM w0.381: R21432.2 239.44,65.92 v1(239.44,65.26)
  BOTTOM w0.508: v1(279.93,67.78) 279.67,68.04 278.53,68.04
  vias: v1(168.5,63.11) v3(167.71,64.81) v3(167.81,64.05) v3(167.89,65.57) v3(168.47,64.91) v3(168.57,64.15) v3(169.03,65.52) v3(169.23,64.79) v3(169.87,65.47) v3(202.28,89.3) v3(202.28,87.77) v3(203.04,89.3) v3(203.04,87.77) v3(203.8,89.3) v3(203.8,87.77) v3(204.57,89.3) v3(204.57,87.77) v3(205.33,89.3) v3(205.33,87.77) v3(206.09,89.3) v3(206.09,87.77)
+1.8V: length 469.7
  TOP w0.203: U13157.17 29.82,41.38 v1(29.63,41.58) ; v1(124.48,117.29) 124.48,116.68 123.86,116.06 U13119.5
  TOP w0.508: v1(112.42,65.12) 111.65,64.35 PR9227.1
  IN1 w0.508: v1(118.89,66.89) 118.89,73.55 120.97,75.63 120.97,76.69 121.6,77.31 124.64,77.31 127.15,79.83 127.15,83.49 127.9,84.23 127.9,87.45 129.65,89.21 129.65,96.17 123.21,102.61 123.21,109.44 124.06,110.29 124.06,111.76 123.57,112.26 123.57,113.15 122.26,114.46 122.26,115.85 123.69,117.29 v1(124.48,117.29) ; 118.64,64.23 120.26,64.23 122.09,62.41 127.24,62.41 128.4,61.25 v1(129.2,61.25)
  IN3 w0.254: 31.21,45.83 31.21,43.4 32.56,42.05 32.56,41.65 32.3,41.39 29.92,41.39 29.73,41.58 v1(29.63,41.58)
  IN3 w0.508: 31.21,45.83 31.31,45.93 31.31,49.26 31.97,49.93 31.97,51.2 32.58,51.81 33.32,51.81 36.38,54.87 36.38,55.58 37.1,56.3 v1(39.01,56.3) ; v1(129.2,61.25) 129.2,60.77 129.74,60.24 130.27,60.24 131.83,58.68 145.73,58.68 146.16,58.26 151.94,58.26 153.87,60.19 157.61,60.19 158.85,61.43 165.42,61.43 167.05,63.06 167.05,66.03 168.19,67.17 175.03,67.17 177.41,69.56 181.72,69.56 182.43,70.27 190.02,70.27 193.83,74.08 195.07,74.08 197.65,76.67 198.32,76.67 201.83,80.18 203.03,80.18 205.13,82.28 206.52,82.28 211.2,86.96 278.31,86.96 280.11,85.16 281.4,85.16 283.33,83.23 284.7,83.23 285.88,82.05 288.13,82.05 288.71,81.47 293.65,81.47 294.42,80.71 298.46,80.71 299,80.17 300.08,80.17 301.92,78.32 304.62,78.32 304.81,78.52 307.24,78.52 308.02,77.74 309.57,77.74 310.23,78.4 314.4,78.4 316.56,80.57 333.57,80.57 333.83,80.31 336.87,80.31 337.94,79.24 337.94,77.16 338.98,76.12 342.45,76.12 344.3,77.96 352.44,77.96 354.16,76.24 v1(354.63,76.24)
  IN4 w0.254: v1(29.63,41.58) 29.73,41.58 29.89,41.42 32.33,41.42 32.57,41.66 32.57,42.02 31.31,43.28 31.31,46.62
  IN4 w0.508: v1(23.41,36.77) 23.41,37.53 23.64,37.76 23.64,41.82 25.73,43.91 26.24,43.91 27.21,44.88 27.21,44.89 27.56,45.24 27.57,45.24 27.84,45.51 28.37,45.51 29.48,46.62 31.31,46.62 ; v1(39.01,56.3) 39.01,58.13 39.59,58.72 39.59,59.71 40.84,60.95 42.62,60.95 43.33,61.66 50.49,61.66 50.71,61.88 51.8,61.88 53.11,60.57 55.19,60.57 57.18,58.59 60.59,58.59 61.91,57.27 62.72,57.27 63.37,56.62 64.05,56.62 64.7,57.27 66.83,57.27 67.97,58.41 67.97,63.31 71.44,66.79 77.37,66.79 78.92,68.35 86.37,68.35 89.05,65.66 91.55,65.66 94.25,62.96 98.65,62.96 99.44,63.74 100.2,63.74 100.59,63.35 103.84,63.35 104.29,62.91 106.14,62.91 107.11,63.87 111.17,63.87 v1(112.42,65.12)
  BOTTOM w0.508: v1(23.41,36.77) 23.27,36.63 L4273.2 ; R20949.1 355.24,76.62 354.86,76.24 v1(354.63,76.24)
  vias: v1(118.13,66.89)
