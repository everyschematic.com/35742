# Allegro board DAZGLMB1ED0 dazglmb1ed0-d-ver a-165 (.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CPU_PCI_BCLKP: length 158.1
  TOP w0.081: U41.D35 226.72,129.06 226.51,128.85 226.51,128.78 226.12,128.39 224.81,128.39 224.62,128.58 223.98,128.58 223.73,128.83 223.73,128.97 223.45,129.25 v1(223.44,129.25)
  TOP w0.102: 296.28,50.66 296.3,50.68 296.3,50.72 296.51,50.94 296.51,51.71 295.93,52.29 295.93,52.59 295.96,52.62 295.96,52.86 295.8,53.02 295.8,53.05 295.59,53.26 U13113.J2
  TOP w0.14: v1(289.38,53.05) 289.38,51.76 290.1,51.03 290.76,51.03 291.32,50.47 296.1,50.47 296.28,50.66
  IN5 w0.089: v1(223.44,129.25) 223.44,128.44 223.23,128.23 222.53,128.23 220.61,126.31 220.61,116.84 218.12,114.35 215.66,114.35 211.74,110.42 211.74,105.82 211.23,105.32 211.23,103.73 212.08,102.88 212.08,101.14 222.66,90.56 265.43,90.56 278.74,77.25 278.74,73.31 280.5,71.56 280.5,66.63 281,66.14 281,60.56 284.19,57.37 285.14,57.37 286.63,55.88 287.55,55.88 287.96,55.47 287.96,54.99 289.38,53.58 v1(289.38,53.05)
CPU_PLTRST#R: length 137.3
  TOP w0.14: R21191.2 304.57,47.95 v1(304.54,47.92) ; U41.BP35 264.98,128.57 265.61,128.57 265.69,128.49 266.22,128.49 266.35,128.62 266.59,128.62 267.48,129.51 267.48,132.43 268.09,133.04 269.08,133.04 269.36,132.76 R542.2 R541.2 269.92,133.07 v1(270.02,133.16)
  IN1 w0.089: v1(304.54,47.92) 305.29,48.67 305.29,50.68 304.82,51.15 304.82,51.5 305.25,51.93 305.58,51.93 306.83,50.69 307.16,50.69 307.79,51.32 307.79,53.36 308.25,53.81 309.52,53.81 309.84,54.13 309.84,55.27 309.52,55.59 309.14,55.59 308.25,56.48 307.94,56.48 307.56,56.86 307.56,57.8 307.05,58.31 307.05,58.65 306.5,59.19 305.84,59.19 302.66,62.37 302.66,65.62 302.41,65.88 300.12,65.88 299.49,66.51 284.39,66.51 283.57,67.33 283.57,71.01 280.42,74.16 280.42,78.48 277.89,81.02 277.89,95.59 275.48,98 275.48,101.12 273.98,102.61 273.98,105.61 273.24,106.36 273.24,107.05 271.44,108.85 271.44,109.59 269.5,111.53 269.5,111.97 265.32,116.14 265.32,123.54 266.54,124.75 270.04,124.75 270.95,125.66 270.95,126.91 271.34,127.3 271.34,127.95 271.85,128.46 271.85,129.99 270.91,130.93 270.91,131.23 270.02,132.12 v1(270.02,133.16)
CPU_THERMDA: length 254.6
  TOP w0.14: U13092.2 359.04,43.27 359.28,43.5 v1(359.28,44.92) 359.28,45.28 v1(359.94,45.94) ; Q7834.2 220.09,138.27 220.37,138.55 Q7834.3 221.1,137.68 v1(221.28,137.51)
  IN3 w0.079: v1(359.94,45.94) 359.94,45.18 360.31,44.81 360.85,44.81 361.03,44.99 361.03,49.99 359.64,51.38 359.64,54.57 359.96,54.89 359.96,58.15 359.27,58.84 357.4,58.84 356.89,59.35 356.14,59.35 355.9,59.59 353.02,59.59 352.45,60.16 351.71,60.16 350.9,60.98 342.59,60.98 342.03,60.42 333.78,60.42 332.66,59.3 332.16,59.3 330.6,57.74 330.6,56.86 329.16,55.42 326.76,55.42 326.37,55.04 323.41,55.04 322.89,55.55 318.14,55.55 317.93,55.34 316.05,55.34 314.88,54.17 313.21,54.17 313.04,54 312.86,54 312.28,53.42 311.05,53.42 310.95,53.52 308.97,53.52 308.49,53.99 302.44,53.99 301.85,54.58 301.13,54.58 300.65,55.06 299.87,55.06 299.29,54.48 298.44,54.48 298.05,54.1 294.66,54.1 294.11,53.54 293.49,53.54 291.64,55.39 289.54,55.39 288.15,56.79 287.07,56.79 286.74,57.11 283.13,57.11 279.44,60.8 279.42,60.8 v1(279.42,60.8)
  IN5 w0.089: v1(221.28,137.51) 221.81,136.97 221.81,135.47 222.35,134.94 222.35,134.15 223.07,133.43 223.07,130.27 219.54,126.75 219.54,117.28 217.68,115.42 215.22,115.42 209.14,109.34 209.14,105.35 210.11,104.39 210.11,103.21 211.01,102.31 211.01,100.7 223.02,88.69 265.79,88.69 277.6,76.89 277.6,71.73 277.52,71.65 277.52,67.98 279.92,65.58 279.92,61.29 v1(279.42,60.8)
  BOTTOM w0.14: v1(359.94,45.94) 359.56,45.94 359.09,45.47 C94774.1
CPU_THERMDC: length 249.2
  TOP w0.14: Q7834.1 222.12,137.41 v1(222.3,137.58) ; v1(360.52,45.23) 359.87,44.58 359.87,43.33 359.16,42.62 U13092.3
  IN3 w0.079: v1(279.42,60.11) 282.88,56.65 286.44,56.65 286.79,56.3 287.98,56.3 289.35,54.93 291.45,54.93 293.3,53.08 294.3,53.08 294.85,53.64 298.24,53.64 298.63,54.02 301.76,54.02 302.25,53.53 308.3,53.53 308.78,53.06 310.77,53.06 310.87,52.96 312.47,52.96 313.05,53.54 313.24,53.54 313.41,53.71 315.07,53.71 316.24,54.88 318.12,54.88 318.33,55.09 322.39,55.09 323.11,54.37 323.93,54.37 324.53,53.77 325.68,53.77 325.9,53.99 327.97,53.99 328.19,53.77 331.91,53.77 332.06,53.63 334.18,53.63 335.06,54.5 339.72,54.5 341.65,56.43 341.65,58.13 343.31,59.79 347.02,59.79 347.74,60.52 348.77,60.52 349.32,59.97 351.25,59.97 351.54,59.68 352.17,59.68 352.72,59.13 355.71,59.13 356.01,58.83 356.76,58.83 357.21,58.38 358.4,58.38 359.18,57.6 359.18,51.19 360.52,49.85 v1(360.52,45.23)
  IN5 w0.089: v1(222.3,137.58) 222.3,135.83 222.83,135.3 222.83,134.36 223.54,133.65 223.54,130.08 220.01,126.55 220.01,117.09 217.87,114.95 215.42,114.95 209.61,109.15 209.61,105.55 210.58,104.58 210.58,103.4 211.48,102.5 211.48,100.89 223.22,89.16 265.99,89.16 278.07,77.08 278.07,71.54 277.99,71.46 277.99,68.17 280.39,65.78 280.39,61.08 v1(279.42,60.11)
  BOTTOM w0.14: C94774.2 360.47,45.18 v1(360.52,45.23)
CPU_WIGIG_DP_AUXN: length 251.4
  TOP w0.14: U41.E27 227.86,123.61 v1(228.18,123.29) ; v1(47.37,70.32) 47.95,70.32 C95888.1
  IN1 w0.089: v1(228.18,123.29) 227.79,123.68 226.44,123.68 224.95,122.18 224.95,121.17 223.67,119.89 223.67,111.33 222.67,110.33 222.67,107.64 222.13,107.11 222.13,105.54 221.37,104.78 221.37,104.03 220.89,103.55 220.89,103.54 217.1,99.75 217.1,96.1 210.01,89.01 210.01,73.7 208.08,71.77 208.08,70.87 205.19,67.98 198.06,67.98 196.14,66.06 195.59,66.06 193.84,64.3 193.84,63.67 193.42,63.25 191.1,63.25 190.36,62.52 187.81,62.52 187.12,61.83 183.76,61.83 183.1,62.49 178.39,62.49 177.5,61.6 173.2,61.6 170.61,59.01 168.49,59.01 165.6,56.12 143.92,56.12 143.14,55.34 132.04,55.34 131.73,55.02 120.57,55.02 120.56,55.02 116.31,55.02 115.64,55.69 112.05,55.69 110.57,54.21 97.5,54.21 95.2,51.91 83.29,51.91 81.89,50.51 78.3,50.51 77.77,49.98 74,49.98 73.86,50.11 69.77,50.11 68.27,51.6 67.41,51.6 67.03,51.98 67.03,52.63 66.19,53.48 66.19,55.17 65.69,55.66 65.69,57.3 65.17,57.83 65.17,59.01 60.62,63.56 60.62,65.08 59.67,66.03 54.37,66.03 52.53,64.19 48.86,64.19 47.72,65.33 47.72,68.33 48.03,68.64 48.03,69.79 47.73,70.09 47.6,70.09 v1(47.37,70.32)
CPU_WIGIG_DP_AUXP: length 251.4
  TOP w0.14: v1(47.34,69.64) 47.76,70.06 47.96,70.06 48.11,69.91 C95889.1 ; U41.D27 227.21,123.61 v1(227.53,123.29)
  IN1 w0.089: v1(227.53,123.29) 227.14,123.29 226.92,123.51 226.51,123.51 225.11,122.11 225.11,121.1 223.83,119.82 223.83,111.26 222.84,110.26 222.84,107.57 222.3,107.04 222.3,105.47 221.54,104.71 221.54,103.96 221.06,103.48 221.06,103.47 217.27,99.68 217.27,96.03 210.18,88.94 210.18,73.63 208.25,71.7 208.25,70.8 205.26,67.81 198.13,67.81 196.21,65.89 195.66,65.89 194,64.23 194,63.6 193.49,63.08 191.17,63.08 190.43,62.35 187.88,62.35 187.19,61.66 183.69,61.66 183.03,62.32 178.46,62.32 177.57,61.43 173.27,61.43 170.68,58.84 168.56,58.84 165.67,55.95 143.99,55.95 143.21,55.17 132.11,55.17 131.8,54.86 120.6,54.86 120.6,54.85 116.24,54.85 115.57,55.53 112.12,55.53 110.64,54.04 97.57,54.04 95.27,51.74 83.36,51.74 81.96,50.34 78.37,50.34 77.84,49.81 73.93,49.81 73.79,49.94 69.7,49.94 68.2,51.44 67.34,51.44 66.87,51.91 66.87,52.56 66.02,53.41 66.02,55.1 65.53,55.59 65.53,57.23 65,57.76 65,58.94 60.45,63.49 60.45,65.01 59.6,65.86 54.44,65.86 52.6,64.02 48.79,64.02 47.55,65.26 47.55,68.4 47.86,68.71 47.86,69.72 47.66,69.92 47.43,69.92 47.34,69.83 v1(47.34,69.64)
CPU_WIGIG_DP_HPD: length 311
  IN3 w0.079: v1(46.63,49.04) 46.93,48.73 47.49,48.73 47.9,49.14 48.86,49.14 49.27,49.54 56.95,49.54 57.91,48.58 59.32,48.58 60.07,47.84 60.35,47.84 61.13,47.05 61.13,45.69 61.84,44.97 64.06,44.97 65.25,43.79 65.25,43.43 65.65,43.02 66.21,43.02 66.77,43.58 67.2,43.58 67.53,43.25 76.93,43.25 77.26,43.58 79.13,43.58 79.8,44.25 88.44,44.25 89.38,45.2 90.14,45.2 93.24,48.29 98,48.29 98.47,48.76 171.92,48.76 178.9,55.74 179.97,55.74 180.41,56.19 183.13,56.19 183.6,55.72 191.96,55.72 192.27,55.41 192.84,55.41 194.19,54.06 195.31,54.06 195.81,53.56 198.2,53.56 198.76,53 199.58,53 199.87,52.71 202.75,52.71 203.09,53.05 205.58,53.05 205.96,53.43 205.96,54.96 206.67,55.67 207.59,55.67 207.97,55.29 207.97,54.98 209.52,53.43 225.9,53.43 226.11,53.64 270.07,53.64 272.02,51.69 286.31,51.69 286.6,51.98 289.4,51.98 290.22,51.16 291.7,51.16 292.31,50.54 297.13,50.54 297.38,50.79 298.75,50.79 299.44,51.47 301.34,51.47 301.54,51.68 302.64,51.68 303.47,52.52 307.29,52.52 309.39,50.41 v1(310.69,50.41)
  BOTTOM w0.14: R22050.1 310.92,49.11 310.92,50 310.76,50.16 310.76,50.33 v1(310.69,50.41) ; v1(46.63,49.04) 46.32,49.35 46.32,49.92 48.37,51.97 50.64,51.97 51.08,52.41 52.49,52.41 53.79,53.71 53.79,55.93 55.55,57.69 55.55,64.44 56.86,65.74 R22000.2
CPU_WIGIG_DP_ML0N: length 256.8
  TOP w0.14: v1(49.3,66.72) 49.35,66.77 C95880.1 ; v1(230.53,130.81) 230.96,130.38 U41.K37
  IN1 w0.089: v1(49.3,66.72) 49.47,66.54 50.03,66.54 50.45,66.96 50.45,68.41 51.26,69.22 52.25,69.22 52.69,69.66 56.44,69.66 56.79,70.01 59.47,70.01 59.87,69.61 59.87,69.09 62.6,66.35 64.98,66.35 68.34,63 68.34,60.23 68.93,59.65 68.93,55.78 69.1,55.61 69.1,53.57 70.12,52.54 72.98,52.54 73.14,52.38 81.34,52.38 82.83,53.87 93.36,53.87 96.12,56.63 107.91,56.63 108.76,57.47 111.52,57.47 113.4,59.35 122.71,59.35 123.61,58.45 126.7,58.45 127.55,57.6 133.6,57.6 133.85,57.34 142.38,57.34 142.99,57.95 145.63,57.95 146.11,58.44 151.84,58.44 153.42,60.02 157.66,60.02 159.71,62.07 167.41,62.07 167.76,62.42 170.62,62.42 174.18,65.98 178.82,65.98 180.04,67.2 193.78,67.2 194.04,67.46 194.59,67.46 195.34,68.21 195.88,68.21 198.4,70.73 201.34,70.73 202.46,71.85 205.61,71.85 206.27,72.5 206.44,72.5 208.08,74.15 208.08,90.36 209.78,92.06 209.78,97.16 211.73,99.1 211.73,102.89 211.1,103.52 211.1,105.09 211.74,105.72 211.74,109.42 216.11,113.79 218.04,113.79 221.55,117.31 221.55,127.21 222.52,128.18 225.18,128.18 227.77,130.78 229.56,130.78 229.82,130.51 230.24,130.51 v1(230.53,130.81)
CPU_WIGIG_DP_ML0P: length 256.8
  TOP w0.14: U41.K36 230.94,129.73 v1(230.62,130.06) ; C95881.1 49.5,65.88 v1(49.32,66.06)
  IN1 w0.089: v1(49.32,66.06) 49.64,66.37 50.1,66.37 50.62,66.89 50.62,68.34 51.33,69.05 52.32,69.05 52.76,69.5 56.51,69.5 56.86,69.84 59.41,69.84 59.7,69.55 59.7,69.02 62.53,66.18 64.91,66.18 68.17,62.93 68.17,60.16 68.76,59.58 68.76,55.71 68.93,55.54 68.93,53.5 70.05,52.38 72.91,52.38 73.07,52.21 81.41,52.21 82.9,53.7 93.43,53.7 96.19,56.46 107.98,56.46 108.83,57.31 111.59,57.31 113.47,59.18 122.64,59.18 123.54,58.28 126.63,58.28 127.49,57.43 133.53,57.43 133.78,57.18 142.45,57.18 143.06,57.79 145.7,57.79 146.18,58.27 151.91,58.27 153.49,59.86 157.73,59.86 159.77,61.91 167.48,61.91 167.83,62.26 170.69,62.26 174.25,65.81 178.89,65.81 180.11,67.03 193.85,67.03 194.11,67.3 194.66,67.3 195.41,68.05 195.95,68.05 198.47,70.57 201.41,70.57 202.53,71.68 205.68,71.68 206.34,72.34 206.51,72.34 208.25,74.08 208.25,90.29 209.95,91.99 209.95,97.09 211.9,99.03 211.9,102.96 211.27,103.59 211.27,105.02 211.9,105.65 211.9,109.35 216.18,113.63 218.11,113.63 221.72,117.24 221.72,127.14 222.59,128.02 225.25,128.02 227.84,130.61 229.49,130.61 229.75,130.34 230.33,130.34 v1(230.62,130.06)
CPU_WIGIG_DP_ML1N: length 257.7
  TOP w0.14: U41.J34 230.16,128.43 v1(229.83,128.76) ; v1(49.3,68.32) 49.49,68.13 49.84,68.13 49.96,68.24 C95882.1
  IN1 w0.089: v1(229.83,128.76) 229.61,128.53 229.61,128.15 229.2,127.74 229.2,127.06 228.25,126.11 224.3,126.11 223.31,125.13 223.31,124.73 222.87,124.29 222.87,116.8 218.57,112.5 216.65,112.5 213.07,108.93 213.07,104.95 213.2,104.82 213.2,103.88 213.76,103.32 213.76,93.68 209.62,89.54 209.62,73.86 207.67,71.91 207.67,71.08 205.03,68.44 201.22,68.44 200.8,68.86 198.35,68.86 195.96,66.46 195.44,66.46 193.26,64.29 191.58,64.29 190.28,62.98 183.76,62.98 183.02,63.73 181.62,63.73 181.18,64.16 180.33,64.16 179.65,63.48 174.52,63.48 170.53,59.49 168.25,59.49 166.63,57.86 164.11,57.86 162.76,56.51 143.71,56.51 142.98,55.78 131.59,55.78 131.28,55.48 127.43,55.48 126.59,56.31 118.77,56.31 118.59,56.14 111.59,56.14 110.13,54.68 97.24,54.68 95.07,52.5 83.33,52.5 81.73,50.9 77.98,50.9 77.45,50.37 74.57,50.37 74.3,50.64 70.07,50.64 67.3,53.41 67.3,55.16 66.19,56.27 66.19,57.76 65.96,57.99 65.96,58.78 62.11,62.63 62.11,63.27 61.08,64.31 61.08,65.81 59.58,67.3 54.55,67.3 52.12,64.86 50.26,64.86 49.87,65.25 49.01,65.25 48.11,66.15 48.11,67.6 48.61,68.1 49.08,68.1 v1(49.3,68.32)
CPU_WIGIG_DP_ML1P: length 257.8
  TOP w0.14: v1(229.83,129.4) 230.15,129.08 U41.J35 ; v1(49.35,67.58) 49.35,67.68 49.52,67.86 49.76,67.86 C95883.1
  IN1 w0.089: v1(229.83,129.4) 229.66,129.4 229.44,129.18 229.44,128.22 229.03,127.81 229.03,127.13 228.18,126.28 224.23,126.28 223.14,125.2 223.14,124.8 222.7,124.36 222.7,116.87 218.5,112.67 216.58,112.67 212.9,108.99 212.9,104.88 213.03,104.75 213.03,103.81 213.59,103.25 213.59,93.75 209.45,89.61 209.45,73.93 207.5,71.98 207.5,71.15 204.96,68.61 201.29,68.61 200.87,69.03 198.28,69.03 195.89,66.63 195.37,66.63 193.19,64.46 191.51,64.46 190.21,63.15 183.83,63.15 183.09,63.89 181.68,63.89 181.25,64.33 180.26,64.33 179.58,63.65 174.45,63.65 170.46,59.66 168.18,59.66 166.56,58.03 164.04,58.03 162.69,56.68 143.64,56.68 142.91,55.95 131.52,55.95 131.21,55.64 127.5,55.64 126.66,56.48 118.7,56.48 118.52,56.3 111.52,56.3 110.06,54.85 97.17,54.85 95,52.67 83.26,52.67 81.66,51.07 77.91,51.07 77.38,50.54 74.64,50.54 74.37,50.81 70.14,50.81 67.47,53.48 67.47,55.23 66.36,56.34 66.36,57.83 66.13,58.06 66.13,58.85 62.28,62.7 62.28,63.34 61.24,64.38 61.24,65.88 59.65,67.47 54.48,67.47 52.05,65.03 50.33,65.03 49.94,65.42 49.08,65.42 48.28,66.22 48.28,67.53 48.68,67.93 49.26,67.93 49.35,67.84 v1(49.35,67.58)
CPU_WIGIG_DP_ML2N: length 246.9
  TOP w0.14: U41.H36 229.36,129.73 v1(229.04,129.41)
  IN1 w0.089: v1(229.04,129.41) 228.63,129.82 228.12,129.82 225.24,126.94 224.05,126.94 222.31,125.2 222.31,117.03 218.34,113.06 216.42,113.06 212.51,109.16 212.51,104.72 212.64,104.58 212.64,103.58 213.12,103.11 213.12,93.94 208.91,89.73 208.91,73.95 207.08,72.12 207.08,71.52 206.6,71.05 203.04,71.05 202,70.01 198.7,70.01 195.86,67.16 195.34,67.16 193.21,65.03 191.52,65.03 190.04,63.55 184.09,63.55 183.35,64.29 182.03,64.29 181.52,64.8 179.89,64.8 179.29,64.2 174.44,64.2 170.31,60.06 167.89,60.06 166.31,58.49 163.94,58.49 163.44,57.98 162.43,57.98 161.55,57.1 150.21,57.1 149.7,57.61 146.42,57.61 146.01,57.2 143.47,57.2 142.71,56.44 133.68,56.44 133.25,56.87 127.01,56.87 126.83,57.05 119.2,57.05 117.63,58.62 115.2,58.62 113.32,56.75 109.22,56.75 107.75,55.27 96.9,55.27 94.77,53.14 83.17,53.14 81.62,51.59 74.44,51.59 74.1,51.25 70.28,51.25 68.33,53.19 68.33,55.34 68.09,55.58 68.09,56.6 67.65,57.05 67.65,58.81 66.97,59.49 66.08,59.49 64.83,60.74 64.83,62.23 64.43,62.63 63.28,62.63 62.68,63.23 62.68,63.51 62.14,64.05 62.14,65.77 59.32,68.6 56.74,68.6 56.66,68.67 56.15,68.67 v1(55.9,68.42)
  BOTTOM w0.14: C95884.1 56.34,68.57 56.05,68.57 v1(55.9,68.42)
CPU_WIGIG_DP_ML2P: length 246.8
  TOP w0.14: v1(229.04,130.06) 229.36,130.38 U41.H37
  IN1 w0.089: v1(229.04,130.06) 228.69,130.06 228.63,129.99 228.05,129.99 225.17,127.11 223.98,127.11 222.14,125.27 222.14,117.1 218.27,113.23 216.35,113.23 212.34,109.23 212.34,104.65 212.47,104.52 212.47,103.51 212.95,103.04 212.95,94.01 208.74,89.8 208.74,74.02 206.91,72.19 206.91,71.59 206.53,71.21 202.97,71.21 201.93,70.17 198.63,70.17 195.79,67.33 195.27,67.33 193.14,65.19 191.45,65.19 189.97,63.71 184.16,63.71 183.42,64.46 182.1,64.46 181.59,64.96 179.82,64.96 179.22,64.36 174.38,64.36 170.24,60.23 167.82,60.23 166.24,58.66 163.88,58.66 163.37,58.15 162.36,58.15 161.48,57.27 150.28,57.27 149.77,57.78 146.35,57.78 145.94,57.37 143.4,57.37 142.64,56.61 133.75,56.61 133.32,57.04 127.08,57.04 126.9,57.22 119.27,57.22 117.7,58.79 115.13,58.79 113.25,56.91 109.16,56.91 107.68,55.44 96.83,55.44 94.7,53.31 83.1,53.31 81.55,51.76 74.37,51.76 74.03,51.42 70.35,51.42 68.5,53.26 68.5,55.41 68.26,55.65 68.26,56.67 67.81,57.12 67.81,58.88 67.04,59.66 66.15,59.66 64.99,60.81 64.99,62.3 64.5,62.79 63.35,62.79 62.84,63.3 62.84,63.58 62.31,64.12 62.31,65.84 59.39,68.76 56.81,68.76 56.73,68.84 56.14,68.84 v1(55.9,69.08)
  BOTTOM w0.14: C95908.1 56.3,68.84 56.14,68.84 v1(55.9,69.08)
CPU_WIGIG_DP_ML3N: length 252.3
  TOP w0.14: U41.J38 229.97,131.56 v1(229.86,131.66)
  IN1 w0.089: v1(55.24,70.35) 55.5,70.61 55.5,70.82 55.94,71.26 59.64,71.26 60.44,70.47 60.44,69.33 62.86,66.91 65.26,66.91 70.4,61.78 70.4,59.54 69.5,58.64 69.5,55.99 69.66,55.84 69.66,53.98 70.41,53.22 73.27,53.22 73.54,52.94 81.09,52.94 82.58,54.43 93.11,54.43 95.87,57.19 107.55,57.19 108.4,58.04 111.29,58.04 113.16,59.91 123.44,59.91 124.08,59.28 126.87,59.28 127.85,58.3 140.23,58.3 140.63,58.71 145.37,58.71 145.98,59.32 151.84,59.32 153.11,60.59 157.06,60.59 159.11,62.63 166.9,62.63 167.3,63.03 170.42,63.03 173.99,66.61 178.65,66.61 179.95,67.91 193.7,67.91 194.26,68.47 194.26,68.58 196.98,71.3 201.03,71.3 202.2,72.48 205.45,72.48 206.03,73.07 206.2,73.07 207.52,74.38 207.52,90.63 209.1,92.21 209.1,97.28 211.12,99.31 211.12,102.66 209.16,104.61 209.16,107.64 215.88,114.35 217.8,114.35 220.99,117.54 220.99,127.44 222.88,129.34 222.88,129.62 225.86,132.6 229.28,132.6 229.63,132.25 229.63,131.9 v1(229.86,131.66)
  BOTTOM w0.14: C95886.1 56.43,69.89 55.7,69.89 v1(55.24,70.35)
CPU_WIGIG_DP_ML3P: length 252.3
  TOP w0.14: U41.J37 230.06,130.38 229.59,130.85 229.59,131.28 v1(229.2,131.66)
  IN1 w0.089: v1(55.93,70.35) 55.67,70.61 55.67,70.75 56.01,71.1 59.57,71.1 60.27,70.4 60.27,69.26 62.79,66.75 65.19,66.75 70.23,61.71 70.23,59.6 69.34,58.71 69.34,55.93 69.49,55.77 69.49,53.91 70.34,53.05 73.2,53.05 73.47,52.78 81.16,52.78 82.64,54.26 93.18,54.26 95.94,57.02 107.62,57.02 108.47,57.87 111.36,57.87 113.23,59.74 123.38,59.74 124.01,59.11 126.8,59.11 127.78,58.13 140.3,58.13 140.7,58.54 145.44,58.54 146.04,59.15 151.91,59.15 153.18,60.42 157.13,60.42 159.18,62.47 166.97,62.47 167.37,62.87 170.49,62.87 174.06,66.44 178.72,66.44 180.02,67.74 193.76,67.74 194.42,68.4 194.42,68.51 197.05,71.14 201.1,71.14 202.27,72.32 205.52,72.32 206.1,72.9 206.27,72.9 207.69,74.31 207.69,90.57 209.27,92.14 209.27,97.21 211.29,99.24 211.29,102.73 209.33,104.68 209.33,107.57 215.95,114.19 217.87,114.19 221.16,117.47 221.16,127.37 223.05,129.27 223.05,129.55 225.93,132.43 229.21,132.43 229.46,132.18 229.46,131.92 v1(229.2,131.66)
  BOTTOM w0.14: C95887.1 56.44,70.39 56.34,70.29 55.98,70.29 v1(55.93,70.35)
CPU_WIGIG_MLDIR: length 309.9
  TOP w0.14: v1(283.2,86.2) 283.71,86.71 v1(284.3,86.71) 290.44,86.71 292.58,84.57 298.9,84.57 300.57,82.91 303.95,82.91 304.48,82.38 308.41,82.38 309.8,80.99 309.8,80.73 309.84,80.69 309.84,80.3 309.8,80.26 309.8,79.01 310,78.81 R67238.2
  IN3 w0.079: v1(283.2,86.2) 280.03,89.37 208.01,89.37 206.14,91.25 201.63,91.25 198.68,88.29 198.68,79.73 197.3,78.35 194.11,78.35 190.18,74.41 178.66,74.41 177.21,72.97 177.21,70.72 174.64,68.15 167.1,68.15 166.08,67.13 166.08,63.74 164.79,62.45 156.85,62.45 155.59,61.18 153.49,61.18 151.53,59.22 147.15,59.22 146.1,60.27 137.54,60.27 136.18,61.63 127.2,61.63 124.66,59.09 115.39,59.09 114.57,58.28 106.94,58.28 105.84,59.37 105.84,59.85 105.48,60.21 103.15,60.21 102.28,59.34 102.28,56.05 100.22,53.98 88.09,53.98 86.12,52.02 73.75,52.02 72.86,52.91 69.81,52.91 68.15,54.57 66.81,54.57 65.84,55.54 64.59,55.54 62.9,57.22 62.9,58.55 61.88,59.57 60.37,59.57 59.63,60.32 56.41,60.32 v1(54.3,62.42)
  BOTTOM w0.14: v1(54.3,62.42) 53.92,62.81 53.92,70.34 54.69,71.11 55.87,71.11 R22097.2
CPU_WIGIG_PCIE_RXN1: length 266.1
  TOP w0.14: U13113.E17 293.83,60.61 v2(294.38,60.06)
  IN1 w0.089: v1(61.64,58.51) 61.85,58.73 62.13,58.73 62.63,58.22 62.63,56.07 63.98,54.72 63.98,53 65.23,51.79 65.23,50.88 66.59,49.52 67.76,49.52 69.15,48.13 72.56,48.13 73.03,48.61 78.43,48.61 78.96,49.14 82.46,49.14 82.95,49.63 95.03,49.63 97.75,52.34 126.79,52.34 127.8,53.36 167.76,53.36 171.17,56.76 172.37,56.76 175.26,59.65 177.44,59.65 178.46,58.64 186.53,58.64 187.76,59.87 192.28,59.87 195.96,63.55 195.96,63.69 197.82,65.55 198.24,65.55 198.75,66.06 203.44,66.06 206.22,63.29 206.22,56.4 206.81,55.81 209.59,55.81 211.79,53.6 263.73,53.6 264.14,54.02 277.19,54.02 277.97,54.8 277.97,58.2 278.72,58.94 281.26,58.94 282.43,60.11 282.93,60.11 284.4,61.59 291.98,61.59 293.05,60.52 294.53,60.52 294.61,60.43 294.62,60.34 v2(294.38,60.06)
  BOTTOM w0.14: v1(61.64,58.51) 61.41,58.74 61.13,58.74 60.81,58.42 R21999.2
CPU_WIGIG_PCIE_RXP1: length 266.2
  TOP w0.14: U13113.G17 294.57,60.61 v2(295.07,60.11)
  IN1 w0.089: v1(61.64,59.17) 61.92,58.89 62.2,58.89 62.8,58.29 62.8,56.14 64.14,54.79 64.14,53.08 65.4,51.86 65.4,50.95 66.66,49.69 67.82,49.69 69.22,48.3 72.49,48.3 72.97,48.78 78.36,48.78 78.89,49.31 82.39,49.31 82.88,49.8 94.96,49.8 97.68,52.51 126.72,52.51 127.73,53.52 167.69,53.52 171.1,56.93 172.3,56.93 175.19,59.82 177.51,59.82 178.52,58.81 186.46,58.81 187.69,60.04 192.21,60.04 195.79,63.62 195.79,63.76 197.75,65.72 198.17,65.72 198.68,66.23 203.51,66.23 206.38,63.36 206.38,56.47 206.88,55.97 209.65,55.97 211.86,53.77 263.66,53.77 264.07,54.19 277.12,54.19 277.8,54.87 277.8,58.27 278.65,59.11 281.19,59.11 282.36,60.28 282.86,60.28 284.34,61.76 292.05,61.76 293.12,60.69 294.59,60.69 294.78,60.5 294.78,60.44 294.79,60.35 294.79,60.35 v2(295.07,60.11)
  BOTTOM w0.14: R21998.2 61.13,59.01 61.48,59.01 v1(61.64,59.17)
CPU_WIGIG_PCIE_TXN1: length 247.2
  TOP w0.14: CN2068.61 59.71,59.25 59.48,59.48 59.25,59.48 59.18,59.41 v1(59.18,59.25) ; v1(281.81,53.08) 281.81,53.13 282.18,53.5 282.39,53.5 282.43,53.55 283.65,53.55 284.11,54.01 284.11,54.65 284.32,54.86 284.32,58.51 284.41,58.6 284.64,58.6 C95897.2
  IN5 w0.089: v1(59.18,59.25) 59.01,59.25 58.87,59.39 58.87,59.57 59.09,59.79 59.55,59.79 60.09,59.25 60.09,57.93 61.51,56.52 61.51,54.65 62.21,53.95 62.21,52.18 64.81,49.58 66.55,49.58 68.17,47.96 72.5,47.96 73.04,47.42 75.32,47.42 75.69,47.05 78.62,47.05 79.33,47.76 83.88,47.76 84.68,48.56 89.96,48.56 91.37,49.97 92.5,49.97 94.31,51.78 126.9,51.78 127.38,52.26 154.57,52.26 155.04,51.79 174.22,51.79 176.69,54.25 178.04,54.25 178.35,54.56 183.05,54.56 183.61,55.13 191.78,55.13 192.22,55.57 196.79,55.57 196.9,55.45 198.15,55.45 198.38,55.22 198.71,55.22 198.86,55.07 203.33,55.07 204.65,53.74 255.84,53.74 255.92,53.82 263.42,53.82 264.02,54.42 270.49,54.42 270.81,54.09 280.43,54.09 280.92,53.6 281.37,53.6 281.58,53.39 281.7,53.39 281.81,53.28 v1(281.81,53.08)
CPU_WIGIG_PCIE_TXP1: length 247.2
  TOP w0.14: v1(58.49,59.3) 58.94,59.75 CN2068.59 ; C95898.2 284.94,58.87 284.3,58.87 284.05,58.62 284.05,54.97 283.84,54.76 283.84,54.12 283.53,53.81 282.32,53.81 282.28,53.77 v1(281.78,53.77)
  IN5 w0.089: v1(281.78,53.77) 280.99,53.77 280.5,54.26 270.88,54.26 270.56,54.58 263.95,54.58 263.35,53.99 255.85,53.99 255.77,53.91 204.72,53.91 203.4,55.24 198.93,55.24 198.78,55.39 198.44,55.39 198.22,55.62 196.97,55.62 196.85,55.73 192.15,55.73 191.72,55.3 183.55,55.3 182.98,54.73 178.28,54.73 177.97,54.42 176.62,54.42 174.15,51.96 155.11,51.96 154.64,52.43 127.31,52.43 126.83,51.95 94.24,51.95 92.43,50.14 91.3,50.14 89.89,48.73 84.61,48.73 83.81,47.93 79.26,47.93 78.55,47.22 75.76,47.22 75.39,47.59 73.11,47.59 72.57,48.13 68.24,48.13 66.62,49.75 64.87,49.75 62.38,52.25 62.38,54.02 61.68,54.72 61.68,56.59 60.26,58 60.26,59.32 59.62,59.96 59.02,59.96 58.7,59.64 58.7,59.51 v1(58.49,59.3)
CTL0_EDP: length 3.9
  TOP w0.14: R20934.2 R20935.2 332.48,69.78 332.48,70.5 332.81,70.83 333.09,70.83 333.28,71.02 U13079.22
CTL0_TBT_SDA: length 4.5
  TOP w0.14: U13025.22 333.03,52.61 332.91,52.49 332.76,52.49 332.25,51.98 332.25,51.14 R20837.1 331.74,50 331.87,49.88 C95998.2
CTL1_EDP: length 8.1
  TOP w0.14: v1(334.89,67.12) 334.87,67.1 334.59,67.1 333.41,68.28 R20929.2 R20931.2 332.91,69.65 332.91,69.65 332.78,69.78 332.78,69.78 332.76,69.81 332.76,70.39 332.93,70.55 333.24,70.55 333.48,70.79 333.48,70.86 333.68,71.06 U13079.23
  BOTTOM w0.14: v1(334.89,67.12) 334.71,67.12 334.16,67.67 334.16,68.08 R20918.1
CTL1_TBT_HPDIN: length 8
  TOP w0.14: U13025.23 333.43,51.17 v1(333.4,51.15) 333.4,50.89 333.14,50.63 R20831.1 R20836.1
  BOTTOM w0.14: v1(333.4,51.15) 333.53,51.02 334.33,51.02 334.58,51.26 334.58,52.79 v1(334.7,52.92) R20829.2
CTL2: length 5
  TOP w0.14: U13128.7 363.87,49.5 364.66,48.71 365.15,48.71 365.65,48.2 v1(365.83,48.2)
  BOTTOM w0.14: v1(365.83,48.2) 365.22,48.2 364.4,49.02 R21707.2
CTL3: length 3
  TOP w0.14: v1(365.86,48.85) 365.72,48.99 364.89,48.99 364.37,49.51 U13128.8
  BOTTOM w0.14: R21708.2 365.69,49.02 v1(365.86,48.85)
D/C#: length 3.1
  TOP w0.14: v1(64.66,51.78) 64.64,51.76 TP1.1
  BOTTOM w0.14: v1(64.66,51.78) 64.91,51.54 PC20.2
  BOTTOM w0.178: PC20.2 65.7,51.54 66.36,52.19 PR26.1
DC-DET: length 22.8
  TOP w0.14: R21440.1 v1(39.62,43.65) 39.28,43.65 v1(38.86,43.22) ; v1(33.08,34.42) 32.97,34.32 32.18,34.32 U13108.13
  IN2 w0.089: v1(33.08,34.42) 33.1,34.42 33.17,34.48 33.34,34.48 33.85,34.99 33.85,37.18 34.08,37.41 36.99,37.41 37.96,38.37 39.13,38.37 40.06,39.3 40.06,42.68 39.52,43.22 v1(38.86,43.22)
  BOTTOM w0.14: R22088.1 33.39,32.43 33.17,32.21 R22087.2 32.38,32.38 33.18,33.17 33.18,34.32 v1(33.08,34.42)
DCPRTC: length 1.5
  TOP w0.254: U13113.BA26 311.14,65.54 v2(311.14,65.96)
  BOTTOM w0.254: v2(311.14,65.96) 311.14,66.06 311.48,66.39 C94839.1
DDI1_TX0_DN: length 6.6
  TOP w0.14: U13025.39 336.5,57.9 336.54,57.94 338.06,57.94 340.45,55.55 341.34,55.55 C94559.2
DDI1_TX0_DN_C: length 3.7
  TOP w0.079: U21.AC7 345.03,55.42 345.03,55.3 344.96,55.23 344.79,55.23 344.66,55.36 344.66,55.54 344.52,55.68 343.65,55.68 343.57,55.6 343.56,55.6
  TOP w0.14: C94559.1 342.26,55.6 343.56,55.6
DDI1_TX0_DP: length 6.6
  TOP w0.14: U13025.40 336.5,58.3 336.54,58.26 338.2,58.26 340.58,55.87 341.32,55.87 C13548.2
DDI1_TX0_DP_C: length 3.7
  TOP w0.079: 343.56,55.92 343.57,55.92 343.65,55.84 344.59,55.84 344.72,55.7 345.2,55.7 345.44,55.46 U21.AB7
  TOP w0.14: C13548.1 342.19,55.92 343.56,55.92
DDI1_TX1_DN: length 5.7
  TOP w0.14: U13025.36 336.5,56.7 336.54,56.74 337.9,56.74 339.05,55.59 339.05,55.08 339.75,54.37 340.21,54.37 C94561.2
DDI1_TX1_DN_C: length 4.9
  TOP w0.079: 343.56,54.39 343.57,54.39 343.63,54.44 344.05,54.44 344.1,54.49 344.62,54.49 344.79,54.31 345.13,54.31 345.19,54.38 345.19,54.48 345.13,54.54 U21.AC9
  TOP w0.14: C94561.1 341.07,54.17 341.28,54.39 343.56,54.39
DDI1_TX1_DP: length 5.7
  TOP w0.14: C94560.2 340.29,54.77 340.29,54.77 340.21,54.69 339.88,54.69 339.36,55.21 339.36,55.73 338.03,57.06 336.54,57.06 336.5,57.1 U13025.37
DDI1_TX1_DP_C: length 4.9
  TOP w0.079: U21.AB9 345.21,54.78 344.79,54.78 344.66,54.65 344.04,54.65 343.99,54.6 343.68,54.6 343.57,54.7 343.56,54.7
  TOP w0.14: 343.56,54.7 341.21,54.7 341.03,54.88 C94560.1
DDI1_TX2_DN: length 6.7
  TOP w0.14: C94563.2 341.34,53.52 339.69,53.52 339.07,54.14 338.89,54.14 337.83,55.2 337.83,55.38 337.35,55.86 336.54,55.86 336.5,55.9 U13025.34
DDI1_TX2_DN_C: length 3.8
  TOP w0.079: 343.56,53.74 343.57,53.74 343.65,53.66 343.97,53.66 344.08,53.55 344.51,53.55 344.81,53.85 345.08,53.85 345.14,53.79 345.14,53.69 345.08,53.62 U21.AC11
  TOP w0.14: C94563.1 342.2,53.74 342.38,53.56 342.59,53.56 342.78,53.74 343.56,53.74
DDI1_TX2_DP: length 6.7
  TOP w0.14: C94562.2 341.32,53.2 339.56,53.2 338.93,53.83 338.75,53.83 337.52,55.06 337.52,55.24 337.22,55.54 336.54,55.54 336.5,55.5 U13025.33
DDI1_TX2_DP_C: length 3.8
  TOP w0.079: U21.AB11 345.44,53.62 345.2,53.39 344.01,53.39 343.91,53.5 343.65,53.5 343.57,53.42 343.56,53.42
  TOP w0.14: C94562.1 342.15,52.98 342.42,53.24 342.73,53.24 342.91,53.42 343.56,53.42
DDI1_TX3_DN: length 5.4
  TOP w0.14: U13025.31 336.5,54.7 336.54,54.66 336.96,54.66 338.44,53.18 338.67,53.18 339.52,52.32 340.19,52.32 C94565.2
DDI1_TX3_DN_C: length 5
  TOP w0.079: U21.AC13 345.05,52.77 345.05,52.87 345,52.93 344.76,52.93 344.65,52.82 344.65,52.64 344.56,52.56 343.63,52.56 343.55,52.64 343.53,52.64
  TOP w0.14: C94565.1 341.12,52.29 342.92,52.29 343.27,52.64 343.53,52.64
DDI1_TX3_DP: length 5.4
  TOP w0.14: C94564.2 340.19,52 339.39,52 338.53,52.86 338.31,52.86 336.83,54.34 336.54,54.34 336.5,54.3 U13025.30
DDI1_TX3_DP_C: length 5
  TOP w0.079: U21.AB13 345.44,52.7 345.35,52.61 345.33,52.6 345.21,52.48 344.71,52.48 344.63,52.4 343.63,52.4 343.55,52.32 343.53,52.32
  TOP w0.14: C94564.1 341.05,51.97 343.06,51.97 343.41,52.32 343.53,52.32
DDPB_CLK: length 5.8
  TOP w0.102: v2(311.4,55.24) 311.6,55.03 U13113.BA5
  BOTTOM w0.14: v2(311.4,55.24) 311.27,55.24 310.36,54.32 310.1,54.32 v1(308.71,52.92) 307.69,51.91 R67229.1
DDPB_DATA: length 6.3
  TOP w0.102: U13113.BC4 312.05,54.28 v2(311.93,54.4)
  BOTTOM w0.14: v2(311.93,54.4) 311.73,54.19 311.73,53.14 312.95,51.92 312.95,50.64 v1(312.72,50.41) 312.44,50.13 R67228.1
DDPC_CLK: length 5.6
  TOP w0.102: U13113.BB3 311.55,53.41 v2(311.2,53.76)
  BOTTOM w0.14: R21318.1 311.83,49.78 311.83,51.68 311.47,52.04 v1(311.47,52.52) 311.2,52.8 v2(311.2,53.76)
DDPC_DATA: length 6.9
  TOP w0.127: v2(312.36,54.85) 312.38,54.87 U13113.BD6
  BOTTOM w0.14: v2(312.36,54.85) 312.39,54.82 312.39,54.23 314.07,52.55 v1(314.07,51.3) 314.07,49.99 R21319.1
DDR4_DRAMRST#: length 128.6
  TOP w0.14: v1(251.96,55.62) 251.96,55.52 251.44,54.99 CN2063.108 ; CN2062.108 251.44,65.26 v1(250.62,64.44) ; R21113.2 324.39,58.49 324.28,58.39 C94808.1 324.28,57.57 324.73,57.12 v1(324.84,57.12)
  IN2 w0.089: v1(251.96,55.62) 252.5,56.15 252.5,60.41 252.98,60.89 276.47,60.89 278.36,59 280.49,59 281.45,59.96 286.68,59.96 287.27,60.55 288.8,60.55 289.79,61.54 291.95,61.54 293.35,60.14 293.35,59.78 293.61,59.53 300.79,59.53 301.71,60.46 302.64,60.46 307.36,65.18 307.36,65.83 307.92,66.39 313.54,66.39 314.73,67.58 314.73,68.75 317.19,71.21 318.66,71.21 319.3,71.85 320.29,71.85 320.62,71.52 321.41,71.52 322.88,72.99 324.76,72.99 325.6,72.16 325.6,70.85 327.15,69.29 327.15,64.98 328.29,63.84 328.29,63.27 329.62,61.94 329.62,60.96 328.89,60.23 328.51,60.23 325.39,57.12 v1(324.84,57.12)
  BOTTOM w0.14: C94892.1 251.43,55.08 v1(251.96,55.62) 251.96,55.82 251.43,56.35 251.43,57.29 250.46,58.26 250.46,58.61 250.69,58.84 250.69,60.7 250.01,61.38 250.01,63.85 250.6,64.44 v1(250.62,64.44) 251.3,65.13 C94861.1
DDR4_SUSON_2V5: length 10.9
  TOP w0.14: PR305.2 186.21,72.27 v1(185.97,72.51) 185.01,72.51 183.94,73.58 182.54,73.58 181.83,72.86 R67314.1
DDR_VTT: length 5.7
  TOP w0.254: v1(211.63,55.54) 211.63,54.83 211.94,54.52 CN2063.258 ; 211.94,65.27 CN2062.258
  TOP w0.508: v1(209.7,65.07) 211.73,65.07 211.94,65.27
  vias: v1(186.13,74.74)
DDR_VTT_CNTL: length 13.7
  TOP w0.14: Q7844.1 271.57,107.02 v1(270.99,107.02)
  TOP w0.254: U41.BT13 267.58,112.43 268.05,112.89 269.03,112.89 269.18,112.74 269.87,112.74 270.45,112.16 270.45,111.4 270.02,110.96 R21410.2 270.24,110.82 270.54,110.52 270.54,109.73 270.89,109.39 272.56,109.39 272.77,109.19 272.77,108.22 Q7844.1
DDR_VTTT_PG_CTRL: length 122.8
  TOP w0.254: v1(273.73,100.4) 273.93,100.6 273.93,103.75 273.45,104.23 v1(273.45,104.49) 273.45,105.38 274.15,106.07 R21412.2 274.34,106.9 273.93,107.31 Q7844.3
  IN3 w0.254: v1(174.42,80.31) 175.31,81.2 175.31,82.03 176.07,82.8 176.07,84.9 177.99,86.82 177.99,87.35 178.99,88.36 191.16,88.36 192.17,87.34 196.28,87.34 201.52,92.59 201.52,93.95 202.03,94.45 205.01,94.45 207.51,91.96 265.29,91.96 v1(273.73,100.4)
  BOTTOM w0.254: PR2029.2 174.42,80.26 v1(174.42,80.31)
DEVSLP0: length 377.4
  TOP w0.14: U13113.AG42 304.27,72.94 304.68,72.53 v2(304.69,72.53)
  IN3 w0.079: v1(72.99,26.31) 69.46,22.78 68.22,22.78 67.15,21.71 61.39,21.71 59.74,23.36 59.74,26 58.61,27.12 58.61,28.48 58.21,28.88 57.16,28.88 55.09,30.95 50.44,30.95 49.68,30.19 46.72,30.19 43.3,26.76 40.61,26.76 38.11,29.26 38.11,32.36 38.12,32.36 38.12,33.11 39.04,34.04 39.04,37.83 40.04,38.82 40.04,42.19 39.58,42.65 39.58,43.74 38.82,44.5 38.82,46.34 40.54,48.06 40.54,49.22 41.52,50.21 42.67,50.21 44.75,52.29 44.75,53.56 48.03,56.84 51.92,56.84 52.27,57.19 56.25,57.19 57.61,55.83 60.46,55.83 61.42,54.87 61.93,54.87 64.15,52.65 64.35,52.65 65.81,51.19 67.21,51.19 68.81,49.59 73.41,49.59 74.15,48.86 88.99,48.86 92.88,52.75 100.9,52.75 103.21,55.06 117.35,55.06 118.08,54.33 124.69,54.33 125.45,53.57 126.21,53.57 126.65,54.02 146.68,54.02 148.36,55.7 158.89,55.7 160.63,53.95 164.78,53.95 166.7,55.87 166.7,60 169.81,63.11 170.74,63.11 170.74,63.11 170.77,63.11 172.42,64.77 175.44,64.77 175.44,64.77 177.97,64.77 179.92,66.72 182.63,66.72 183.35,67.44 192,67.44 193.61,65.83 194.22,65.83 198.16,69.77 200.61,69.77 203.66,72.81 203.66,75.31 203.81,75.47 203.81,75.92 205.31,77.42 205.45,77.42 205.83,77.8 206.96,77.8 212.62,83.46 276.29,83.46 281.59,78.16 281.59,78.15 282.81,76.93 282.81,76.15 284.18,74.78 292.27,74.78 292.83,74.22 301.65,74.22 301.85,74.02 303.21,74.02 v2(304.69,72.53)
  BOTTOM w0.14: R21733.2 R67358.2 72.71,24.87 72.71,26.03 v1(72.99,26.31) 73.76,26.31 v1(73.78,26.28) ; R21092.1 304.44,77.29 304.44,75.27 304.23,75.06 304.23,74.58 304.52,74.29 304.52,73.93 304.69,73.75 v2(304.69,72.53)
DEVSLP0_R: length 17.1
  TOP w0.14: CN11.20 70.98,35.65 v1(70.96,35.63)
  IN3 w0.079: v1(72.23,26.15) 72.23,26.46 72.31,26.53 72.31,34.23 70.99,35.55 70.99,35.6 v1(70.96,35.63)
  BOTTOM w0.14: R67358.1 71.56,25.13 72.23,25.8 v1(72.23,26.15)
DEVSLP3: length 332.9
  TOP w0.14: U13113.AB41 302.18,72.51 v2(302.46,72.79)
  IN3 w0.079: v2(302.46,72.79) 301.11,72.79 299.84,74.06 292.05,74.06 291.84,73.85 290.37,73.85 289.98,74.24 284.5,74.24 282.65,76.09 282.65,76.87 276.22,83.3 212.69,83.3 207.03,77.64 205.89,77.64 205.51,77.26 205.37,77.26 203.97,75.86 203.97,75.4 203.81,75.24 203.81,72.75 200.67,69.61 198.22,69.61 194.28,65.67 193.55,65.67 191.93,67.28 183.42,67.28 182.7,66.56 179.99,66.56 178.03,64.61 175.51,64.61 175.5,64.61 172.49,64.61 170.84,62.96 170.81,62.96 170.8,62.95 169.87,62.95 166.86,59.93 166.86,55.8 164.85,53.79 160.57,53.79 158.82,55.54 148.43,55.54 146.75,53.86 126.72,53.86 126.27,53.42 118.13,53.42 116.64,54.9 103.27,54.9 100.96,52.59 92.95,52.59 89.06,48.7 74.07,48.7 73.34,49.43 68.73,49.43 67.13,51.03 65.74,51.03 65.36,51.41 64.51,51.41 63.28,52.64 62.95,52.64 62.39,53.19 62.39,53.67 60.4,55.67 57.55,55.67 56.18,57.03 52.34,57.03 51.96,56.65 48.1,56.65 44.93,53.48 44.93,52.22 42.68,49.98 41.57,49.98 40.7,49.1 40.7,47.99 38.98,46.28 38.98,44.56 39.74,43.81 39.74,42.71 40.19,42.25 40.19,38.76 39.2,37.76 39.2,33.97 38.27,33.04 38.27,32.2 38.27,29.32 40.43,27.16 v1(40.83,27.16)
  BOTTOM w0.14: R21093.1 300.88,73.85 301.95,72.79 v2(302.46,72.79) ; v1(40.83,27.16) 40.46,26.79 40.46,24.88 41.08,24.26 41.08,23.8 41.16,23.72 R21796.2
DEVSLP_N1: length 13.5
  IN1 w0.089: v1(71.91,20.48) 71.75,20.31 71.75,17.09 71.39,16.73 66.68,16.73 CN2069.38
  BOTTOM w0.14: v1(70.73,23.44) 71.54,23.44 R21733.1 71.56,22.82 71.73,22.65 R21734.2 71.73,21.53 71.85,21.4 71.85,20.54 v1(71.91,20.48)
DEVSLP_N2: length 16.3
  IN1 w0.089: v1(42.16,21.84) 42.16,19.93 42.97,19.12 44.95,19.12 45.71,18.36 45.71,17.01 45.46,16.76 40.36,16.76 39.99,17.12 CN2070.38
  BOTTOM w0.14: v1(42.16,21.84) 41.65,21.84 41.39,22.09 R21797.2 41.78,22.57 41.94,22.73 R21796.1
DG_ACE_A_I2C_ADDR: length 4.2
  TOP w0.14: U13155.F1 368.62,23.18 368.98,22.82 v1(368.98,22.57)
  BOTTOM w0.14: v1(368.98,22.57) 368.98,22.89 v1(368.41,23.46) 368.98,24.04 R67084.2
DG_RTD3_CIO_PWR_EN: length 5.9
  TOP w0.079: U21.F1 352.81,59 352.09,59.71 350.74,59.71 350.22,60.23
  TOP w0.14: R67054.1 350.08,60.71 v1(350.08,60.37) 350.22,60.23
  BOTTOM w0.14: R67158.1 350.41,60.7 v1(350.08,60.37)
DG_RTD3_USB_PWR_EN: length 5
  TOP w0.14: v4(353.62,56.74) U21.D4
  BOTTOM w0.14: v1(351.96,59.81) 352.78,59 R67154.1 353.3,58.44 353.08,58.22 353.08,57.75 353.31,57.53 R20694.1 353.72,56.83 v4(353.62,56.74)
DGPU_HOLD_RST#: length 230.4
  TOP w0.102: U13113.AW27 310.63,65.34 v2(310.03,64.74)
  TOP w0.14: v1(133.12,109.9) 132.86,110.15 132.86,110.58 132.81,110.63 132.18,110.63 131.98,110.83 U13115.1
  IN1 w0.14: v1(205.76,75.78) 205.5,76.05 205.5,77.31 205.96,77.77 205.96,78.21 198.9,85.26 198.9,88.54 199.74,89.37 199.74,93.92 199.05,94.61 157.61,94.61 151.9,100.31 150.13,100.31 149.79,99.97 146.11,99.97 145.91,100.16 142.16,100.16 141.86,99.85 136.55,99.85 135.99,100.41 135.23,100.41 134.72,100.92 133.7,100.92 132.39,102.23 132.39,107.95 132.81,108.37 132.81,109.59 v1(133.12,109.9)
  IN3 w0.079: v1(205.76,75.78) 206.73,75.78 208.59,77.65 213.14,82.2 275.76,82.2 281.55,76.41 281.55,75.12 285.26,71.41 291.23,71.41 293.19,69.46 295.2,69.46 296.14,68.52 299.43,68.52 300.82,67.13 307.69,67.13 308.5,66.33 308.67,66.33 309.81,65.19 309.81,64.95 v2(310.03,64.74)
  BOTTOM w0.14: R21313.2 319.23,67.56 317.88,67.56 317.77,67.66 R21256.2 317.36,67.5 317.01,67.15 316.76,67.15 316.38,66.77 313.63,66.77 312.98,66.11 R67241.1 312.27,65.17 311.29,65.17 311.23,65.22 310.26,65.22 310.03,64.99 v2(310.03,64.74)
DGPU_OPP#: length 7.8
  TOP w0.14: U49.71 195.33,55.6 v1(195.9,56.18)
  BOTTOM w0.14: v1(195.9,56.18) 195.9,55.71 195.85,55.66 195.85,54.5 195.35,53.99 C96221.1 195.75,53.68 195.76,53.67 R67319.2 R67322.1 197.78,53.67 198.01,53.9 Q7941.2
DGPU_OPP#_PROCHOT#: length 138.4
  TOP w0.14: Q7859.3 125.9,113.5 126,113.41 R67308.1 126,112.73 126.26,112.46 127.17,112.46 v1(127.25,112.39)
  IN3 w0.079: v1(173.83,53.79) 174.23,53.4 175.74,53.4 179.22,56.88 180.39,56.88 180.62,56.66 186.6,56.66 187.02,57.07 191.91,57.07 194.44,54.55 195.49,54.55 195.95,54.09 196.94,54.09 197.09,54.25 v1(197.61,54.25)
  IN5 w0.089: v1(165.55,64.41) 165.16,64.41 164.1,65.47 162.79,65.47 162.07,64.76 156.47,64.76 155.21,66.01 153.68,66.01 152.02,64.35 150.15,64.35 149.32,65.19 136.98,65.19 136.6,65.57 133.88,65.57 132.99,66.46 132.99,68.29 131.85,69.43 127.59,69.43 127.2,69.82 127.2,71.79 125.7,73.3 125.7,84.09 126.85,85.24 126.85,88.92 128.44,90.52 128.44,93.46 128.27,93.63 128.27,100.43 128.49,100.65 128.49,111.15 v1(127.25,112.39)
  BOTTOM w0.14: v1(197.61,54.25) 197.81,54.45 198.52,54.45 198.72,54.25 Q7941.3 198,52.55 197.66,52.89 R67322.2 ; v1(173.83,53.79) 173.83,53.89 172.67,55.05 172.67,57.65 172.45,57.87 171.42,57.87 169.71,59.59 168.21,59.59 167.41,60.39 167.41,61.93 165.55,63.78 v1(165.55,64.41)
DGPU_OVT#_EC: length 127.8
  TOP w0.14: U49.68 194.81,54.4 194.84,54.37 195.77,54.37 v1(196.36,54.96)
  IN1 w0.089: v1(196.36,54.96) 196.11,54.96 195.35,55.72 178.68,55.72 178.48,55.92 176.58,55.92 175.74,55.08 174.92,55.08 v1(174.85,55.16)
  IN2 w0.089: v1(131.41,110.2) 131.08,109.87 131.08,105.27 130.68,104.87 130.68,87.63 128.75,85.69 128.75,84.07 127.93,83.25 127.93,78.45 133.62,72.76 133.62,69.64 134.97,68.29 135.68,68.29 136.93,67.05 146.21,67.05 146.82,66.43 151.87,66.43 152.17,66.13 153.29,66.13 153.71,66.55 155.12,66.55 156.96,64.71 161.64,64.71 163.28,66.35 164.27,66.35 164.58,66.66 v1(165.46,66.66)
  BOTTOM w0.14: v1(131.41,110.2) 131.27,110.06 130.86,110.06 130.38,110.53 127.83,110.53 127.81,110.51 127.05,110.51 126.97,110.58 Q7943.3 ; R20889.1 196.46,55.06 v1(196.36,54.96) ; v1(165.46,66.66) 166.38,65.74 166.38,63.8 168.47,61.71 168.47,60.95 169.17,60.25 169.87,60.25 171.58,58.55 172.75,58.55 174.16,57.14 174.16,56.17 174.85,55.49 v1(174.85,55.16)
DGPU_PWR_EN: length 256.6
  TOP w0.102: v1(314.74,66.01) 314.33,65.6 313.2,65.6 313.14,65.66 312.83,65.66 U13113.BD27
  TOP w0.14: U13120.2 v1(123.21,114.98) U13119.2
  IN1 w0.14: v1(123.21,114.98) 123.79,115.56 125.57,115.56 126.05,115.08 126.05,114.65 126.26,114.44 126.26,109.6 127.25,108.61 127.25,100.44 129.28,98.41 133.41,98.41 134.06,97.76 138.08,97.76 138.59,97.25 150.77,97.25 155.62,92.4 191.94,92.4 197.04,87.3 197.04,86.16 204.84,78.36 204.84,74.65 v1(204.97,74.51)
  IN3 w0.079: v1(204.97,74.51) 204.95,74.53 204.95,75.73 205.54,76.31 206.06,76.31 206.17,76.21 206.71,76.21 207.92,77.42 213.01,82.51 275.89,82.51 281.87,76.54 281.87,75.48 285.62,71.73 291.38,71.73 292.54,70.57 295.13,70.57 295.89,69.81 298.14,69.81 299.05,68.91 301.9,68.91 303.31,67.5 307.77,67.5 308.63,66.64 314.1,66.64 v1(314.74,66.01)
  IN5 w0.089: v1(326.54,68.42) 326.54,68.8 325.81,69.52 323.5,69.52 322.64,68.67 322.64,68.42 321.88,67.66 320.49,67.66 319.85,67.02 317.52,67.02 317.01,66.51 315.25,66.51 v1(314.74,66.01)
  BOTTOM w0.14: R21309.2 327.68,71.5 327.68,69.69 327.46,69.46 R21271.2 R67240.1 326.69,67.76 326.54,67.91 v1(326.54,68.42)
DGPU_PWROK: length 57.7
  TOP w0.14: Q7851.2 158.87,105.5 158.16,105.5 157.61,106.05 157.44,106.05 Q7857.1 157.39,105.87 158.01,105.25 158.01,103.22 157.25,102.45 154.45,102.45 152.94,100.94 151.77,100.94 151.4,101.31 150.11,101.31 149.12,102.3 147.2,102.3 v1(146.83,102.67)
  IN5 w0.089: v1(121.03,112.06) 124.35,115.38 125.45,115.38 127.5,117.44 127.78,117.44 127.99,117.24 127.99,115.61 128.42,115.18 131.31,115.18 133.12,113.38 133.12,112.22 135.39,109.95 139.62,109.95 144.29,105.27 144.29,102.96 144.93,102.33 146.49,102.33 v1(146.83,102.67)
  BOTTOM w0.14: R21617.2 120.57,111.6 v1(121.03,112.06) 120.45,112.63 Q7866.3
DGPU_PWROK_Q: length 246
  TOP w0.102: v1(315.18,64.81) 314.6,65.4 313.12,65.4 313.05,65.46 312.52,65.46 U13113.BC27
  TOP w0.14: v1(156.09,104.84) Q7857.3
  IN2 w0.089: v1(156.09,104.84) 155.34,104.1 155.34,103.47 156.23,102.58 157.63,102.58 158.39,103.34 161.06,103.34 161.82,104.11 161.82,106.94 162.36,107.48 165.36,107.48 166.07,106.78 167.9,106.78 168.3,106.39 168.3,104.97 170.38,102.89 172.41,102.89 175.92,99.38 199.49,99.38 202.3,96.57 205.85,96.57 209.11,93.3 209.11,73.17 206.87,70.93 206.87,67.93 206.27,67.33 206.27,54.37 208.94,51.7 229.79,51.7 230.26,51.23 233.48,51.23 233.95,51.7 241.17,51.7 241.87,51 247.4,51 249.65,53.26 263.58,53.26 263.91,53.59 278.59,53.59 282.33,57.33 286.42,57.33 286.72,57.03 288,57.03 290.04,55 291.36,55 292.38,53.98 292.38,53.79 292.94,53.23 293.18,53.23 293.47,52.93 295.26,52.93 296.41,54.08 298.1,54.08 298.25,54.23 299.14,54.23 301.01,56.1 303.89,56.1 304.27,56.48 304.27,57.39 304.78,57.9 304.78,60.91 306.19,62.32 306.73,62.32 307.71,63.31 307.71,63.75 307.87,63.91 309.71,63.91 310.03,63.59 310.03,63.34 310.54,62.83 312.44,62.83 313.71,64.1 314.47,64.1 v1(315.18,64.81)
  BOTTOM w0.14: v1(315.18,64.81) 315.34,64.97 316.78,64.97 317.12,64.63 318.03,64.63 318.08,64.58 318.82,64.58 319.09,64.3 319.09,63.06 319.32,62.83 R67242.1 R21248.2 319.58,64.22 319.43,64.38 R21316.1 319.62,65.02 319.88,64.76 321.58,64.76 322.12,65.29 R21244.1
DGPU_THER_ALERT#: length 112.1
  TOP w0.14: v1(180.08,75.23) 180.51,74.79 R67367.1 R67366.1
  IN2 w0.089: v1(180.08,75.23) 180.05,75.19 178.36,75.19 175.87,72.71 174.77,72.71 174.04,71.97 174.04,71.76 174.04,70.78 174.88,69.94 175.15,69.94 175.39,69.7 175.39,69.15 174.56,68.32 168.32,68.32 166.08,66.07 166.08,65.6 165.92,65.44 163.08,65.44 162,64.35 156.81,64.35 156.71,64.46 156.71,64.46 154.97,66.19 153.87,66.19 153.36,65.68 152.12,65.68 151.72,66.08 146.68,66.08 146.07,66.69 140.13,66.69 139.4,65.96 133.52,65.96 133.41,66.07 133.02,66.46 130.12,66.46 127.23,69.36 126.49,69.36 125.37,70.48 125.37,72.12 126.02,72.78 126.02,83.92 126.95,84.85 126.95,87.93 128.7,89.68 128.7,93.17 128.28,93.58 127.45,94.41 127.45,95.9 127.57,96.02 127.57,109.01 127.45,109.14 v1(127.45,110)
  BOTTOM w0.14: v1(127.45,110) 127.51,110.06 Q7944.3
DMI_RXN0: length 111.9
  TOP w0.081: U13113.C27 292.44,65.22 290.85,65.22 290.7,65.37 290.47,65.37 290.38,65.28 290.38,65 290.47,64.91 v1(290.49,64.91)
  TOP w0.14: v1(228.18,109.12) 227.86,108.79 U41.E8
  IN5 w0.089: v1(290.49,64.91) 290.28,64.7 290.28,64.5 290.07,64.29 288.2,64.29 286.34,66.14 284.68,66.14 283.18,67.64 283.18,72.89 281.37,74.69 281.37,78.36 266.42,93.31 234.67,93.31 227.52,100.46 222.99,100.46 221.04,102.41 221.04,104.91 221.61,105.48 221.61,107.96 221.54,108.03 221.54,110.64 223.11,112.21 224.88,112.21 225.75,111.34 225.75,110.61 226.05,110.3 227.46,110.3 228.04,109.73 228.04,109.26 v1(228.18,109.12)
DMI_RXN1: length 112.2
  TOP w0.081: U13113.B28 291.99,65.94 291.65,66.28 291.06,66.28 291.05,66.3
  TOP w0.14: U41.F6 228.53,107.74 228.33,107.54 v1(228.18,107.54) ; 291.05,66.3 291,66.3 290.68,65.97 v1(290.39,65.97)
  IN5 w0.089: v1(228.18,107.54) 227.78,107.94 227.6,107.94 227.41,108.13 226.98,108.13 226.19,108.91 226.19,109.1 224.95,110.34 224.95,110.74 224.69,111 223.03,111 222.27,110.24 222.27,108.48 222.34,108.41 222.34,105.17 221.77,104.61 221.77,102.71 223.29,101.19 227.91,101.19 235,94.11 235.39,94.11 235.48,94.2 235.48,95.05 235.67,95.24 236.07,95.24 236.26,95.05 236.26,94.2 236.35,94.11 236.61,94.11 236.7,94.2 236.7,95.05 236.89,95.24 237.3,95.24 237.48,95.05 237.48,94.2 237.57,94.11 266.66,94.11 282.1,78.66 282.1,74.99 283.91,73.19 283.91,67.95 284.86,67 286.59,67 288.23,65.36 289.34,65.36 289.53,65.55 290.28,65.55 290.39,65.66 v1(290.39,65.97)
DMI_RXN2: length 130.4
  TOP w0.081: 289.33,66.7 289.38,66.65 291.74,66.65 291.94,66.45 U13113.B29
  TOP w0.14: v1(227.53,107.54) 227.86,107.21 U41.E5 ; 289.33,66.7 289.01,66.7 288.63,66.32 288.63,65.97 v1(288.44,65.78)
  IN5 w0.089: v1(288.44,65.78) 288.64,65.98 288.64,66.12 287.36,67.4 285.01,67.4 284.3,68.11 284.3,73.35 282.5,75.16 282.5,78.83 266.82,94.5 252.84,94.5 252.66,94.69 252.66,95.55 252.57,95.64 252.3,95.64 252.21,95.55 252.21,94.69 252.03,94.5 251.62,94.5 251.43,94.69 251.43,95.55 251.34,95.64 251.08,95.64 250.99,95.55 250.99,94.69 250.8,94.5 250.39,94.5 250.21,94.69 250.21,95.55 250.12,95.64 249.85,95.64 249.76,95.55 249.76,94.69 249.58,94.5 249.17,94.5 248.98,94.69 248.98,95.55 248.89,95.64 248.63,95.64 248.54,95.55 248.54,94.69 248.35,94.5 247.95,94.5 247.76,94.69 247.76,95.55 247.67,95.64 247.4,95.64 247.31,95.55 247.31,94.69 247.13,94.5 246.72,94.5 246.54,94.69 246.54,95.55 246.45,95.64 246.18,95.64 246.09,95.55 246.09,94.69 245.9,94.5 245.5,94.5 245.31,94.69 245.31,95.55 245.22,95.64 244.96,95.64 244.87,95.55 244.87,94.69 244.68,94.5 244.27,94.5 244.09,94.69 244.09,95.55 244,95.64 243.73,95.64 243.64,95.55 243.64,94.69 243.46,94.5 243.05,94.5 242.86,94.69 242.86,95.55 242.77,95.64 242.51,95.64 242.42,95.55 242.42,94.69 242.23,94.5 241.83,94.5 241.64,94.69 241.64,95.55 241.55,95.64 241.28,95.64 241.19,95.55 241.19,94.69 241.01,94.5 240.6,94.5 240.41,94.69 240.41,95.55 240.32,95.64 240.06,95.64 239.97,95.55 239.97,94.69 239.78,94.5 239.38,94.5 239.19,94.69 239.19,95.55 239.1,95.64 238.83,95.64 238.75,95.55 238.75,94.69 238.56,94.5 238.15,94.5 237.97,94.69 237.97,95.55 237.88,95.64 234.11,95.64 228.16,101.58 223.46,101.58 222.16,102.88 222.16,104.44 222.73,105.01 222.73,108.56 222.66,108.63 222.66,109.96 223.01,110.3 223.74,110.3 223.97,110.07 224.66,110.07 225.47,109.26 225.47,108.96 226.28,108.14 226.28,107.47 226.6,107.15 227.14,107.15 v1(227.53,107.54)
DMI_RXN3: length 132
  TOP w0.14: U13113.B30 292.09,67.07 291.69,67.47 290.79,67.47 v1(290.41,67.09) ; v1(229.53,109.91) 229.82,109.62 U41.J9
  IN5 w0.089: v1(290.41,67.09) 290.63,67.31 290.63,67.54 290.95,67.86 291.46,67.86 291.86,67.46 291.86,64.29 291.28,63.7 287.96,63.7 286.23,65.43 284.6,65.43 282.62,67.41 282.62,72.65 280.81,74.46 280.81,78.13 266.26,92.68 233.84,92.68 226.62,99.9 218.67,99.9 213.78,104.79 213.78,109.52 216.49,112.23 221.51,112.23 222.09,112.81 225.07,112.81 226.05,111.83 228.52,111.83 229.41,110.94 229.41,110.03 v1(229.53,109.91)
DMI_RXP0: length 111.9
  TOP w0.081: U13113.B27 292.15,65.38 292.24,65.38 292.32,65.46 292.32,65.54 292.22,65.65 291.92,65.65 291.65,65.38 290.92,65.38 290.77,65.53 290.4,65.53 290.22,65.35 290.22,65.2 289.99,64.96 v1(289.83,64.96)
  TOP w0.14: U41.D8 227.45,108.72 227.53,108.81 v1(227.53,109.12)
  IN5 w0.089: v1(227.53,109.12) 227.64,109.12 227.87,109.34 227.87,109.66 227.39,110.14 225.99,110.14 225.58,110.54 225.58,111.27 224.81,112.04 223.18,112.04 221.71,110.57 221.71,108.1 221.78,108.03 221.78,105.41 221.21,104.84 221.21,102.48 223.06,100.63 227.58,100.63 234.74,93.48 266.49,93.48 281.54,78.43 281.54,74.76 283.35,72.96 283.35,67.71 284.75,66.31 286.41,66.31 288.27,64.46 290,64.46 290.11,64.57 290.11,64.84 289.99,64.96 v1(289.83,64.96)
DMI_RXP1: length 112.2
  TOP w0.081: U13113.A28 291.72,65.86 291.72,65.98 291.58,66.12 291.13,66.12 291,65.99 291,65.87 v1(291.08,65.8)
  TOP w0.14: v1(228.19,108.32) 227.86,107.99 U41.E6
  IN5 w0.089: v1(228.19,108.32) 227.98,108.11 227.67,108.11 227.48,108.3 227.05,108.3 226.36,108.98 226.36,109.17 225.11,110.41 225.11,110.81 224.76,111.17 222.96,111.17 222.1,110.31 222.1,108.41 222.17,108.34 222.17,105.24 221.6,104.68 221.6,102.64 223.22,101.02 227.84,101.02 234.93,93.94 235.46,93.94 235.65,94.13 235.65,94.98 235.74,95.07 236,95.07 236.09,94.98 236.09,94.13 236.28,93.94 236.68,93.94 236.87,94.13 236.87,94.98 236.96,95.07 237.23,95.07 237.31,94.98 237.31,94.13 237.5,93.94 266.59,93.94 281.94,78.59 281.94,74.92 283.74,73.12 283.74,67.88 284.79,66.83 286.52,66.83 288.16,65.19 289.41,65.19 289.6,65.38 290.34,65.38 290.82,65.85 291.02,65.85 v1(291.08,65.8)
DMI_RXP2: length 130.4
  TOP w0.081: U13113.C29 292.56,66.45 292.37,66.25 291.91,66.25 291.67,66.49 289.38,66.49 289.33,66.44
  TOP w0.14: 289.33,66.44 289.12,66.44 288.89,66.21 288.89,65.98 v1(289.1,65.78) ; U41.D5 227.21,106.8 v1(227.39,106.62)
  IN5 w0.089: v1(227.39,106.62) 227.39,106.74 227.14,106.98 226.53,106.98 226.12,107.4 226.12,108.07 225.3,108.89 225.3,109.19 224.59,109.91 223.9,109.91 223.67,110.14 223.08,110.14 222.83,109.89 222.83,108.7 222.9,108.63 222.9,104.94 222.33,104.37 222.33,102.95 223.53,101.75 228.23,101.75 234.18,95.8 237.95,95.8 238.13,95.62 238.13,94.76 238.22,94.67 238.49,94.67 238.58,94.76 238.58,95.62 238.76,95.8 239.17,95.8 239.36,95.62 239.36,94.76 239.45,94.67 239.71,94.67 239.8,94.76 239.8,95.62 239.99,95.8 240.39,95.8 240.58,95.62 240.58,94.76 240.67,94.67 240.94,94.67 241.03,94.76 241.03,95.62 241.21,95.8 241.62,95.8 241.81,95.62 241.81,94.76 241.89,94.67 242.16,94.67 242.25,94.76 242.25,95.62 242.44,95.8 242.84,95.8 243.03,95.62 243.03,94.76 243.12,94.67 243.39,94.67 243.47,94.76 243.47,95.62 243.66,95.8 244.07,95.8 244.25,95.62 244.25,94.76 244.34,94.67 244.61,94.67 244.7,94.76 244.7,95.62 244.89,95.8 245.29,95.8 245.48,95.62 245.48,94.76 245.57,94.67 245.83,94.67 245.92,94.76 245.92,95.62 246.11,95.8 246.52,95.8 246.7,95.62 246.7,94.76 246.79,94.67 247.06,94.67 247.15,94.76 247.15,95.62 247.33,95.8 247.74,95.8 247.93,95.62 247.93,94.76 248.02,94.67 248.28,94.67 248.37,94.76 248.37,95.62 248.56,95.8 248.96,95.8 249.15,95.62 249.15,94.76 249.24,94.67 249.51,94.67 249.6,94.76 249.6,95.62 249.78,95.8 250.19,95.8 250.38,95.62 250.38,94.76 250.46,94.67 250.73,94.67 250.82,94.76 250.82,95.62 251.01,95.8 251.41,95.8 251.6,95.62 251.6,94.76 251.69,94.67 251.96,94.67 252.04,94.76 252.04,95.62 252.23,95.8 252.64,95.8 252.82,95.62 252.82,94.76 252.91,94.67 266.89,94.67 282.66,78.9 282.66,75.23 284.47,73.42 284.47,68.18 285.08,67.57 287.43,67.57 288.81,66.19 288.81,65.87 288.91,65.78 v1(289.1,65.78)
