# Allegro board DAZGLMB1ED0 dazglmb1ed0-d-ver a-165 (.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+1.8V_AON: length 111.7
  TOP w0.203: R21561.1 139.88,112.65 v1(139.88,112.01) ; PR9063.1 154.2,58.08 v1(153.79,57.67) 153.16,57.04 151.94,57.04 151.81,56.91 151.81,55.31 152.07,55.05 v1(152.07,54.98) ; v1(137.23,112.54) 137.34,112.64 R21590.1
  TOP w0.254: v1(124.66,111.42) 124.38,111.14 124.05,111.14 123.86,111.33 U13120.5 ; R21548.1 124.86,103.98 125.21,104.33 C95078.1 v1(125.88,104.61) 126,104.61 126.77,103.85 127.15,103.85 127.35,104.06 U13116.8 ; R21602.2 135.91,114.7 v1(135.88,114.72) ; R21591.1 136.92,119.32 v1(137.08,119.47) ; R21502.2 159.53,106.9 v1(160.04,107.41) ; v1(128.87,94.68) 128.93,94.73 R21559.1 ; v1(110.1,74.82) 110.68,74.82 PR9124.1 ; v1(136.93,74.01) 137.46,74.54 137.92,74.54 138.45,74.01 PR9001.1 ; v1(154.1,105.93) R21583.1 R21584.1 ; R21589.1 137.97,116.17 v1(137.92,116.12) 137.26,116.12 R21560.1 ; R21588.1 138.09,117.44 v1(138.02,117.36) ; R21598.1 138.17,120.36 v1(138.02,120.21) ; C95148.2 125.54,119.86 v1(125.67,119.73) ; v1(138.73,113.82) 139.09,114.18 R21594.1 ; v1(134.34,111.55) 134.13,111.34 R21601.1 ; R21593.1 126.52,116.24 v1(127.05,115.71) 127.43,116.1 R21608.2 ; v1(130.93,119.83) 131.47,119.83 R21881.1 ; R21552.1 125.88,102.58 126,102.45 v1(126.51,102.45) ; v1(126.27,120.68) U13118.5
  TOP w0.508: R21544.2 142.51,103.06 v1(142.67,103.06) ; R67309.2 122.78,120.53 v1(122.78,120.21) ; R21537.2 126.24,95.33 v1(126.13,95.44) ; v1(131.97,100.55) 132.23,100.3 R21538.2 ; Q7857.2 157.39,104.27 156.84,103.72 v1(156.61,103.72) ; R21545.2 144.19,103.47 v1(143.76,103.04) 143.68,103.12 143.6,103.12 R21543.2 ; v1(132.3,115.03) R21507.2 ; v1(131.97,103.98) R21536.2 ; R21542.2 v1(140.85,110.82)
  IN3 w0.254: v1(148.1,62.55) 148.1,65.55 146.28,67.38 146.28,71.71 144.58,73.41 139.12,73.41 138.45,72.74 137.82,72.74 136.93,73.63 v1(136.93,74.01)
  BOTTOM w0.203: R21592.1 134.77,111.98 v1(134.34,111.55)
  BOTTOM w0.254: R21618.1 122.22,111.75 v1(122.02,111.55) 121.23,111.55 R21617.1 ; PR9018.2 136.47,73.31 PR9010.1 ; PR9018.2 135.4,73.37 134.89,72.86 130.7,72.86 130.32,73.24 127.4,73.24 v1(126,71.85) ; PR9018.2 136.41,73.49 v1(136.93,74.01) ; v1(138.02,117.36) 138.54,117.36 138.71,117.19 R67331.1 ; v1(125.12,118.53) 125.04,118.61 R21610.1 123.64,118.61 123.05,118.03 R21616.1 ; v1(148.1,62.55) 149.02,61.64 149.02,61.23 151.18,59.07 151.18,55.97 152.07,55.08 v1(152.07,54.98) ; Q7858.2 v1(147.98,99.53) Q7858.5 ; v1(134.21,113.73) 134.73,113.73 134.96,113.5 R21595.1 ; v1(135.92,120.48) 135.63,120.77 R21596.1 135.63,121.66 135.25,122.04 C95134.1 ; R21881.1 131.42,119.78 130.98,119.78 v1(130.93,119.83) ; Q7943.2 127.28,111.08 v1(127.38,110.99) 127.74,111.36 127.83,111.36 127.83,111.36 Q7944.2 ; R21597.1 137.97,116.17 v1(137.92,116.12) ; Q7860.5 150.39,99.79 v1(150.13,99.53) 150.39,99.28 Q7860.2
  BOTTOM w0.381: v1(143.61,98.88) 143.61,99.08 143.39,99.29 R21547.2 ; R21599.1 147.47,102.96 v1(147.59,103.09)
  BOTTOM w0.508: v1(149.98,103.12) 149.88,103.01 R21600.1 ; v1(150.97,102.99) 150.9,102.91 R21570.1 ; R67320.1 123.71,112.37 v1(124.66,111.42) ; R21546.2 145.95,98.91 v1(145.94,98.9) ; R21571.1 150.34,105.7 151.2,105.7 R21572.1 151.4,105.62 151.67,105.35 151.67,104.58 152.09,104.16 v1(152.29,104.16) ; v1(148.61,103.06) R21569.1
  vias: v1(101.62,64.74) v1(102.38,64.74) v1(103.14,65.88) v1(103.14,65.22) v2(149.21,120.84) v2(149.24,120.21) v2(149.88,120.21)
+1.8V_MAIN: length 159.9
  TOP w0.254: U13114.AT10 v2(149.91,124.36) U13114.AT11 ; U13114.AM10 149.57,127.51 v2(149.91,127.18) 150.24,127.51 U13114.AM11 ; U13114.BC29 v2(162.51,120.16) ; U13114.AR11 150.26,125.41 v2(149.91,125.76) 149.56,125.41 U13114.AR10 ; U13114.AV11 v2(149.91,123.66) U13114.AV10 ; U13114.AN11 150.25,126.81 v2(149.9,126.46) 149.56,126.8 U13114.AN10 ; U13114.AW10 v2(149.91,122.96) U13114.AW11
  TOP w0.508: L4245.2 162.33,102.71 161.56,103.47 161.39,103.47 v1(160.93,103.93)
  IN1 w0.508: v1(154.12,104.61) 153.82,104.61 153.11,103.9 153.11,100.89 158.01,95.99 191.09,95.99 197.81,102.71 200.62,102.71 202.04,104.13 203.19,104.13 212.75,113.69 212.75,119.85 213.51,120.62 217.34,120.62 218.36,121.63 218.36,124.94 215.98,127.32 215.39,127.32 213.7,129 213.7,129.78 212.69,130.79 212.69,153.71 v1(214.9,155.92)
  BOTTOM w0.254: Q34.5 228.37,169.99 228.46,170.09 R21026.2
  BOTTOM w0.305: 228.63,166.2 228.27,166.56 R21032.2 228.27,167.63 228.37,167.73 Q34.2 Q34.5
  BOTTOM w0.508: v1(214.9,155.92) 213.76,157.06 213.76,159.99 218.07,164.29 227.86,164.29 228.63,165.07 228.63,166.2
  vias: v1(105.35,65.17) v1(105.94,65.62) v1(105.94,64.86) v1(106.7,65.62) v1(106.7,64.86) v1(141.24,125.95) v1(141.24,125.19) v1(142.01,125.95) v1(142.01,125.19) v1(154.12,105.27) v1(154.12,103.95) v2(160.35,120.87) v2(160.41,120.16) v2(161.84,120.9) v2(161.81,120.16) v2(161.81,119.46) v2(162.45,120.87) v2(164.55,120.87) v2(164.61,120.16)
+1.8V_S5:
  vias: v1(100.86,74.11) v1(116.35,66.39) v1(117.11,66.39) v3(101.21,75.81) v3(101.77,76.39) v3(102.28,75.81) v3(102.79,76.42) v3(108.33,75.51) v3(108.33,74.72) v3(109.04,75.2) v3(109.04,74.44)
+1.8VPCU: length 3.6
  TOP w0.14: PR66837.2 270.69,169.24 v1(271.06,169.61) 271.34,169.89 271.93,169.89 272.3,169.51 PR66866.1
+1V_GFX: length 4.2
  TOP w0.254: U13114.BC21 v2(157.61,119.46)
  BOTTOM w0.508: C95067.1 v1(155.85,101.54) C95074.1 ; v1(157.25,101.54) C95072.1 ; C95016.2 154.45,101.82 v1(154.71,101.57) 154.45,101.31 C95066.1
  vias: v1(162.48,65.55) v1(164.08,103.79) v1(167.71,103.62) v2(153.41,120.86) v2(153.41,120.16) v2(154.11,120.16) v2(155.51,120.16) v2(155.51,119.46) v2(156.18,120.82) v2(156.21,119.46) v2(157.61,120.86) v2(157.61,120.16) v2(158.26,120.84) v2(166.01,120.86) v2(166.01,120.16) v2(166.01,119.46) v2(166.71,120.86) v2(166.71,120.16) v3(160.04,66.13) v3(160.04,65.37) v3(160.8,66.13) v3(160.8,65.37) v3(161.56,66.13) v3(161.56,65.37)
+1V_GFX_PG: length 96.4
  TOP w0.14: R21608.1 127.88,116.61 v1(127.59,116.89) 127.26,117.22 127.09,117.22 126.92,117.39 U13118.2 ; v1(154.68,54.98) 155.6,55.91 PR9063.2 156.57,58.08 PR9077.2
  IN5 w0.089: v1(147.9,60.65) 147.72,60.47 146.22,60.47 145.14,61.55 130.46,61.55 129.05,62.96 129.05,67.4 127.03,69.43 127.03,71.66 125.52,73.17 125.52,84.17 126.67,85.32 126.67,89 128.26,90.59 128.26,93.11 127.48,93.9 127.48,100.14 128.31,100.98 128.31,107.72 126.66,109.36 126.66,112.59 127.9,113.82 127.9,115.14 127.53,115.51 127.53,116.83 v1(127.59,116.89)
  BOTTOM w0.14: v1(147.9,60.65) 147.9,60.27 150.67,57.5 150.67,55.64 150.95,55.36 150.95,54.73 151.25,54.42 154.12,54.42 v1(154.68,54.98)
+1V_GFX_S: length 4.3
  BOTTOM w0.508: PR67010.1 158.24,58.33 158.24,61.64 v1(157.8,62.07)
  vias: v1(159.33,61.79)
+1V_S5: length 6.3
  TOP w0.508: PQ9055.3 212.29,153.99 212.48,153.8 PR255.1 214.17,153.23 214.9,152.49 214.9,150.97 215.16,150.71
  vias: v1(284.27,80.86) v1(286.23,79.67) v1(286.76,80.05) v1(287.32,79.7) v1(291.82,79.26) v1(292.47,79.26) v1(292.55,78.2) v1(293.13,79.26) v1(293.21,78.2) v1(293.9,78.2) v3(210.89,94.58) v3(211.2,93.84) v3(211.65,94.53) v3(211.96,93.74) v3(212.41,94.43) v3(215.31,149.24) v3(215.72,149.88) v3(216.17,149.24) v3(216.53,149.93) v3(216.94,149.24) v3(217.29,149.93) v3(217.7,149.24) v3(218.05,149.93) v3(218.46,149.24) v3(218.82,149.93)
+1V_S5_ON: length 175.2
  TOP w0.14: PR115.2 247.11,161.79 247.64,162.32 248.24,162.32 248.71,162.78 v1(248.74,162.78)
  IN1 w0.089: v1(248.74,162.78) 247.55,163.97 237.28,163.97 235.07,161.76 235.07,159.47 231.82,156.22 231.82,156.2 231.8,156.18 231.8,153.76 228.24,150.2 224.26,150.2 222.27,152.19 216.59,152.19 214.17,149.77 214.17,142.01 219.72,136.46 220.74,136.46 223.21,133.99 223.21,131.37 221.88,130.04 221.88,129.75 219.99,127.86 219.99,117.96 217.39,115.36 215.46,115.36 205.72,105.61 205.72,97.72 203.96,95.96 203.96,93.23 201.12,90.39 201.12,85.37 206.52,79.98 206.52,77.54 206.06,77.08 206.06,76.54 206.52,76.08 206.52,74.8 205.79,74.07 205.62,74.07 205.2,73.65 204.34,73.65 203.96,74.03 201.34,74.03 199.71,72.41 187.69,72.41 184.74,69.46 179.93,69.46 179.39,68.93 v1(178.96,68.93)
  BOTTOM w0.14: R67333.2 179.06,65.96 178.08,66.94 178.08,67.35 178.96,68.24 v1(178.96,68.93)
+1V_S5_SRC:
  vias: v1(214.15,154.59)
+1V_S5_VIN:
  vias: v1(233.65,156.4)
+1V_SUS: length 391.1
  TOP w0.254: v1(308.81,45.64) 308.81,46.13 R21107.2 ; v1(229.78,126.65) 229.81,126.62 U41.H30 ; C755.1 C96159.1 273.07,130.3 273.43,129.94 v1(273.58,129.94) 273.6,129.94 274.16,129.38 R538.1 R539.1 ; v1(273.3,125.19) 273.23,125.19 272.98,125.43 272.35,125.43 272.31,125.47 C85.1 R544.1 271.17,125.47 270.91,125.22 R571.2 270.45,125.01 270.91,124.55 R20757.2 ; v1(284.3,84.73) 283.81,84.73 282.67,85.87 282.67,89.17 279.06,92.78 275.76,92.78 268.12,100.42 v1(268.12,100.52)
  TOP w0.508: v1(212.49,157.88) 212.49,157.85 211.5,156.86 PQ9055.1 211.27,153.24 PR255.2 211.28,152.41 211.36,152.33 PR86.1 ; v1(213.63,139.16) 214.02,139.54 Q20.3 211.22,140.17 210.84,139.79 210.84,132.17 211.37,131.64 R20751.1 211.87,130.25 212.59,129.53 v1(213.11,129.53)
  IN3 w0.508: v1(268.12,100.52) 268.45,100.52 270.76,102.84 270.76,109.8 269.92,110.63 269.92,112.32 266.06,116.18 266.06,121.22 267.51,122.67 267.51,123.51 268.45,124.45 270.33,124.45 271.44,125.57 272.92,125.57 v1(273.3,125.19) 273.73,125.19 274.19,125.65 274.19,129.33 v1(273.58,129.94) 273.3,130.22 273.3,132.38 274.19,133.27 274.19,139.95 273.39,140.75 273.39,144.49 274.09,145.19 274.09,167.74 v1(272.82,169.01)
  IN4 w0.254: v1(213.11,129.53) 213.17,129.53 215.18,127.52 216.27,127.52 217.66,126.12 223.35,126.12 224.38,127.16 225,127.16 225.56,127.72 228.72,127.72 v1(229.78,126.65)
  IN5 w0.254: v1(205.33,102) 204.77,102.56 204.77,108.24 211.11,114.58 211.11,127.53 v1(213.11,129.53) ; v1(284.3,84.73) 286.23,82.8 287.78,82.8 289.1,81.47 289.78,81.47 290.37,80.89 290.37,79.87 291.54,78.71 294.53,78.71 294.99,78.25 295.83,78.25 297.9,76.18 297.9,75.98 298.85,75.02 298.85,74.76 299.78,73.83 306.95,73.83 307.59,74.46 312.69,74.46 313.15,74.01 314.3,74.01 315.06,74.77 323.95,74.77 324.73,73.98 324.73,72.79 325.14,72.38 325.14,72.08 328.01,69.21 328.95,69.21 330.07,68.09 v1(330.07,67.86)
  IN5 w0.508: v1(272.82,169.01) 272.44,169.01 271.93,168.49 268.12,168.49 266.55,170.06 265.82,170.06 264.44,168.67 255.72,168.67 254.95,167.9 251.06,167.9 250.83,168.13 239.3,168.13 239.2,168.03 238.06,168.03 236.37,166.34 217.06,166.34 216.68,165.95 216.68,164.56 213.13,161 213.13,158.21 212.8,157.88 v1(212.49,157.88)
  BOTTOM w0.254: R20823.2 229.67,125.99 229.12,126.54 C260.1 229.62,126.81 v1(229.78,126.65) ; v1(308.81,45.64) 309.52,45.64 309.67,45.48 317.39,45.48 317.95,44.92 322.35,44.92 325.78,48.35 327.48,48.35 328.32,49.19 328.32,52.95 327.18,54.08 327.18,55.37 326.86,55.69 326.86,56.32 327.3,56.75 327.3,58.39 329.97,61.05 330.22,61.05 330.55,61.38 330.55,64.63 329.56,65.62 329.56,66.89 330.07,67.4 v1(330.07,67.86) ; R180.2 267.55,99.31 268.12,99.88 v1(268.12,100.52) ; PR43.1 PR41.1 PR44.1 269.35,168.46 269.64,168.75 PC9383.1 272.43,168.75 272.69,169.01 v1(272.82,169.01) ; v1(205.33,102) 205.94,102.61 R178.1
  BOTTOM w0.508: R20822.2 216.65,138.43 216.17,138.9 213.89,138.9 v1(213.63,139.16) 213.63,139.41 211.86,141.19 211.86,157.32 212.36,157.83 212.47,157.83 212.49,157.85 v1(212.49,157.88)
+2.5V: length 143
  TOP w0.508: PQ40.1 204.11,69.05 v1(204.13,69.08) ; PR298.1 107.91,55.79 108.78,56.66 v1(109.39,56.66) 110.21,56.66 110.51,56.96 110.51,59.22 111.7,60.42 111.7,61.41 v1(111.73,61.43)
  IN2 w0.508: v1(204.13,69.08) 203.47,69.08 200.96,71.59 196.41,71.59 195.8,72.2 194.29,72.2 193.25,73.24 189.38,73.24 188.5,74.12 184.64,74.12 184.08,74.68 181.32,74.68 180.77,74.12 178.32,74.12 176.17,71.97 175.08,71.97 174.77,71.67 174.77,71.09 175.18,70.67 175.46,70.67 176.17,69.96 176.17,68.89 174.87,67.59 168.65,67.59 166.96,65.89 166.96,63.93 166.2,63.18 155.74,63.18 155.11,63.81 149.33,63.81 148.28,64.86 140.46,64.86 140.28,65.04 135.76,65.04 134.81,64.09 130.83,64.09 130.51,63.78 128.91,63.78 127.81,62.68 123.87,62.68 123.21,62.02 121.79,62.02 120.72,63.08 113.81,63.08 112.16,61.43 v1(111.73,61.43)
  IN5 w0.508: v1(211.81,77.99) 211.7,77.99 209.23,75.53 209.23,69.85 209.34,69.74 209.34,68.88 209.04,68.57 v1(208.63,68.57) 208.63,64.84 v1(209.72,63.75)
  BOTTOM w0.508: v1(204.13,69.08) 207.94,69.08 208.45,68.57 v1(208.63,68.57) ; v1(209.72,63.75) 209.92,63.55 R67195.2 ; R67197.2 210.23,76.67 211.55,77.99 v1(211.81,77.99)
+2.5VSUS:
  vias: v1(204.01,72.91) v1(210.21,61.76) v1(210.94,61.76)
+3V: length 697.6
  TOP w0.203: v1(182.3,74.02) 181.76,73.48 R67366.2 ; v1(330.86,47.72) 330.73,47.84 C94823.1 ; v1(318.56,70.7) 319.05,70.7 R21204.2 ; v1(355.75,39.84) 355.78,39.87 R21039.1 ; R22214.2 30.5,57.62 v1(30.96,57.17) ; v1(137.36,62.96) 137.36,62.5 137.05,62.19 CN2076.10
  TOP w0.254: 128.54,115.03 128.8,115.28 R21587.1 ; R21216.2 320.39,72.72 v1(320.39,72.94) ; R223.1 327.22,76.47 v1(327.3,76.39) ; v1(50.32,59.89) 49.95,59.53 R22212.2 ; C94823.1 U13102.5 ; v1(318.59,66.36) 318.49,66.26 R21200.2 ; R21198.2 v1(318.56,64.1) ; R67239.2 302.66,81.47 v1(302.66,81.65) 302.25,82.06 300.48,82.06 300.25,81.83 R21178.2 ; R21090.2 v1(294.53,79.26) ; v1(312.82,47.92) 312.77,47.97 R21099.2 ; R21210.2 v1(318.41,71.7) ; R21205.2 v1(318.56,70.7)
  TOP w0.305: R22100.1 367.42,39.56 Q7930.5 Q7930.2 ; 317.52,81.63 Q7911.2 Q7911.5 314.98,81.63 314.72,81.36 R21172.1 ; Q7896.2 270,47.41 v1(269.72,47.13) 270,46.85 Q7896.5
  TOP w0.381: R22167.2 33.64,53.81 33.9,54.07 v1(33.9,54.14) ; R67148.1 321.96,75.82 321.74,76.04 321.74,76.14 v1(321.76,76.17) ; PR263.1 244.39,159.58 245.05,158.92 248.2,158.92 v1(251.94,162.65) ; L4258.1 330.1,63.2 v1(329.46,63.85) ; R20900.1 173.12,61.94 172.11,60.93 v1(172.11,59.66) ; v1(89.17,83.66) 89.05,83.66 88.66,83.27 PR97.1 ; R22168.2 45.49,53.65 45.11,53.26 44.5,53.26 v1(43.91,53.84) ; PR9121.2 120.94,75.4 v1(121.57,75.4) ; v1(239.67,165.7) 239.67,166.08 240.05,166.46 R20987.1 R20994.1 R20988.1 ; v1(318.43,69.51) 318.08,69.16 R21207.2 ; R22101.1 365.76,42.11 366.63,41.24 367.08,41.24 367.76,40.56 v1(367.99,40.56) 367.76,40.34 R22100.1 ; v1(332.28,65.62) 332.76,65.62 Q7917.2 ; Q7931.2 324.68,55.36 323.5,56.55 R67233.2 323.69,56.68 v1(324.1,57.09) ; R20974.1 253.64,169.69 v1(254.1,170.15) ; R21235.1 323.76,67.16 v1(324.23,66.69) ; v1(318.69,81.63) 318.55,81.76 R21174.1 317.66,81.76 317.52,81.63 ; v1(147.31,60.98) 147.82,61.48 PR9165.1 ; v1(127.27,114.2) 127.28,114.19 127.71,114.19 128.54,115.03 ; v1(268.35,169.89) 268.35,170.25 268.11,170.49 267.23,170.49 PR66851.2 ; R21327.1 323.95,65.24 324.43,65.73 v1(324.43,65.88) ; v1(30.96,57.17) 31.29,57.5 R22191.1 ; v1(121.94,67.5) 121.58,67.5 121.18,67.91 121.18,70.83 122.14,71.8 v1(122.14,72.08) ; v1(330.01,59.11) 330.01,59.36 329.75,59.62 R67235.2 329.08,59.62 328.96,59.5 Q7932.2 ; R22007.1 355.5,76.45 356.43,76.45 v1(356.66,76.22) ; R22001.2 v1(49.52,71.33)
  TOP w0.508: R22140.1 47.55,76.05 v1(47.87,76.37) ; Q7847.2 40.63,50.59 v1(39.82,51.4) ; v1(31.77,62.55) 31.77,62.2 31.63,62.06 R22163.2 ; R21053.2 267.66,45.73 v1(267.66,46.22) ; v1(318.66,79.85) 318.41,79.59 R222.1 ; R67025.1 267.49,47.9 v1(267.52,47.87) 267.88,48.23 R21052.2 268.25,48.23 268.9,48.89 270.25,48.89 270.58,49.22 270.58,50.41 v1(269.13,51.86) ; v1(268.14,51.83) 268.89,51.09 R21060.1 R21058.1 ; v1(37.17,89.53) CN2074.2
  IN1 w0.203: v1(182.3,74.02) 185.5,74.02 v1(187.1,75.62)
  IN1 w0.381: 342.03,87.92 341.52,88.43 340.61,88.43 339.24,87.05 v1(339.24,85.82) ; 342.03,87.92 342.03,86.71 v1(341.52,86.2) ; 342.03,87.92 342.54,88.43 344.29,88.43 345.36,89.5 349.02,89.5 350.34,90.82 354.12,90.82 v1(354.4,91.1) ; v1(329.46,63.85) 329.46,59.66 v1(330.01,59.11) 330.01,59.09 330.22,58.88 330.22,55.08 328.44,53.31 328.44,52.67 328.46,52.66 328.46,52.33 328.04,51.91 326.92,51.91 326.33,51.32 326.33,49.74 326.13,49.54 326.13,48.25 326.66,47.72 v1(330.86,47.72) ; v1(132.38,64.79) 132.38,66.74 131.72,67.4 131.72,69.69 132.33,70.3 v1(132.33,70.83) ; v1(17.55,8.09) 17.67,8.09 17.7,8.07 23.36,8.07 24.91,9.62 24.91,13.46 26.51,15.06 26.51,17.47 v1(27.33,18.28)
  IN1 w0.508: v1(314.23,79.16) 317.97,79.16 v1(318.66,79.85) ; 45.38,77.77 45.38,79.87 37.79,87.47 37.79,88.92 v1(37.17,89.53) ; v1(267.66,46.22) 267.52,46.36 v1(267.52,47.87) ; v1(168.52,66.56) 169.11,67.15 170.48,67.15 174.09,70.76 174.09,76.04 173.17,76.95 v1(172.05,76.95)
  IN2 w0.381: v1(115.59,69.18) 117.27,67.5 v1(121.94,67.5) 122.47,67.5 123.34,66.64 123.34,65.12 v1(124.48,63.97) ; v1(312.82,47.92) 312.82,49.46 314.11,50.74 314.11,51.93 315.74,53.56 v1(316.35,53.56)
  IN2 w0.508: v1(209.77,54.88) 209.77,56.02 209.06,56.74 209.06,63.26 209.09,63.29 ; v1(233.59,57.82) 233.59,60.76 233.23,61.12 215.5,61.12 215.08,60.7 215.08,57.95 v1(214.14,57.01) ; v1(302.66,81.65) 302.2,82.11 295.35,82.11 294.53,81.3 v1(294.53,79.26) ; v1(318.69,81.63) 318.66,81.6 v1(318.66,79.85)
  IN3 w0.381: v1(268.35,169.89) 268.35,170.15 267.8,170.69 265.23,170.69 264.92,171.01 264.92,171.52 264.33,172.1 258.77,172.1 256.05,169.38 254.53,169.38 ; v1(147.31,60.98) 146.79,61.5 138.16,61.5 137.36,62.3 v1(137.36,62.96) 137.36,63.54 136.8,64.1 132.61,64.1 132.38,64.33 v1(132.38,64.79) ; v1(367.99,40.56) 367.99,39.54 368.37,39.16 368.37,37.1 368.36,37.09 368.36,36.05 367.55,35.25 v1(367.5,35.25)
  IN3 w0.508: v1(209.77,54.88) 210.13,54.53 213.81,54.53 214.37,55.08 214.37,56.79 v1(214.14,57.01) ; v1(304.82,50.46) 304.26,49.9 303.02,49.9 301.69,48.58 291.96,48.58 291.21,49.33 289.27,49.33 287.77,50.82 270.17,50.82 v1(269.13,51.86) 269.11,51.83 v1(268.14,51.83) ; v1(318.69,81.63) 313.96,81.63 313.41,81.07 310.57,81.07 309.97,81.67 308.89,81.67 308.26,81.04 303.21,81.04 302.66,81.58 v1(302.66,81.65)
  IN3 w1.016: v1(173.63,85.31) 173.63,86.2 177.98,90.55 193.46,90.55 196.36,93.46 196.36,96.82 202.67,103.13 202.67,105.82 209.44,112.59 209.44,139.46 211.09,141.11 211.09,160.93 215.74,165.57 v1(215.79,165.57) 216.05,165.57 216.91,164.71 238.68,164.71 v1(239.67,165.7)
  IN4 w0.508: v1(354.4,91.1) 356.31,91.1 358.59,88.82 358.59,82.29 v1(358.63,82.25) ; v1(33.9,54.14) 33.9,53.71 33.55,53.36 32.68,53.36 30.96,55.08 v1(30.96,57.17) 30.96,57.95 31.77,58.77 v1(31.77,62.55)
  IN5 w0.381: v1(121.57,75.4) 122.4,76.23 122.4,77.78 122.68,78.05 122.68,98.64 123.21,99.18 123.21,108.7 126.16,111.65 126.16,112.73 126.8,113.37 126.8,113.72 v1(127.27,114.2)
  IN5 w0.508: v1(357.02,42.49) 358.13,42.49 360.17,44.53 362.13,44.53 364,42.65 366.61,42.65 367.99,41.28 v1(367.99,40.56)
  BOTTOM w0.203: v1(21.91,14.06) 21.91,13.63 21.64,13.35 C96223.1 21.2,12.21 21,12.01 U13156.5 ; R21203.2 319.05,70.93 318.41,71.57 v1(318.41,71.7) ; R20881.2 39.36,51.86 v1(39.82,51.4)
  BOTTOM w0.254: R21418.2 232.56,66.2 232.27,65.91 ; R21389.2 214.4,56.76 v1(214.14,57.01) ; v1(318.59,66.36) 318.49,66.26 R21195.2 ; v1(320.39,72.94) 320.34,72.99 R21202.2 ; R21089.2 321.3,57.12 v1(321.84,57.65) ; v1(318.56,70.7) 317.98,70.7 317.72,70.96 R21215.2 ; R813.2 178.05,57.47 177.58,57.47 ; R21201.2 318.23,65.37 v1(318.54,65.07) 318.94,65.47 R21316.2 ; v1(321.71,68.29) 322.47,67.53 322.5,67.53 R21194.2 ; R21088.2 318.28,59.76 318.84,60.32 318.84,60.57 v1(318.82,60.6) ; R21391.2 232.18,53.56 232.56,53.94 ; 301.24,78.83 300.88,78.48 R21093.2 R21177.2 302.12,78.09 302.43,78.4 R21176.2 R21092.2 ; v1(209.77,54.88) 210.21,54.45 R21390.2
  BOTTOM w0.305: 210.51,65.5 R21417.2 v1(209.7,66.01) ; v1(318.43,69.51) 318.61,69.69 R21328.1
  BOTTOM w0.381: R21359.1 318.46,60.67 318.54,60.6 v1(318.82,60.6) ; R21386.2 210.59,65.43 210.51,65.5 ; R21251.1 314.2,78.78 314.23,78.81 v1(314.23,79.16) ; R21193.2 326.44,64.23 v1(326.54,64.13) ; v1(30.73,44.62) 30.88,44.47 30.88,43.76 31.32,43.31 R67353.1 ; PR701.1 124.11,64.35 v1(124.48,63.97) 124.59,63.87 124.59,63.87 124.93,63.52 124.93,63.52 124.98,63.47 PR67199.2 ; R21132.1 323.62,56.61 v1(324.1,57.09) ; PR702.1 122.19,66.89 121.94,67.15 v1(121.94,67.5) ; R22138.1 58.37,75.48 59.05,76.17 v1(59.05,76.39) ; v1(215.79,165.57) 215.79,165.85 216.54,166.6 R22137.2 216.67,166.61 Q7901.2 ; R21313.1 320.19,67.66 320.44,67.4 320.95,67.4 321.71,68.16 v1(321.71,68.29) ; R20941.2 v1(339.24,85.82) ; R21212.2 318.38,71.72 v1(318.41,71.7) ; 232.27,65.91 231.9,65.54 231.9,62.37 233.59,60.68 v1(233.59,57.82) 233.59,55.79 233.07,55.27 233.07,54.45 232.56,53.94 ; R21311.1 R21309.1 327.64,72.33 327.17,71.86 v1(327.17,71.85) ; v1(26.49,45.18) 26.49,44.21 26.94,43.76 R67351.2 ; R21101.2 317.87,64.1 v1(318.56,64.1) ; 177.58,57.47 175.37,57.47 175.22,57.62 174.38,57.62 172.35,59.66 v1(172.11,59.66) ; R20943.2 342.29,85.44 v1(341.52,86.2) ; R67262.2 v1(17.55,8.09) ; v1(316.35,53.56) 316.35,53.43 316.93,52.86 R67231.2 ; R67370.2 375.73,18.55 v1(375.99,18.81) ; R21214.2 318.26,69.69 v1(318.43,69.51) ; v1(115.59,69.18) 115.72,69.05 PR67201.2 ; R20889.2 204.11,55.06 205.05,54.12 208.55,54.12 209.32,54.88 v1(209.77,54.88)
  BOTTOM w0.508: PR2016.1 176.63,85.06 176.16,85.52 175.08,85.52 174.86,85.31 v1(173.63,85.31) ; 301.24,78.83 301.87,79.47 301.87,80.86 v1(302.66,81.65) ; R67398.1 357.53,43 v1(357.02,42.49) ; v1(267.66,46.22) 269.21,46.22 269.72,46.73 v1(269.72,47.13) ; v1(172.11,59.66) 172.11,60.93 170.33,62.7 168.16,62.7 166.92,63.94 166.92,65.73 167.76,66.56 v1(168.52,66.56) ; v1(358.63,82.25) R20955.1
  vias: v1(27.71,18.81) v1(36.62,29.63) v1(36.62,28.97) v1(39.11,31.71) v1(39.77,31.71) v1(40.03,64.23) v1(47.19,76.75) v1(47.37,29.43) v1(47.67,77.23) v1(48.08,29.51) v1(48.08,28.85) v1(48.08,28.19) v1(48.23,77.69) v1(48.33,76.88) v1(48.64,78.22) v1(48.71,76.32) v1(49.75,50.66) v1(50.44,50.66) v1(51.43,31.49) v1(52.14,31.51) v1(55.75,39.08) v1(56.13,39.62) v1(58.19,28.24) v1(58.19,27.58) v1(58.26,25.39) v1(59.23,27.58) v1(66.21,47.82) v1(66.21,47.13) v1(122.31,72.72) v1(122.8,72.08) v1(122.97,72.72) v1(186.79,76.2) v1(187.43,76.2) v1(187.79,75.62) v1(209.7,68.06) v1(252.6,162.65) v1(319.17,75.63) v1(326.79,72.43) v1(330.07,69.82) v1(330.07,69.16) v1(355.37,71.47) v1(355.47,70.81) v1(355.98,71.21) v1(360.01,63.11) v1(360.32,63.69) v1(360.7,63.11) v3(40.53,62.7) v3(40.91,61.94) v3(41.3,62.7) v3(41.68,61.94) v3(42.06,62.7) v3(42.46,61.99) v3(47.52,54.32) v3(47.52,53.56)
+3V3PD: length 71.8
  TOP w0.14: v1(369.89,23.71) 369.62,23.98 U13155.H1 ; U13155.B1 366.62,24.32 366.08,23.77
  TOP w0.305: 366.08,23.77 365.53,23.22 v1(365.53,23.08) 365.53,22.59 366.29,21.83 C96013.2 ; v1(332.54,63.69) R67250.2 R67249.2 ; v1(358.19,37.43) 358.36,37.25 Q7926.2 ; v1(364.51,22.06) 365.15,21.43 R67133.2 ; Q7926.5 v1(360.9,37.25)
  IN1 w0.305: v1(332.54,63.69) 331.99,63.14 331.99,61.66 332.32,61.33 335.02,61.33 339.11,57.24 339.11,54.83 340.89,53.05 341.4,53.05 342.03,52.42 v1(342.03,51.35)
  BOTTOM w0.305: v1(358.19,37.43) 359.3,37.43 359.51,37.63 359.51,39.08 359.52,39.09 Q7949.5 359.52,39.74 359.47,39.8 359.47,40.3 359.52,40.35 Q7949.2 359.52,41.04 359.89,41.41 359.89,41.85 359.59,42.16 358.81,42.16 358.27,41.61 356.7,41.61 356.19,42.12 356.19,44.5 355.48,45.22 344.99,45.22 342.67,47.54 342.67,50.64 342.03,51.27 v1(342.03,51.35) ; Q7927.2 372.01,18.57 R67131.2 371.7,17.16 369.84,19.02 365.8,19.02 365.22,19.6 365.22,20.46 365.27,20.51 R67132.2 364.99,20.82 364.64,21.17 364.64,21.94 v1(364.51,22.06)
  vias: v1(366.14,36.29) v1(366.14,35.63) v1(369.47,34.61)
+3V_2.5V_VDDSPD-CHA: length 2.9
  TOP w0.254: CN2063.255 212.69,63.07 211.83,63.92 v1(211.45,63.92)
  vias: v1(212.14,64.46)
+3V_2.5V_VDDSPD-CHB: length 2.3
  TOP w0.254: CN2062.255 212.69,73.54 212.19,73.04
  TOP w0.381: v1(211.86,73.04) 212.19,73.04
  vias: v1(211.2,72.81)
+3V_AR: length 17.3
  TOP w0.254: v4(352.32,54.79) U21.H9
  TOP w0.381: R67149.2 v1(340.63,58.51)
  IN4 w0.508: v1(349.65,64.35) 349.65,64.23 348.13,62.71 348.13,61.99 348.44,61.68 354.01,61.68 356.23,59.45 357.63,59.45 v1(357.73,59.55)
  BOTTOM w0.508: v1(349.65,64.35) 349.28,63.98 R67150.2
  vias: v1(335.72,47.72) v1(336.32,48.71) v1(336.37,47.72) v1(337.03,47.72) v1(358.06,60.14) v1(358.62,59.81) v1(359.25,59.61)
+3V_DEEP_SUS: length 215.7
  TOP w0.203: v1(317.67,73.24) R21227.2 ; v1(299.69,81.5) 299.79,81.6 R21295.2
  TOP w0.254: v1(314.22,48.81) 314.34,48.93 R21317.1 ; R21223.2 319.65,73.47 319.81,73.63 R21220.1 ; v1(304.38,81.64) 303.68,80.94 R21287.2 ; v1(298.31,79.26) 298.31,78.89 298.6,78.6 R21082.2 ; v1(318.39,75.29) 318.11,75.29 R21221.2 ; R21224.2 v1(317.67,73.24) ; R21081.2 v1(297.58,79.26) ; v1(311.25,80.36) Q7909.5 ; R67227.2 320.77,62.07 v1(320.9,61.94) ; R67221.2 323.46,62.07 v1(323.84,61.69) ; U13098.5 320.84,46.36 C94809.1 321.11,46.74 v1(320.7,47.15) ; R21303.2 R21297.2 v1(321.15,63.21) ; Q7909.2 313.53,80.36 v1(313.96,80.79) ; v1(299.69,81.5) 299.46,81.27 R21079.2 R21080.2 ; v1(305.05,81.63) 305.05,81.32 305.33,81.04 R21289.2 ; R67214.2 296.13,79.59 295.96,79.42 295.7,79.42 v1(295.55,79.26) 295.68,79.14 R21084.2 R21083.2 ; R21149.1 322.32,59.02 323.08,59.78 R21298.2 v1(323.9,60.04) ; R21077.2 301.14,81.23 v1(300.87,81.5) ; v1(320.9,61.21) 320.75,61.05 R21151.1 ; R21126.1 v1(318.88,57.71)
  TOP w0.508: v1(310.79,81.68) 310.41,81.3 R21143.1 ; R21146.1 313.63,78.76 313.51,78.88 v1(313.51,79.16) ; v1(316.89,79.98) R21348.2 316.18,79.15 316.16,79.18 R21351.2 ; v1(306.85,81.63) 307.03,81.45 R21236.1 ; R17808.2 306.34,78.97 306.34,81.02 v1(305.71,81.65) ; R21124.1 v1(320.45,57.89) ; v1(312.44,79.29) 312.06,78.91 R21144.1 ; R21238.1 323.57,69.1 v1(324.17,68.5) 324.63,68.95 U13103.8 ; v1(320.42,75.28) 320.42,75 319.81,74.4 R21220.1 ; v1(320.82,68.11) 320.26,67.56 R21219.1 ; R21412.1 274.34,104.33 278.96,99.71 v1(279.17,99.71)
  IN1 w0.508: v1(279.17,99.71) 279.17,98.72 280.51,97.38 280.51,91.14 285.19,86.45 290.57,86.45 292.12,84.9 296.84,84.9 297.5,84.24 v1(297.5,83.91)
  IN2 w0.508: 295.75,78.55 294.63,77.44 290.93,77.44 v1(289.94,76.45)
  IN3 w0.508: v1(211.7,98.14) 211.88,97.96 213.28,97.96 214.22,98.9 269.01,98.9 272.08,101.97 276.91,101.97 v1(279.17,99.71)
  IN4 w0.508: v2(312.35,60.21) 312.66,59.91 317.39,59.91 317.93,59.38 v1(318.82,59.38) ; v1(211.7,98.14) 211.7,99.79 v1(214.4,102.48)
  BOTTOM w0.203: 312.79,71.31 R21226.2 R21228.2 311.01,71.31 310.71,71.01 R21283.1 ; v1(324.17,68.5) 324.76,67.91 C94824.2
  BOTTOM w0.254: R21130.1 323.97,59.96 v1(323.9,60.04) ; U53.5 211.31,98.86 C420.1 211.33,98.51 v1(211.7,98.14) ; v1(320.9,61.21) 320.36,60.67 R21153.1 ; R21078.2 297.94,78.27 297.58,78.63 v1(297.58,79.26) ; v1(325.52,65.62) 325.19,65.29 R21244.2 ; v1(318.88,57.71) 318.68,57.91 R21128.1 ; v1(300.87,81.5) 300.78,81.41 R21293.2 ; v1(305.05,81.63) 305.05,80.86 R21285.2 ; v1(304.38,81.64) 304.38,81.21 303.81,80.65 R21281.2 ; R67211.2 318.15,47.75 318.28,47.62 C94855.2 320.03,47.62 320.32,47.33 320.52,47.33 v1(320.7,47.15) ; R21301.2 320.64,61.69 v1(320.9,61.94) ; v1(324.76,60.04) 324.79,60.07 R67243.1 ; R21305.2 305.79,81.58 v1(305.71,81.65) ; R67225.2 323.46,62.07 v1(323.84,61.69) ; v1(214.4,102.48) 214.01,102.1 C812.1 213.42,102.36 U13064.5 ; v1(297.5,83.91) 298.11,83.31 R21164.2 298.57,83.31 299.23,82.64 299.23,81.96 v1(299.69,81.5)
  BOTTOM w0.508: R21343.2 312.84,60.71 v2(312.35,60.21) ; v1(315.62,51.65) 315.62,52.66 R21105.1 ; v1(326.36,65.68) 326.8,65.24 R21270.1 ; R21272.2 315.75,48.75 316.75,47.75 R67211.2 ; v1(306.9,51.2) 306.67,51.2 306.34,51.53 306.34,52.27 306.13,52.49 R21337.2 ; v1(312.41,77.28) 311.83,76.7 R21252.1 ; R21324.2 288.09,78.7 288.42,78.37 R21326.2 R67237.1 R67236.1 289.1,75.61 v1(289.94,76.45) ; v1(324.17,68.5) 323.82,68.85 R21254.1 ; v1(298.31,79.26) 298.31,79.14 299.04,78.42 R21335.2 ; v1(320.82,68.11) 320.31,68.62 R21230.1 ; v1(328.82,60.85) R21253.1 ; v1(325.9,66.49) R21240.2 ; R21232.2 v1(323.9,60.04)
  vias: v1(299.31,52.11) v1(301.77,51.02) v1(308.05,81.65) v1(315.95,51.12) v1(323.84,71.97) v1(324.51,71.97) v1(330.45,65.47) v1(330.65,66.11)
+3V_DVDD: length 36
  TOP w0.203: U13108.3 35.17,30.06 35.53,30.42 C95903.2
  IN3 w0.254: v1(35.43,52.67) 35.43,52.14 34.39,51.1 34.39,49.6 33.78,48.99 33.67,48.99 33.64,48.95 33.26,48.95 33.22,48.99 32.86,48.99 31.77,47.89 31.77,45.64 31.64,45.52 31.64,45.25 31.54,45.16 31.54,44.26 32.41,43.4 33.07,43.4 33.49,42.97 33.49,39.12 31.57,37.19 31.57,36.64 31.64,36.57 31.64,33.8 32.25,33.19 32.25,31.06 33.22,30.09 35.12,30.09 35.61,30.57 v1(35.61,31.61)
  BOTTOM w0.203: R21475.1 35.84,53.08 v1(35.43,52.67) 35.25,52.85 v1(35.25,53.36)
+3V_DVDD_IO: length 2.1
  TOP w0.178: v1(29.69,36.19) 29.81,36.19 30.25,35.75 30.25,35.4 29.94,35.09 U13108.18
+3V_EDP: length 53.2
  TOP w0.178: v1(331.64,71.85) 331.85,72.05 331.85,72.15 332.01,72.32 U13079.20 ; U13079.1 335.68,77.77 v1(336.16,78.25) ; U13079.6 v1(333.68,78.38) ; U13079.28 335.68,71.44 335.88,71.24 v1(336.29,71.24)
  TOP w0.254: v1(333.68,78.38) 333.43,78.63 C94649.1 332.96,78.58 C94650.1 ; C94658.1 335.99,79.53 C94648.1 336.02,78.8 336.02,78.39 v1(336.16,78.25) ; R20936.1 R20934.1 332.4,67.1 v1(332.58,67.1) 332.71,67.23 332.97,67.23 R20929.1 ; v1(335.5,67.76) 335.5,68.13 R20924.1
  BOTTOM w0.254: v1(331.64,71.85) 331.64,72.08 331.92,72.36 C94652.1 332.28,73.72 331.87,74.13 331.11,74.13 330.59,74.65 330.59,77.93 329.91,78.61 329.91,79.01 330.08,79.18 330.08,79.35 330.31,79.58 330.88,79.58 331.34,80.04 331.34,80.33 331.41,80.41 331.41,80.65 331.66,80.9 R20913.1 332.19,80.9 332.45,80.65 R20912.1 333.59,80.65 334.06,80.18 ; v1(336.29,71.24) 336.69,71.24 337.27,70.66 337.75,70.66 338.21,71.11 338.21,71.38 339.04,72.21 339.04,72.78 R67381.2 339.11,72.78 339.75,73.41 339.75,75.99 337.48,78.25 v1(336.16,78.25) 336.81,78.9 336.85,78.9 337.16,79.2 337.16,79.63 336.85,79.94 335.87,79.94 335.44,80.37 R20916.1 334.24,80.37 334.06,80.18 ; v1(336.29,71.24) 336.42,71.11 336.42,69.74 336.04,69.36 336.04,68.29 v1(335.5,67.76) 335.5,66.95 334.97,66.41 333.67,66.41 333.24,66.84 R20929.1 ; v1(336.29,71.24) 336.06,71.47 C94647.1 ; 334.06,80.18 334.06,80.03 333.68,79.66 v1(333.68,78.38)
  vias: v1(331.64,66.72)
+3V_KB_P: length 2.6
  TOP w0.254: v1(265.7,47.08) 266.1,47.48 R67025.2 265.65,47.9 265.23,47.48 U13093.27
+3V_LDO_EC: length 220
  TOP w0.254: v1(189.63,70.98) R823.2 190.17,70.17 190.33,70.33 R20887.2
  TOP w0.381: v1(176.55,67.1) 175.75,66.29 D19.1
  TOP w0.508: R20894.2 R388.2 187.79,70.91 v1(188.26,70.91)
  IN5 w0.381: v1(189.63,70.98) 189.15,71.47 188.49,71.47 188.26,71.24 v1(188.26,70.91) 188.23,70.88 v1(188.23,68.88) 187.55,69.56 184.96,69.56 184.68,69.28 184.68,68.49 184.53,68.34 181.73,68.34 v1(181.66,68.42) 181.58,68.34 178.7,68.34 178.07,67.71 177.16,67.71 v1(176.55,67.1) 175.1,65.65 175.1,64.84 173.48,63.21 173.48,60.88 172.79,60.2 172.79,59.59 171.76,58.55 171.52,58.55 170.37,57.4 166.34,57.4 165.78,57.95 164.39,57.95 164.37,57.94 164.11,57.94 162.99,56.81 157.23,56.81 156.66,57.38 149.85,57.38 149.18,58.06 142.9,58.06 142.39,58.56 134.31,58.56 133.66,57.91 125.77,57.91 125.66,57.8 118.65,57.8 117.55,58.89 115.23,58.89 114.93,58.6 114.93,58.6 113.97,57.64 111.88,57.64 111.3,57.06 108.56,57.06 107.41,55.91 100.18,55.91 99.56,55.29 92.4,55.29 90.86,53.74 85.05,53.74 82.5,51.19 77.59,51.19 76.72,52.06 73.33,52.06 72.57,52.82 69.3,52.82 67.4,54.73 67.4,55.23 67.86,55.69 67.86,56.66 67.53,56.99 67.53,57.96 67.79,58.21 67.79,59.06 65.91,60.94 v1(65.91,61.23) 64.37,62.77 63.3,62.77 62.43,63.64 62.43,65.78 59.49,68.72 56.96,68.72 56.07,67.84 55.24,67.84 49.6,62.2 46.04,62.2 44.98,63.26 44.98,63.31 38.23,63.31 37.34,62.42 32.51,62.42 31.49,61.41 31.49,59.16 29.51,57.17 29.51,56.18 28.62,55.29 v1(28.62,54.98)
  BOTTOM w0.254: R67364.2 181.48,68.6 v1(181.66,68.42)
  BOTTOM w0.381: v1(176.55,67.1) 177.79,65.85 177.79,63.68 178.26,63.22 R816.2 ; v1(188.23,68.88) 188.23,68.44 187.83,68.04 R20901.1 188.49,67.37 188.78,67.66 R382.2 ; R22145.1 v1(189.63,70.98) ; v1(65.91,61.23) 65.91,62.3 66.56,62.95 PR287.2 PR312.2 ; R67293.1 28.39,54.45 28.62,54.68 v1(28.62,54.98)
+3V_MINIDP:
  vias: v1(252.7,170.15)
+3V_RTC: length 304.6
  TOP w0.305: U13113.BA22 311.45,63.01 311.12,63.34 310.66,63.34 v2(310.54,63.47)
  TOP w0.381: R21231.2 321.16,56.91 v1(321.16,58)
  TOP w0.457: v1(45.97,69.71) 46.15,69.89 46.15,70.73 45.87,71.01 D8568.3
  TOP w0.508: R618.1 R251.1
  TOP w0.635: R251.1 v1(176.18,71.67) 176.36,71.85 v1(177.83,71.85)
  IN2 w0.635: v1(202.13,69.33) 200.88,70.58 196.49,70.58 195.52,71.54 194,71.54 193.26,72.28 187.55,72.28 187.38,72.44 184.87,72.44 183.99,73.32 178.58,73.32 177.83,72.57 v1(177.83,71.85)
  IN3 w0.635: v1(202.13,69.33) 202.2,69.33 209.42,76.56 209.42,77.23 213.79,81.6 275.52,81.6 280.96,76.16 280.96,74.75 283.99,71.72 283.99,71.72 285.77,69.94 289.94,69.94 293.01,66.87 293.01,66.51
  IN5 w0.635: v1(45.97,69.71) 45.97,71.26 47.9,73.19 49.91,73.19 50.55,72.55 51.72,72.55 52.37,73.19 57.2,73.19 58.54,71.85 59.94,71.85 61.62,70.17 61.62,69 63.13,67.49 68.46,67.49 69.09,66.86 69.09,66.12 70.99,64.22 77.07,64.22 78.71,65.85 81.27,65.85 82.24,64.89 85.41,64.89 86.23,65.7 91.99,65.7 94.08,63.62 100.07,63.62 100.4,63.29 103.93,63.29 104.26,62.96 106.07,62.96 108.25,60.77 115.31,60.77 117.31,62.77 121.59,62.77 122.15,62.21 125.4,62.21 127.27,60.34 130.22,60.34 130.98,61.1 144.95,61.1 146.12,59.94 151.72,59.94 151.87,60.08 156.41,60.08 157.15,59.34 157.15,59.27 162.1,59.27 162.44,59.62 163.51,59.62 163.8,59.91 167.37,59.91 167.5,60.04 170.22,60.04 171.77,61.59 171.77,63.97 172.49,64.69 172.49,65.75 177.83,71.09 v1(177.83,71.85)
  BOTTOM w0.254: 324.43,56.46 C94811.1
  BOTTOM w0.381: v1(324.4,56.48) 324.43,56.46 324.96,56.46 325.39,56.03 325.39,55.08 325.57,54.9 325.57,53.95 325.28,53.66 R21142.1 325.28,49.17 324.98,48.88 R21137.1
  vias: v1(315.87,63.16)
+3V_RTC_1: length 19.7
  TOP w0.508: R21138.1 46,75.35 43.26,78.1 36.7,78.1 35.94,77.33 Q7935.1 34.11,77.79 v1(34.11,78.45) CN2054.1
+3V_RTC_2: length 4.5
  TOP w0.14: v1(45.44,70.48) 45.21,70.7 D8568.1
  TOP w0.508: D8568.1 45.21,74.41 45.22,74.43 R21138.2
+3V_S5: length 326.5
  TOP w0.203: v1(353.97,71.54) U13143.16
  TOP w0.508: PR310.1 v1(190.8,77.66) 190.49,77.97 189.86,77.97 189.07,77.18 188.49,77.18 188.07,76.77 PR311.1 ; v1(332.63,62.83) 332.12,62.83 L4259.1 331.69,63.9 331.76,63.97 R67250.1 ; R966.1 173.92,60.38 v1(174.49,59.81)
  IN1 w0.508: v1(349.91,63.21) 348.01,65.1 348.01,65.14 347.74,65.41 346.64,65.41 345.27,64.04 344.32,64.04 343.71,64.65 342.94,64.65 342.06,65.52 337.49,65.52 336.45,66.56 335.98,66.56 335.97,66.55 335.36,65.95 335.19,65.95 334.16,64.91 334.16,64.35 v1(332.63,62.83)
  IN2 w0.508: v1(349.91,63.21) 349.91,63.59 350.29,63.97 350.29,66.01 350.92,66.64 353.66,66.64 355.37,68.34 355.37,69.94 353.97,71.34 v1(353.97,71.54)
  IN3 w0.508: 316.53,57.42 318.05,57.42 318.46,57.01 318.46,56.46 318.82,56.1 323.95,56.1 324.33,55.72 326.28,55.72 326.79,56.23 326.79,57.12 327.55,57.88 329.97,57.88 331.62,59.53 331.62,62.08 332.37,62.83 v1(332.63,62.83)
  IN3 w0.762: 277.39,66.89 276.91,66.41 211.78,66.41 210.59,65.22 210.59,63.53 209.51,62.45 207.92,62.45
  IN3 w1.27: 190.57,61.15 191.26,60.47 191.94,60.47 191.99,60.52 193.24,60.52 194.08,59.68 194.08,56.36 ; 198.72,55.26 198.9,55.08 202.86,55.08 206.42,58.64 207.23,58.64 207.92,59.33 207.92,62.45 205.89,64.48 205.89,68.04 206.52,68.67 206.52,69.31 212.11,74.9 214.52,74.9 214.97,75.34 214.97,78.39 216.35,79.77 273.83,79.77 275.86,77.74 275.86,75.91 277.64,74.13 277.64,71.59 277.39,71.34 277.39,66.89 279.12,65.17 279.12,64.66 284.2,59.58 286.84,59.58 286.91,59.66
  IN5 w0.508: v1(190.8,77.66) 192.17,76.29 192.17,71.26 v1(191.46,70.55) 190.91,70.55 189.23,72.23 187.98,72.23 187.52,71.77 180.06,71.77 179.32,72.51 175.66,72.51 173.12,69.97 173.12,67.53 169.74,64.15 169.74,63.19
  BOTTOM w0.254: v1(353.97,71.54) 353.77,71.34 C94990.2 C94989.2 ; 125.81,49.76 R67300.2 126.66,49.51 Q7939.2
  BOTTOM w0.508: 125.81,49.76 123.76,49.76 118.23,55.29 118.23,58.59 118.96,59.31 119.36,59.31 120.44,60.39 120.44,61.84 120.49,61.89 v1(120.49,61.99) ; v1(191.46,70.55) 191.24,70.33 R22146.1
  vias: v1(31.64,56.56) v1(43.07,64.53) v1(129.94,64.48) v1(287.09,58.05) v1(289.59,50.38) v1(290.24,50.26) v1(290.9,50.23) v1(291.64,59.53) v2(293.31,58.94) v3(44.09,66.01) v3(44.09,65.12) v3(44.72,65.55) v3(44.72,64.71) v3(129.81,68.93) v3(129.81,68.16) v3(130.58,68.93) v3(130.58,68.16) v3(169.92,60.77) v3(170.45,61.31)
+3V_SSD1:
  vias: v1(57.2,21.99) v1(57.65,22.52) v1(60.88,25.21) v1(61.62,26.71) v1(62.33,26.71) v1(63.39,26.71) v1(64.23,26.69) v1(65.22,26.69) v1(66.16,26.71) v1(70.25,22.34) v1(75.18,22.17) v1(75.18,21.51)
+3V_SSD2:
  vias: v1(29.92,21.07) v1(30.07,21.99) v1(30.47,21.4) v1(37.56,26.28) v1(38.12,27.3) v1(38.78,27.17) v1(39.44,27.14) v1(43.89,25.98) v1(44.55,25.98) v1(45.21,25.98) v1(48.03,22.14) v1(48.15,22.98) v1(48.58,22.47)
+3V_TYPEC_DP: length 25
  TOP w0.178: U13025.1 335.76,59.11 ; U13025.6 333.43,60.23 333.34,60.32 C94544.1 ; U13025.20 331.55,53.9 331.16,53.51 ; U13025.28 335.43,52.92 335.68,52.67
  TOP w0.203: 335.68,52.67 335.88,52.47 336.92,52.47 336.97,52.42
  TOP w0.254: R67382.2 336.73,52.18 C94545.1 336.73,51.07 v1(336.85,50.94) 336.82,50.94 336.39,50.51 335.56,50.51 R20841.1 ; 335.76,59.11 336.16,59.11 336.62,59.58 C94542.1 336.32,60.45 336.12,60.64 336.12,61.05 R20827.2 335.61,62.01 335.43,62.2 333.72,62.2 ; R20833.2 331.36,48.73 331.4,48.76 C95998.1 332.13,48.76 332.16,48.73 R20836.2 332.76,48.35 v1(332.25,47.84) ; v1(331.31,52.92) 331.06,52.67 C94543.1 330.7,53.05 331.16,53.51
  IN2 w0.254: v1(336.85,50.94) 334.77,48.86 333.27,48.86 v1(332.25,47.84)
  vias: v1(332.49,61.87) v1(333.14,61.87)
+3V_U3_R: length 12.8
  TOP w0.203: v1(25.42,47.51) 25.45,47.53 U13124.25 ; U13124.9 31.69,49.93 C95896.1
  TOP w0.381: v1(31.34,50.56) 31.71,50.56 C95896.1 ; R22048.2 30.87,54.33 31.19,54.02 v1(31.19,53.2)
  TOP w0.508: v1(25.78,42.61) R21692.1 R21691.1
  BOTTOM w0.254: C95510.1 C95509.1 25.4,47.49 v1(25.42,47.51)
  BOTTOM w0.508: C95896.1 31.64,50.26 v1(31.34,50.56) ; R21695.2 v1(26.31,51.35) ; v1(30.08,46.03) R21686.1 R21687.1
  vias: v1(25.93,55.21) v1(27.27,55.06) v1(27.96,55.03) v1(29.36,55.21) v1(30.55,52.9)
+3V_UIF: length 29.1
  TOP w0.14: U13152.27 377.89,7.69 379.1,7.69 v1(379.14,7.65)
  TOP w0.254: 374.77,17.26 v1(374.8,17.26) ; 374.77,17.26 374.77,17.26 374.77,17.27 374.87,17.27 375.25,17.65 R67027.2 ; 374.77,17.26 374.84,17.2 374.84,16.8 373.81,15.76 R67028.2 373.36,15.96 373.03,16.29 Q7916.2 Q7916.5 ; R67303.1 378.55,12.07 v1(378.56,12.08)
  IN3 w0.254: v1(374.8,17.26) 374.81,17.27 377.1,17.27 377.3,17.47 377.68,17.47 378.01,17.14 378.01,16.82 377.62,16.43 377.62,13.1 378.02,12.69 378.02,12.62 v1(378.56,12.08)
  BOTTOM w0.254: R67369.2 374.88,17.19 v1(374.8,17.26) 374.78,17.26 374.77,17.25 374.77,17.12 374.16,16.52 374.16,15.49 374.5,15.14 374.5,14.98 Q7948.2 ; R67386.1 379.07,5.93 378.28,6.72 R67024.2 378.31,6.84 379.11,7.65 v1(379.14,7.65) 379.14,7.93 379.36,8.15 C96257.1 379.31,8.6 379.31,9.38 379.65,9.72 C96256.2 379.65,10.66 379.76,10.77 R67389.2 379.76,11.44 379.5,11.7 378.94,11.7 v1(378.56,12.08)
+3VA: length 12.3
  TOP w0.254: U13150.14 17.17,18.38 17.07,18.48 C95980.2 ; U13150.12 v1(18.83,20.63)
  TOP w0.305: U13151.1 18.58,30.31 v1(18.99,30.73) ; v1(12.36,31.53) 12.45,31.61 Q7915.2 Q7915.5 14.83,31.61 15.13,31.92 15.63,31.92 R67017.2
  TOP w0.381: R67016.2 v1(12.36,31.53)
  TOP w0.508: R67017.2 15.67,32.22 v1(16.12,32.68)
  BOTTOM w0.203: R67012.1 17.81,31.92 18.3,31.43 C95977.1
  BOTTOM w0.254: v1(15.74,19.14) 15.8,19.2 R67328.1
  BOTTOM w0.508: C95977.1 v1(18.99,30.73)
  vias: v1(14.04,18.33) v1(16.4,19.17) v1(22.96,19.48)
+3VPCU: length 836.3
  TOP w0.203: v1(227.91,149.28) 227.84,149.21 PC5653.1 227.65,148.49 227.65,147.85 228.07,147.43 PU43.12 ; v1(235.96,154.02) 236.4,154.45 PC5600.1 237.25,154.13 PU38.20 ; v1(91.46,75.86) PR66968.1
  TOP w0.254: R67246.1 v1(47.29,71.5)
  TOP w0.305: PR66968.1 92.66,78.04 PC9377.1
  TOP w0.381: R22156.2 199.08,67.53 v1(199.21,67.4) ; v1(342.23,64.51) 341.8,64.94 339.69,64.94 339.49,64.74 336.62,64.74 336.16,64.28 334.79,64.28 334.67,64.41 R67249.1 334.29,63.84 334.88,63.25 L4264.1 ; R67285.1 40.46,32.17 39.71,32.92 39.27,32.92 v1(39.26,32.93) ; v1(146.17,74.77) 146.17,74.49 145.49,73.81 PR9003.1 ; v1(175.43,71.34) 175.43,72.2 175.27,72.36 R20898.1 ; v1(183.99,70.98) 184.02,70.96 R20896.2 ; v1(185.44,71.04) 185.44,70.71 R20895.2 ; R20966.1 R20968.2 v1(237.13,168.62) ; v1(235.55,49.83) 237,51.27 243,51.27 243.71,51.99 v1(243.76,51.99) ; v1(259.81,169.38) 259.96,169.23 259.96,168.87 PR66884.2
  TOP w0.457: PQ9087.1 66.7,52.74 68.46,52.74 68.92,53.2 68.92,54.34 PR67240.1
  TOP w0.508: v1(67.2,60.65) 67.93,59.92 69.26,59.92 v1(69.6,59.58) 70.14,59.03 73.48,59.03 75.15,60.71 v1(76.24,60.71) ; R22155.2 R22156.2 ; PQ9087.1 64.51,53.75 64,54.26 64,56.21 63.65,56.56 v1(63.65,57.24) 64.39,57.24 PQ9088.1
  IN1 w0.381: v1(378.68,8.37) 378.53,8.37 378,8.91 378,9.82 379.24,11.07 379.24,12.23 v1(378.76,12.72) ; v1(43.45,52.72) 41.09,52.72 v1(39.57,54.25)
  IN2 w0.381: v1(183.99,70.98) 183.99,71.77 183.92,71.85 ; v1(342.23,64.51) 342.59,64.15 342.59,63.36 341.83,62.6 341.83,61.87 342.64,61.05 344.29,61.05 344.93,60.42 344.93,59.63 344.49,59.2 344.49,57.42 343.05,55.97 343.05,53.08 v1(342.74,52.77) ; 183.92,71.85 185.57,71.85 ; 183.92,71.85 180.61,71.85 179.24,70.48 176.88,70.48 176.02,71.34 v1(175.43,71.34) ; 185.57,71.85 185.44,71.72 v1(185.44,71.04) ; 185.57,71.85 186.71,71.85 186.96,71.59 190.01,71.59 190.43,71.17 191.83,71.17 192.7,70.3 193.01,70.3 v1(193.54,69.77)
  IN2 w0.508: 258.49,148.17 v1(258.49,151.05) ; 245.2,147.95 245.14,148 245.14,152.37 244.52,152.99 244.52,153.48 v1(244.75,153.71) ; 251.12,147.95 251.23,148.05 251.23,153 v1(251.96,153.74) ; v1(63.65,57.24) 63.16,57.24 62.82,57.58 62.82,60.74 v3(64.16,62.07)
  IN2 w0.762: v1(259.81,169.38) 259.81,168.9 260.19,168.52 265.88,168.52 265.93,168.47 268.98,168.47 271.55,165.9 271.55,160.75 272.44,159.86 272.44,157.3 271.04,155.9 271.04,155.03 270.66,154.65 270.66,152.24 269.72,151.3 v1(266.39,151.3) 267.67,150.02 267.67,147.32 266.67,146.32 264.64,146.32 263.62,147.34 259.33,147.34 258.49,148.17 257.65,147.34 251.73,147.34 251.12,147.95 243.33,147.95 241.19,150.08 241.19,152.24 239.42,154.02 v1(235.96,154.02) 235.87,154.02 230.7,148.85 228.34,148.85 v1(227.91,149.28)
  IN3 w0.381: v1(231.36,49.62) 231.36,49.72 231.6,49.95 235.43,49.95 v1(235.55,49.83) ; v1(207.06,54.7) 207.06,54.63 209.11,52.57 226.26,52.57 226.46,52.77 242.67,52.77 243.45,51.99 v1(243.76,51.99) 244.01,51.99 244.54,52.52 266.62,52.52 267.84,51.3 268.95,51.3 269.95,50.3 287.49,50.3 287.58,50.21 288.99,48.81 291,48.81 291.74,48.06 301.91,48.06 302.63,48.78 311.87,48.78 313.52,50.43 316.75,50.43 317.47,49.72 320.8,49.72 321.06,49.46 321.96,49.46 322.24,49.73 323.88,49.73 325.56,51.42 328.31,51.42 329.37,50.37 339.73,50.37 340.51,51.15 340.51,51.53 341.4,52.42 342.39,52.42 v1(342.74,52.77)
  IN3 w0.508: v1(146.17,74.77) 147.09,73.85 147.09,67.78 148.99,65.88 153.69,65.88 153.94,66.13 155.09,66.13 155.72,65.5 155.72,64.74 156.31,64.15 161.25,64.15 163.47,66.37 163.47,66.9 166.05,69.49 172.16,69.49 173.84,71.17 175.27,71.17 v1(175.43,71.34) 175.56,71.47 175.56,75.25 173.04,77.77 173.04,83.45 174.69,85.1 174.69,85.25 176.51,87.06 176.51,87.62 178.49,89.61 197.06,89.61 200.25,92.79 200.25,97.71 204.57,102.02 204.57,105.12 211.98,112.54 211.98,134.71 213.51,136.24 214.27,136.24 214.52,135.98 216.5,135.98 220.82,140.3 225.45,140.3 227.65,142.51 227.65,149.02 v1(227.91,149.28)
  IN4 w0.381: v1(378.76,12.72) 378.02,12.72 377.06,13.68 377.06,15.08 376.52,15.61 376.52,17.16 376.13,17.56 375.32,17.56 374.95,17.92 374.6,17.92 v1(374.6,17.93) 374.59,17.93 374.36,17.93 373.67,18.61 369.47,18.61 369.26,18.82 366.2,18.82 365.12,19.9 365.12,22.27 364.71,22.67 364.71,28.19 365.73,29.2 365.73,30.72 364.92,31.53 364.92,37.46 365.2,37.74 365.2,39.62 365.43,39.85 365.43,41.21 365.04,41.6 365.04,52.09 364.31,52.82 363.65,52.82 362.86,53.61 362.86,59.38 361.19,61.05 360.73,61.05 358.82,62.96 358.03,62.96 357.65,63.34 357.65,71.85 356.64,72.86 v1(355.44,72.86) ; v1(43.45,52.72) 44.14,52.72 46.3,50.56 47.14,50.56 49.68,48.02 49.68,43.18 44.77,38.28 44.77,36.14 43.44,34.8 40.09,34.8 39.69,34.41 39.34,34.41 38.81,33.87 38.81,33.39 v1(39.26,32.93) 37.68,32.93 35.53,30.78 35.53,28.85 32.3,25.62 31.84,25.62 26.24,20.02 26.24,14.89 25.04,13.68 25.04,10.51 23.13,8.6 v1(18.19,8.6) ; v1(345.23,88.59) 338.58,88.59 336.42,86.43 v1(333.98,86.43)
  IN4 w0.508: v1(39.57,54.25) 38.22,54.25 37.23,55.24 37.23,58.77 38.63,60.16 38.63,69.18 43.43,73.98 v3(43.43,75.02) ; v1(237.13,168.62) 237.13,167.35 235.35,165.57 235.35,157.06 227.91,149.62 v1(227.91,149.28)
  BOTTOM w0.305: R67175.2 373.75,19.28 374.21,18.82 374.21,18.46 374.59,18.08 374.59,17.93
  BOTTOM w0.381: PR183.2 76.85,69.35 76.45,68.95 v1(76.13,68.95) ; PR66838.2 261.13,167.81 260.25,168.69 ; RP1.10 232.18,48.8 v1(231.36,49.62) ; v1(235.55,49.83) 235.55,49.93 235.26,50.22 RP1.5 ; v1(76.24,60.71) 76.24,61.67 75.89,62.02 75.39,62.02 PR204.2 ; 260.25,168.69 259.81,169.13 v1(259.81,169.38) ; 260.25,168.69 PR66832.1 PR66931.1 PR66932.1 PC5667.1 ; R67273.1 309.34,82.47 309.62,82.74 320.34,82.74 321.08,82.01 321.08,80.35 321.39,80.04 330.69,80.04 330.86,80.2 330.86,83.27 333.98,86.39 v1(333.98,86.43) ; v1(193.54,69.77) 194.25,69.77 194.38,69.64 195.83,69.64 198.06,67.4 v1(199.21,67.4) 199.21,67.25 200.4,66.06 201.67,66.06 201.83,65.9 203.17,65.9 205.81,63.26 205.81,58.67 205.89,58.59 205.89,55.12 206.31,54.7 v1(207.06,54.7) ; PR18.2 162.17,56.24 163.01,55.41 163.68,55.41 164.03,55.76 165.26,55.76 166,56.5 166,61.9 164.36,63.55 164.36,67.23 165.91,68.78 171.7,68.78 172.61,69.68 172.61,71.07 172.54,71.14 172.54,71.85 172.92,72.23 174.54,72.23 v1(175.43,71.34) ; 374.59,17.93 v1(374.6,17.93) ; R67263.2 v1(18.19,8.6)
  BOTTOM w0.508: PR9.2 69.26,59.92 v1(69.6,59.58) ; v1(67.2,60.65) 66.95,60.39 PR15.2
  vias: v1(36.09,76.32) v1(344.7,64.63) v1(344.83,65.37) v1(345.56,65.4) v1(345.89,88.56) v1(346.55,88.56) v1(354.76,72.71) v1(354.96,73.35) v3(36.72,75.56) v3(37.1,76.27) v3(37.56,75.56) v3(37.94,76.24) v3(38.42,75.56) v3(38.76,76.27) v3(42.67,75.07) v3(44.17,75.38) v3(63.07,65.48) v3(63.35,64.18) v3(63.65,63.47) v3(63.81,64.79) v3(63.86,65.55) v3(64.14,64.08) v3(64.62,65.4) v3(64.64,64.64) v3(67.07,66.6) v3(67.63,65.98) v3(67.87,66.71) v3(68.13,65.28) v3(68.37,66.12) v3(85.92,80.94) v3(86.48,81.53) v3(92.7,78.99) v3(93.47,78.99)
+3VPCU_EC: length 63.3
  TOP w0.178: U49.50 186.8,52.75 186.94,52.88 v1(186.94,53.15)
  TOP w0.203: U49.114 185.6,66.22 v1(185.82,66.01) ; v1(183.14,66.01) 182.8,66.35 U49.121 ; U49.26 179.33,55.6 v1(179.73,55.21) ; v1(192.88,63.72) 193.16,64 U49.92
  TOP w0.508: v1(180.87,71.04) 180.77,71.14 180.26,71.14 179.85,70.73 L4238.2
  IN2 w0.381: v1(179.73,55.21) 179.73,54.93 180.49,54.17 185.77,54.17 186.79,53.15 v1(186.94,53.15) 186.94,52.9 187.8,52.04 189.96,52.04 190.82,52.9 190.82,54.32 190.41,54.74 190.41,56.6 189.81,57.19 v1(189.81,57.6)
  IN4 w0.381: v1(192.88,63.72) 192.88,63.92 192.43,64.38 191.26,64.38 190.45,63.57 187.88,63.57 186.89,64.56 v1(186.89,65.9) 185.92,65.9 v1(185.82,66.01) 184.55,64.74 184.04,64.74 183.66,65.12 183.66,65.55 183.32,65.9 183.25,65.9 v1(183.14,66.01)
  IN5 w0.381: v1(189.81,57.6) 189.81,57.69 193.44,61.32 193.44,63.21 192.93,63.72 v1(192.88,63.72)
  BOTTOM w0.203: C94640.1 179.47,55.46 v1(179.73,55.21) ; v1(186.94,53.15) 186.55,53.54 C94638.1 C94639.1 ; 185.82,66.26 C94635.1
  BOTTOM w0.254: C94636.1 186.71,66.08 v1(186.89,65.9)
  BOTTOM w0.381: C94637.1 193.01,63.85 v1(192.88,63.72) ; v1(189.81,57.6) 189.81,57.43 190.3,56.94 L13.1 ; v1(186.89,65.9) 187.15,66.17 R20901.2 ; v1(183.14,66.01) 182.85,66.01 C94634.1 180.97,67.08 180.36,67.68 180.36,69.31 179.98,69.69 179.98,70.7 180.41,71.14 180.77,71.14 v1(180.87,71.04)
  BOTTOM w0.508: v1(185.82,66.01) 185.82,66.26
+3VPCU_ECPLL: length 3.4
  TOP w0.203: U49.127 180.4,68.79 180.87,69.26 C94642.1 180.07,69.34 L4238.1
+5V: length 287.4
  TOP w0.508: U13161.1 23.73,16.21 24.96,14.98 v1(25.53,14.98) ; v1(330.58,79.01) 330.22,78.66 R230.2 ; v1(45.89,48.78) 45.91,48.81 45.91,49.19 C94921.2 44.85,48.73 Q7845.3 ; Q7833.3 v1(233.52,166.97) ; PR126.1 31.63,63.37 31.14,63.87 v1(31.14,64.46) ; R22143.2 87.17,79.83 v1(87.17,79.52) ; v1(38.37,89.45) 38.42,89.5 CN2074.1
  IN1 w0.508: v1(269.13,135.27) 270.2,135.27 273.48,132 273.48,130.88 274.19,130.17 274.19,125.04 273.41,124.26 271.95,124.26 270.69,123 269.18,123 267.96,121.78 267.96,115.9 269.94,113.92 272.04,113.92 273.53,112.44 273.53,110.79 273.73,110.58 273.73,109.31 275.13,107.92 275.13,106.98 275.72,106.39 275.72,103.77 277.49,102 277.49,98.75 279.8,96.44 279.8,89.66 282.19,87.27 282.19,85.41 284.25,83.35 v1(284.25,81.93) ; v1(233.52,166.97) 234.16,167.61 238.65,167.61 239.39,168.35 250.74,168.35 251.35,167.73 255.29,167.73 256.18,168.62 262.66,168.62 263.42,169.38 265.45,169.38 265.96,169.89 266.72,169.89 267.99,168.62 269.87,168.62 v1(270.73,167.76) ; v1(27.02,22.67) 27.02,19.04 24.65,16.67 24.65,15.31 24.98,14.98 v1(25.53,14.98)
  IN2 w0.508: v1(45.89,48.78) 44.8,47.69 44.8,46.68 44.04,45.91 43.07,45.91 41.17,44.01 v1(41.17,42.84)
  IN3 w0.508: v1(284.25,81.93) 285.34,80.83 287.51,80.83 289.98,78.36 290.67,78.36 291.49,77.54 294.39,77.54 294.9,78.05 300.62,78.05 301.32,77.35 304.92,77.35 305.19,77.62 306.56,77.62 307.66,76.52 310.29,76.52 310.6,76.82 311.91,76.82 312.24,76.49 315.56,76.49 317.35,78.28 322.08,78.28 324.02,76.34 v1(324.25,76.34) 324.35,76.34 326.45,78.44 330,78.44 v1(330.58,79.01)
  IN5 w0.508: v1(270.73,167.76) 272.1,166.39 272.1,165.37 273.59,163.88 273.59,144.71 272.37,143.49 272.37,140.76 269.13,137.52 v1(269.13,135.27)
  BOTTOM w0.254: v1(52.04,76.06) 52.06,76.09 R22141.1
  BOTTOM w0.508: v1(284.25,81.93) 281.73,81.93 281.33,82.34 280.26,82.34 279.67,81.75 279.67,78.58 282.11,76.14 282.11,72.35 282.35,72.11 282.35,63.76 281.71,63.11 281.71,56.7 278.58,53.57 278.58,52.25 277.63,51.31 273.35,51.31 272.57,52.09 270.58,52.09 270.13,52.54 266.31,52.54 265.97,52.89 262.6,52.89 262.25,53.24 258.91,53.24 258.29,52.62 v1(258.29,51.88) ; v1(58.52,77.92) 58.52,78.1 58.02,78.59 R22139.2
  vias: v1(18.79,45.69) v1(19.45,45.56) v1(20.11,45.56) v1(20.39,35.93) v1(20.98,45.33) v1(21.05,35.91) v1(33.7,25.44) v1(34.23,25.82) v1(41.27,42.16) v1(41.27,41.49) v1(41.27,40.83) v1(113.9,62.27) v1(114.64,62.27) v1(144.06,55.46) v1(144.72,55.46) v1(145.38,55.46) v1(188.74,53.15) v1(189.25,52.75) v1(257.6,51.76) v3(115.56,57.52) v3(115.97,56.86) v3(116.33,57.55) v3(116.73,56.86) v3(117.09,57.52) v3(117.5,56.86)
