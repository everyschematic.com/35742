# Allegro board DAZGLMB1ED0 dazglmb1ed0-d-ver a-165 (.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
24780_VCC: length 266.7
  TOP w0.508: PR16.1 v1(190.24,169.1)
  IN5 w0.178: v1(190.24,169.1) 193.89,165.45 204.62,165.45 209.04,161.02 209.04,130.47 208,129.42 208,115.92 200.82,108.75 200.82,99.73 194.23,93.13 194.23,88.9 198.17,84.97 198.17,84.71 198.73,84.15 198.73,77.22 198.73,76.9 199.51,76.12 200.85,76.12 201.06,75.91 201.06,75.38 199.82,74.14 199.82,71.86 195.6,67.63 195.48,67.63 193.52,67.63 193.44,67.55 180.07,67.55 178.48,65.96 178.18,65.96 175,62.78 175,62.78 174.75,62.53 174.75,62.53 174.38,62.16 174.38,60.76 173.51,59.9 173.51,59.47 173.52,59.16 172.18,57.83 171.82,57.83 170.45,56.46 169.43,56.46 169.04,56.07 156.95,56.07 156.38,56.63 142.13,56.63 141.4,57.36 126,57.36 125.89,57.26 118.42,57.26 117.33,58.35 115.45,58.35 114.14,57.04 112.25,57.04 110.57,55.36 100.48,55.36 99.85,54.74 92.63,54.74 90.98,53.09 85.17,53.09 82.67,50.59 76.63,50.59 v1(76.27,50.94)
  BOTTOM w0.178: v1(76.27,50.94) 76.27,52.74 PC16.1 75.22,53.79 74.54,53.79 74.19,54.15 PU1.28
51225_CS1: length 3.6
  BOTTOM w0.203: PU9.1 82.28,70.51 82.57,70.22 v1(83.28,70.22) 83.43,70.22 84.85,68.81 PR182.1
51225_CS2: length 3.8
  BOTTOM w0.203: PR190.1 78.75,69.31 79.33,69.31 79.55,69.52 v1(79.55,70.2) 79.61,70.26 80.42,70.26 80.68,70.51 PU9.5
51225_DH1: length 8.4
  IN3 w0.61: v3(88.51,68.08) 88.51,70.15 84.96,73.7 v3(83.66,73.7)
  vias: v1(84.12,74.26)
51225_DH2: length 14.8
  IN3 w0.61: v3(79.52,73.75) 77.29,73.75 74.92,71.39 71.34,71.39 70,70.04 v3(70,66.34)
51225_DL1: length 7.9
  BOTTOM w0.61: v3(89.28,74.47) 89.28,75.07 88.59,75.75 84.83,75.75 v1(84.68,75.61) 84.35,75.61 83.66,74.92 82.85,74.92 82.67,74.75
51225_DL2: length 12.5
  BOTTOM w0.508: v1(69.62,74.51) 69.62,75.49 70.11,75.99 78.63,75.99 80.23,74.39
51225_EN1: length 2.3
  BOTTOM w0.203: PR179.2 84.89,71.16 84.55,71.51 PU9.20
51225_FB1: length 3.4
  BOTTOM w0.14: PR185.1 PR184.1
  BOTTOM w0.203: PR184.1 82.82,68.95 v1(82.09,69.69) 81.88,69.9 PU9.2
51225_FB2: length 3.3
  BOTTOM w0.203: PR189.1 PR188.2 80.28,69.23 v1(80.72,69.66) 81.08,70.03 PU9.4
51225_SW1: length 11.8
  IN1 w0.61: v3(84.25,72.18) 84.3,72.23 v3(94.71,72.23)
  BOTTOM w0.203: PU9.18 84.12,72.31 v3(84.25,72.18)
  vias: v1(99.59,72.98)
51225_SW2: length 11.5
  IN1 w0.61: v3(77.86,72.81) 77.16,72.12 73.89,72.12 72.92,73.09 v3(68.15,73.09)
  BOTTOM w0.203: PU9.8 78.84,72.31
  vias: v1(67.41,73.04)
51225_VBST1: length 1.4
  BOTTOM w0.203: PU9.17 83.86,72.71 84.2,73.04
  vias: v1(86.03,74.98)
51225_VBST2: length 1.1
  BOTTOM w0.203: 78.99,72.97 79.25,72.71 PU9.9
  vias: v1(78.38,73.83)
51225_VIN:
  vias: v1(80.33,76.04)
61087COMP: length 2.3
  TOP w0.254: PR9233.2 363.55,82.77 364.35,83.58 364.85,83.58 PU8006.1
61087EN: length 5
  TOP w0.254: PU8006.3 366.02,83.18 366.27,82.94 367.92,82.94 368.74,83.76 v1(368.74,84.08) 368.74,84.79 PC8102.2
61087FB: length 2.6
  TOP w0.254: PU8006.2 365.52,83.22 365.02,82.72 PR9232.2 365.02,82.32 PR9231.1
61087FREQ: length 2.5
  TOP w0.254: PR9229.2 364.38,88.15 PR9234.1 365.33,87.58 365.52,87.38 PU8006.9
61087SS: length 2
  TOP w0.254: PU8006.10 364.66,87.07 v1(363.96,87.07) PC8104.2
61087SW:
  vias: v1(368.65,93.9)
+601_VCC: length 8.9
  TOP w0.178: U13146.35 61.18,30.77 60.73,30.32 v1(60.73,30.12) ; U13146.28 57.37,32.73 v1(56.99,32.35) ; v1(64.46,36.14) 64.46,35.73 64.26,35.53 U13146.8
  TOP w0.381: v1(65.96,35.75) 66.35,36.15 R21988.2
  TOP w0.508: v1(54.25,36.69) 54.76,37.2 R21984.2 R21979.2 ; R21986.2 54.58,31.89 v1(54.17,31.49) ; v1(66.03,39.26) 65.67,39.62 R21744.1
  vias: v1(61.26,37)
+602_VCC: length 12.5
  TOP w0.178: U13147.35 71.34,39.29 71.02,38.96 v1(71.02,38.6) ; v1(67.03,41.32) 67.1,41.24 U13147.28 ; U13147.8 75.02,44.04 v1(75.15,43.91)
  TOP w0.508: v1(76.09,47.64) 75.99,47.74 75.99,48.44 75.81,48.62 R21918.1
  BOTTOM w0.203: v1(75.15,43.91) 74.77,44.29 C95594.2
  BOTTOM w0.508: R21919.1 R21897.1 R21907.1 R21899.1 R21910.1 R21908.2 78.3,45.69 v1(78.43,45.81)
  vias: v1(64.5,46.96) v1(68.32,46.75) v1(68.3,46.07)
+603_VCC: length 14.8
  TOP w0.178: v1(49.75,38.3) 49.73,38.32 U13149.8 ; v1(45.62,32.83) 45.62,33.68 45.94,34 U13149.35 ; v1(41.7,35.37) 41.85,35.52 U13149.28
  TOP w0.381: v1(38.58,34.92) 38.76,34.74 R21958.2 ; R21957.2 39.36,39.2 v1(39.62,39.46)
  TOP w0.508: v1(51.35,41.6) 51.35,41.83 50.58,42.6 R21975.1 ; v1(52.39,39.13) 52.32,39.21 R21964.2
  IN4 w0.508: v1(38.58,34.92) 38.68,34.92 38.73,34.97 38.75,34.97 39.75,35.96 39.75,39.34 v1(39.62,39.46)
  BOTTOM w0.381: v1(39.62,39.46) 39.62,38.28
  vias: v1(46.48,39.13)
+604_VCC: length 4.4
  TOP w0.178: U13148.35 55.72,42.76 55.37,42.42 v1(55.37,41.93) ; U13148.28 51.66,44.54 v1(51.51,44.69) ; v1(59.53,47.19) 59.38,47.34 U13148.8
  vias: v1(53.69,49.14)
+PWR_SRC_GPU_SENSE1_IN_N: length 10.1
  TOP w0.254: PR67196.2 128.24,73.2 v1(128.24,72.71)
  IN5 w0.254: v1(128.24,72.71) 128.42,72.89 128.42,73.37 128.67,73.63 130.68,73.63 133.29,71.02 133.29,70.63 133.73,70.2 134.08,70.2 v1(134.39,70.5)
  BOTTOM w0.254: PR146.2 v1(134.39,70.5)
+PWR_SRC_GPU_SENSE1_IN_P: length 11.6
  TOP w0.254: PR67195.2 128.9,73.29 v1(128.9,72.69)
  IN5 w0.254: v1(128.9,72.69) 128.76,72.83 128.76,73.12 128.89,73.24 130.58,73.24 132.86,70.96 132.86,70.58 133.59,69.85 134.04,69.85 v1(134.36,69.54)
  BOTTOM w0.14: v1(134.36,71.34) 134.87,70.83 134.87,70.04 v1(134.36,69.54)
  BOTTOM w0.254: PR139.2 v1(134.36,69.54)
+TPVDD: length 224.2
  TOP w0.254: R21067.2 121.17,64.73 121.56,65.12 Q7892.5 Q7892.2 123.72,65.12 124.11,65.51 R21068.2 ; CN2078.10 142,55.39 141.57,55.82 141.57,58 142.11,58.54 v1(142.11,59.27)
  TOP w0.508: 126.64,64.1 126.64,64.74 125.87,65.51 R21068.2
  IN3 w0.508: v1(129.89,61.26) 136.03,61.26 137.39,59.9 141.87,59.9 142.11,59.66 v1(142.11,59.27) 143.66,59.27 144.28,59.9 145.8,59.9 146.85,58.85 151.69,58.85 153.62,60.78 153.64,60.78 153.68,60.81 157.4,60.81 158.63,62.04 164.91,62.04 166.45,63.59 166.45,66.97 167.25,67.78 174.8,67.78 178.46,71.43 178.46,72.46 179.32,73.32 183.86,73.32 184.81,72.38 190.26,72.38 194.12,76.24 196.06,76.24 197.44,77.62 198.21,77.62 201.52,80.93 202.72,80.93 204.82,83.03 206.21,83.03 211.51,88.32 279.59,88.32 280.93,86.98 280.93,86.69 283.64,83.98 285.01,83.98 285.55,83.43 287.92,83.43 288.99,82.36 298.39,82.36 298.85,81.91 298.85,81.37 299.31,80.91 301.83,80.91 302.76,79.98 307.99,79.98 308.17,79.8 309.67,79.8 310.33,79.14 v1(310.87,79.14)
  BOTTOM w0.203: 140.3,56.1 140.16,56.23 R21063.1 139.33,56.24 138.96,56.23 R21064.1
  BOTTOM w0.254: v1(310.87,79.14) 310.87,78.43 311.1,78.19 R67257.2
  BOTTOM w0.508: Q7843.2 311.44,79.71 v1(310.87,79.14) ; 140.3,56.1 140.63,56.1 141.45,56.91 141.45,58.13 142.11,58.79 v1(142.11,59.27)
  vias: v1(128.39,62.42)
+WL_VDD: length 3.4
  TOP w0.508: Q7888.2 62.81,52.14 62.77,52.19 R21709.2 v1(62.77,53.35) ; R21710.2 60.75,52.67 v1(61.16,52.26) 60.59,51.7 Q7889.2
  vias: v1(49.25,49.27) v1(50.82,74.11) v1(50.85,73.37) v1(50.95,55.19) v1(51.58,54.98)
A0_EDP: length 5.4
  TOP w0.14: v1(331.44,75.92) U13079.11
  BOTTOM w0.14: v1(331.44,75.92) 332.48,76.96 332.48,78.21 R20914.2 332.96,79.52 332.91,79.57 R20912.2
A0_TBT: length 2.8
  TOP w0.14: U13025.11 v1(331.19,57.5)
  BOTTOM w0.14: R20840.1 332.03,58.96 R20835.1 331.23,57.54 v1(331.19,57.5)
A_DE0: length 4.4
  TOP w0.14: R21750.1 56.52,33.75 56.79,33.75 56.92,33.88 v1(56.97,33.88) 57.04,33.88 57.39,33.53 U13146.26
  BOTTOM w0.14: R21750.1 56.49,33.72 56.81,33.72 v1(56.97,33.88)
A_DE0_1: length 5.5
  TOP w0.14: U13147.26 67.55,42.04 67.53,42.06 66.97,42.06 66.56,42.46 v1(65.93,42.46) 65.7,42.23 R21911.1 64.41,41.36 v1(64.07,41.36)
  BOTTOM w0.14: v1(65.93,42.46) 65.7,42.23 R21911.1
A_DE0_2: length 5.2
  TOP w0.14: U13149.26 41.88,36.32 v1(41.45,36.75) 41.45,36.37 40.91,35.83 R21967.1
  BOTTOM w0.14: v1(41.45,36.75) 41.45,36.65 40.63,35.83 R21967.1
A_DE0_3: length 3.8
  TOP w0.14: U13148.26 51.91,45.34 51.74,45.51 v1(50.65,45.51) 50.44,45.3 R21948.1
  BOTTOM w0.14: v1(50.65,45.51) 50.44,45.3 R21954.2
A_DE0_5: length 1.8
  TOP w0.14: R21691.2 26.87,44.39 27.56,45.08 U13124.29
A_DE1: length 5.1
  TOP w0.14: U13146.2 64.38,33.13 64.59,32.92 64.59,32.4 v1(64.41,32.22) 64.64,32.22 65.57,31.29 R21752.1
  BOTTOM w0.14: v1(64.41,32.22) 65.6,31.03 R21753.2
A_DE1_1: length 4.4
  TOP w0.14: v1(75.31,41.04) 75.28,41.07 75.18,41.07 74.61,41.64 U13147.2
  BOTTOM w0.14: R21914.1 74.58,40.31 v1(75.31,41.04) 75.79,41.04 76.22,40.61 R21919.2
A_DE1_2: length 4.4
  TOP w0.14: U13149.2 49.15,35.92 49.56,35.52 49.56,35.48 v1(50.07,34.98) 50.96,34.08 R21971.1
  BOTTOM w0.14: v1(50.07,34.98) 50.96,34.08 R21971.1
A_DE1_3: length 5
  TOP w0.14: R21951.1 v1(60.05,43.61) 59.71,43.27 v1(59.47,43.27) 59.46,43.29 59.46,44.42 58.93,44.94 U13148.2
  BOTTOM w0.14: R21951.1 v1(60.05,43.61)
A_DE1_5: length 2.9
  TOP w0.14: R21692.2 25.78,44.85 v1(25.8,44.87) 26.06,44.87 26.26,44.67 26.69,44.67 27.16,45.14 U13124.28
A_EQ0: length 3.3
  TOP w0.14: R21888.1 v1(65.07,32.62) 65.07,32.85 64.39,33.53 U13146.3
  BOTTOM w0.14: R21889.2 65.64,32.05 v1(65.07,32.62)
A_EQ0_1: length 4.6
  TOP w0.14: v1(75.92,41.64) 75.79,41.52 75.12,41.52 74.82,41.82 74.82,41.88 74.66,42.04 U13147.3
  BOTTOM w0.14: 75.9,41.62 R21897.2 ; 75.9,41.62 75.79,41.52 74.76,41.52 R21896.1 ; 75.9,41.62 v1(75.92,41.64)
A_EQ0_2: length 5
  TOP w0.14: U13149.3 49.18,36.32 49.71,35.8 50,35.8 v1(50.1,35.7) 50.76,35.04 R21924.1
  BOTTOM w0.14: R21924.1 50.76,35.04 v1(50.1,35.7) 50.08,35.7 49.4,35.02 v1(49.4,34.92)
A_EQ0_3: length 3.9
  TOP w0.14: R21932.1 60.44,43.93 v1(59.98,44.39) 59.03,45.34 U13148.3
  BOTTOM w0.14: R21933.2 60.44,43.93 v1(59.98,44.39)
A_EQ0_5: length 3
  TOP w0.14: U13124.32 28.76,45.01 v1(29.15,44.62)
  BOTTOM w0.14: v1(29.15,44.62) 29.41,44.87 R21686.2 29.65,45.48 v1(30.5,45.48)
A_EQ1: length 3
  TOP w0.14: U13146.4 64.43,33.93 64.77,33.59 v1(65,33.59) 65.45,33.13 R21754.1
  BOTTOM w0.14: R21755.2 65.52,33.06 v1(65,33.59)
A_EQ1_1: length 4.2
  TOP w0.14: U13147.4 74.88,42.44 v1(75.33,41.99)
  BOTTOM w0.14: R21913.1 74.94,42.38 v1(75.33,41.99) 75.5,42.16 76.49,42.16 R21907.2
A_EQ1_2: length 5
  TOP w0.14: R21969.1 50.72,36.3 49.88,36.3 v1(49.55,36.63) 49.46,36.72 U13149.4
  BOTTOM w0.14: v1(48.89,36.14) 49.38,36.63 v1(49.55,36.63) 49.92,36.26 50.76,36.26 R21969.1
A_EQ1_3: length 5.4
  TOP w0.14: U13148.4 59.4,45.74 v1(60.09,45.05) 60.19,44.95 R21950.1
  BOTTOM w0.14: R21942.2 60.19,44.95 v1(60.09,45.05) 59.76,45.05 58.8,44.09 v1(58.8,43.81)
A_EQ1_5: length 1.7
  TOP w0.14: v1(28.49,44.61) 28.36,44.74 U13124.31
  BOTTOM w0.14: v1(28.49,44.61) 28.37,44.73 R21687.2
A_EQ2: length 2.6
  TOP w0.14: U13146.5 64.82,34.33 v1(64.92,34.23) 65,34.15 R21890.1
  BOTTOM w0.14: v1(64.92,34.23) 65.07,34.08 R21891.2
A_EQ2_1: length 5
  TOP w0.14: U13147.5 75.15,42.84 75.26,42.73 v1(76.05,42.73)
  BOTTOM w0.14: R21898.1 75.41,43.37 v1(76.05,42.73) R21899.2
A_EQ2_2: length 3.4
  TOP w0.14: U13149.5 49.88,37.12 50.19,36.82 v1(50.19,36.8) 50.69,36.8 R21926.1
  BOTTOM w0.14: v1(50.19,36.8) 50.42,36.8 50.69,37.08 R21927.2
A_EQ2_3: length 4.7
  TOP w0.14: R21935.1 60.37,45.97 v1(60.11,45.71) 59.69,46.14 U13148.5
  BOTTOM w0.14: v1(58.9,45.1) 58.97,45.18 58.97,45.18 59.5,45.71 v1(60.11,45.71) 60.37,45.97 R21935.1
ACE_I2C_SCL2: length 31.1
  TOP w0.081: 365.56,26.24 366.3,26.24 366.55,26.49 U13155.B5
  TOP w0.14: 365.56,26.24 364.58,27.22 v1(364.15,27.22) ; Q7926.1 359.18,37.75 359.35,37.58 v1(359.35,35.97) 359.35,35.64 360.55,34.43 v1(361.23,34.43)
  IN1 w0.089: v1(364.15,27.22) 363.63,27.74 363.63,32.73 361.93,34.43 v1(361.23,34.43)
  BOTTOM w0.14: R67134.1 364.34,35.4 363.38,34.43 v1(361.23,34.43) 360.49,34.43 356.98,37.94 356.98,40.57 357.37,40.96 358.32,40.96 358.54,40.74 Q7949.1
ACE_I2C_SDA2: length 23.6
  TOP w0.14: U13155.A5 365.71,26.49 364.27,27.93 v1(364.15,27.93) ; Q7926.4 360.15,36.75 359.87,36.47 359.87,35.85 360.7,35.02 v1(360.93,35.02)
  IN1 w0.089: v1(364.15,27.93) 364.1,27.98 364.1,32.93 362.01,35.02 v1(360.93,35.02)
  BOTTOM w0.14: Q7949.4 360.02,38.98 359.98,38.94 359.98,36.92 359.73,36.67 359.73,35.93 360.64,35.02 v1(360.93,35.02) 363.22,35.02 R67112.1
ACIN: length 135.4
  TOP w0.14: v1(191.43,57.6) 191.94,57.09 191.94,56.43 192.38,55.99 193.18,55.99 193.19,56 U49.72
  IN3 w0.079: v1(191.43,57.6) 191.05,57.98 188.62,57.98 188.25,57.62 185.18,57.62 184.55,56.99 182.01,56.99 181.95,57.05 181.95,57.75 181.61,58.1 178.73,58.1 175.21,54.58 172.06,54.58 171.59,54.1 171.59,52.74 168.37,49.53 97.46,49.53 v1(97.23,49.29)
  BOTTOM w0.14: v1(97.23,49.29) 97.18,49.34 75.84,49.34 74.58,48.08 71.31,48.08 70.12,49.27 70.12,49.76 PR40.1 69.64,50.41 69.79,50.56 70.1,50.56 70.37,50.29 PR39.2 70.61,50.72 70.56,50.77 PR30.1
ACPRESENT: length 155.6
  TOP w0.127: U13113.BB15 311.93,59.24 v2(311.71,59.03)
  TOP w0.14: v1(195.27,60.32) 195.27,60.34 194.81,60.8 U49.84
  IN3 w0.079: v1(195.27,60.32) 194.71,60.88 194.71,62.46 195.97,63.73 195.97,63.78 196.39,64.2 196.39,64.89 197.36,65.86 198.19,65.86 198.56,66.23 202.69,66.23 205.51,69.04 205.51,69.67 212.75,76.92 212.75,78.75 214.7,80.69 274.96,80.69 279.2,76.45 279.2,75.11 280.77,73.55 280.77,69.89 279.2,68.33 279.2,66.37 282.07,63.51 290.31,63.51 293.01,60.8 294.79,60.8 295.62,61.63 305.14,61.63 305.68,61.08 305.68,59.72 306.02,59.37 308.38,59.37 309.08,58.67 311.36,58.67 v2(311.71,59.03)
  BOTTOM w0.14: v2(311.71,59.03) 312.4,59.03 312.89,58.54 317.7,58.54 317.88,58.36 R21128.2
ACZ_BCLK: length 4.1
  TOP w0.102: U13113.BA9 311.55,56.27 v2(311.3,56.02)
  BOTTOM w0.14: v2(311.3,56.02) 312.11,56.02 312.19,56.1 v1(313.81,56.1) 313.99,56.1 314.37,55.72 R21100.2
ACZ_RST#: length 10.9
  TOP w0.112: U13113.BD8 313.09,55.99 313.9,55.99
  TOP w0.14: v1(317.34,48.99) 317.11,49.22 317.11,49.9 317.31,50.1 R21102.2 317.52,50.27 317.26,50.53 317.26,51.19 317.69,51.62 317.69,52.01 317.3,52.4 316.49,52.4 315.54,53.36 315.54,54.35 314.73,55.16 314.73,55.34 314.35,55.72 314.17,55.72 313.9,55.99
ACZ_SDOUT: length 6.3
  TOP w0.102: U13113.BB7 311.97,55.53 v2(312.34,55.53)
  BOTTOM w0.14: v2(312.34,55.53) 313.26,55.53 313.66,55.13 313.66,54.78 313.89,54.55 R21103.2 313.89,53.45 v1(314.17,53.18) 314.55,52.8 R21105.2 R21098.2
ACZ_SPKR: length 360.1
  TOP w0.102: v1(314.5,64.81) 314.12,65.19 312.94,65.19 U13113.BD26
  TOP w0.14: v1(18.08,34.92) 18.31,34.69 D13039.2 ; R21235.2 R21241.1 322.21,66.38 321.97,66.13 v1(321.97,65.75)
  IN1 w0.089: v1(40.03,44.49) 39.9,44.62 37.9,44.62 36.38,43.1 32.58,43.1 32.18,43.5 25.01,43.5 23.67,42.16 23.67,38.22 21.86,36.41 19.58,36.41 v1(18.08,34.92)
  IN3 w0.079: v1(314.5,64.81) 314.05,65.26 311.1,65.26 309.88,66.48 308.56,66.48 307.71,67.34 303.24,67.34 301.84,68.75 298.98,68.75 298.08,69.65 293.21,69.65 291.29,71.57 285.33,71.57 281.71,75.19 281.71,76.47 275.83,82.35 213.08,82.35 208.23,77.5 206.78,76.05 206.1,76.05 206,76.16 205.61,76.16 205.11,75.66 205.11,74.94 205.43,74.62 205.43,73.25 200.86,68.68 200.86,68.37 200.29,67.8 197.53,67.8 194.61,64.88 192.04,64.88 191.62,65.3 191.62,66.02 191.15,66.5 186.69,66.5 186.19,66 186.19,65.77 185.08,64.65 185.08,62.07 184.88,61.87 184.41,61.87 183.74,62.55 182.38,62.55 181.86,63.07 181.86,64 181.38,64.48 180.17,64.48 179.65,63.96 172.76,63.96 171.12,62.32 170.14,62.32 167.53,59.72 167.53,55.46 164.82,52.75 117.67,52.75 116.87,53.55 116.07,53.55 114.45,51.93 93.26,51.93 89.4,48.07 68.58,48.07 66.98,49.67 64.51,49.67 61.54,52.64 60.68,52.64 60.18,53.14 60.18,53.59 58.89,54.88 57.44,54.88 56.06,56.27 53.83,56.27 51.99,54.42 50.79,54.42 48.6,52.24 45.64,52.24 40.46,47.06 40.46,44.92 v1(40.03,44.49)
  IN5 w0.089: v1(321.97,65.75) 322.22,65.5 322.22,65.24 321.71,64.74 319.81,64.74 319.68,64.61 317.77,64.61 317.14,65.24 314.93,65.24 v1(314.5,64.81)
ACZ_SYNC: length 11.9
  TOP w0.112: U13113.BD9 312.87,56.65 313.27,56.25 314.06,56.25 314.33,55.98
  TOP w0.14: v1(320.33,50.47) 319.96,50.1 R21104.2 319.25,50.1 319.09,50.27 R21112.1 318.54,50.83 318.21,51.16 318.21,51.84 317.4,52.65 316.66,52.65 315.84,53.46 315.84,54.46 314.97,55.33 314.97,55.52 314.52,55.98 314.33,55.98
ADOGND: length 67.2
  TOP w0.203: v1(26.84,26.25) 26.85,26.25 27.1,26.51 C94928.1 ; C94962.1 20.34,30.86 20.06,30.58 C95974.1 19.35,30.21 v1(19.15,30.01) ; U13157.20 30.82,40.18 30.61,40.39 27.21,40.39 v1(27.05,40.22) ; v1(26.26,37.76) 26.03,37.99 C96232.1 ; v1(14.12,13.35) 14.16,13.4 R21450.2 ; v1(27.02,28.15) 27.13,28.04 27.47,28.04 27.54,28.11 U13108.37 ; R21449.2 15.79,12.53 v1(15.89,12.43) ; v1(17.04,17.87) 16.91,17.87 16.76,18.03 C95980.1 ; v1(28.24,35.53) 28.34,35.43 U13108.22 ; v1(30.53,42.03) 30.77,41.78 U13157.16 ; v1(13.76,27.17) C95973.1 ; C96233.1 25.8,40.18 v1(25.7,40.07)
  TOP w0.254: 25.5,37.25 24.45,36.2 C94925.2 ; U13150.10 v1(19.83,20.64)
  TOP w0.305: v1(17.04,17.87) 17.04,17.88 U13150.15
  TOP w0.381: C95962.2 16.4,24.93 v1(16.1,25.24) ; v1(23.24,28.21) C94953.2 22.69,27.41 22.64,27.37 D8577.2 ; C94963.1 22.62,32.23 22.37,32.48 v1(22.37,32.86) ; C94930.1 25.41,26.52 25.03,26.9 C94926.1 25.03,27.53 25.46,27.96 v1(25.47,27.96) ; R67015.2 14.67,26.11 15.18,25.59 v1(15.44,25.59) ; v1(20.19,23.89) 20.35,24.05 C94952.2 ; v1(26.59,24.8) C94927.1 ; D8575.2 15.18,19.52 v1(14.88,19.52) ; D8569.2 14.63,17.03 v1(14.43,16.83) ; v1(13.74,6.98) 14,7.24 D8570.2 ; C94943.2 15.82,9.35 15.79,9.32 D8571.2 v1(14.42,9.32) ; C94942.2 16.29,17.12 15.67,17.75 v1(15.56,17.75) ; C96234.2 25.56,38.75 v1(25.46,38.65) 25.25,38.44 R67352.1
  TOP w0.508: C95978.2 21.62,21.77 v1(21.54,21.85) ; v1(19.88,26.1) 20.1,26.32 C95975.2 ; v1(25.8,37.25) 25.5,37.25 ; v1(21.31,29.56) 21,29.25 R67013.2 ; C94922.1 23.72,30.22 23.36,29.86 v1(23.36,29.58)
  BOTTOM w0.203: C96224.2 17.34,13.89 v1(17.09,14.14) ; C94932.2 26.47,34.62 v1(26.08,34.23) ; R67014.2 15.87,26.02 v1(15.44,25.59) ; C96236.1 28.56,42.62 28.67,42.51 C96235.1 ; v1(21.74,15.79) 20.75,14.8 C96223.2 ; v1(15.89,12.43) 15.96,12.36 18.54,12.36 18.89,12.01 U13156.2
  BOTTOM w0.305: v1(26.08,34.23) 25.52,34.23 24.88,34.87 C94931.2
  BOTTOM w0.381: C95977.2 18.22,32.21 v1(18.18,32.25) ; C94930.1 25.41,27.9 v1(25.47,27.96) ; v1(27.2,42.28) 27.54,42.62 C96236.1 ; R21468.1 27.49,28.41 27.23,28.15 v1(27.02,28.15) ; C95979.2 15.78,17.15 15.56,17.36 v1(15.56,17.75) ; v1(14.43,16.83) 14.96,17.36 C95981.2 ; C96222.2 16.92,27.85 v1(17.24,27.52) ; v1(15.26,6.57) 15.72,7.03 R21470.1 ; C94933.2 28.25,35.52 v1(28.24,35.53)
  BOTTOM w0.508: v1(25.7,40.07) 25.43,39.8 R21465.1 ; R21462.1 26.94,34.09 26.99,34.15 v1(26.99,34.18) ; R21466.1 26.96,28.21 v1(27.02,28.15) ; v1(16.4,32.02) 16.34,31.95 C94951.1
  vias: v1(1.04,27.52) v1(1.04,24.98) v1(1.04,22.44) v1(1.04,19.9) v1(1.04,15.97) v1(1.04,13.68) v1(1.04,11.14) v1(1.04,8.6) v1(1.04,6.06) v1(17.29,28.64) v1(17.52,15.54) v1(17.83,28.08) v1(18.18,20.11) v1(18.18,19.45) v1(18.28,28.64) v1(18.38,27.52) v1(19.58,18.13) v1(22.02,16.5)
AMP_EN: length 14.7
  TOP w0.203: U13151.5 15.42,28.83 v1(15.29,28.97)
  IN1 w0.203: v1(15.29,28.97) 16.4,27.86 16.4,27.25 16.68,26.97 18.61,26.97 18.94,27.3 18.94,29.56 17.72,30.78 v1(17.72,31.13)
  BOTTOM w0.203: v1(17.72,31.13) 17.19,31.66 R67012.2 16.83,32.28 R67338.2 R67342.2 ; v1(15.29,28.97) 15.63,28.63 C96222.1
AMP_MUTE#: length 265.5
  TOP w0.14: D13066.1 38.2,49.7 38.02,49.88 38.02,50.94 37.62,51.34 v1(37.62,51.52) 37.63,51.53 D8587.1 ; v1(187.47,64.99) 187.47,65.4 187.7,65.62 187.7,66.06 188,66.36 U49.108
  IN2 w0.089: v1(187.47,64.99) 187.17,65.29 185.57,65.29 184.44,66.42 182.75,66.42 182.11,65.78 179.89,65.78 177.96,63.85 176.01,63.85 174.47,62.31 171.53,62.31 171.25,62.03 170.55,62.03 168.73,60.21 168.27,60.21 167.17,59.12 163.75,59.12 163.27,59.61 162.5,59.61 161.56,58.67 155.3,58.67 154.71,59.26 152.67,59.26 152.26,58.86 150.34,58.86 149.57,59.62 147.29,59.62 145.93,60.99 138.09,60.99 137.49,60.39 131.31,60.39 130.91,59.99 130.91,59.09 126.44,54.63 118.62,54.63 118.3,54.94 115.38,54.94 115.09,55.24 111.12,55.24 110.03,54.15 101.1,54.15 100.39,53.44 96.33,53.44 93.56,50.67 83.87,50.67 82.87,49.67 78.09,49.67 77.7,49.28 72.92,49.28 72.63,49.57 70.52,49.57 70.38,49.71 70.37,49.71 68.67,51.42 67.72,51.42 67.12,52.02 67.12,52.89 64.81,55.2 63.98,55.2 61.08,58.09 61.08,61.51 62.23,62.65 62.23,64.71 61.84,65.09 61.13,65.09 59.68,63.64 54.79,63.64 52.91,61.76 50.06,61.76 49.85,61.56 47.75,61.56 46.55,60.37 46.55,58.79 45.79,58.03 45.79,57.24 44.74,56.2 44.74,55.24 45.13,54.86 45.13,51.35 44.04,50.26 40.36,50.26 39.29,51.32 37.82,51.32 v1(37.62,51.52)
  IN5 w0.089: v1(37.62,51.52) 36.06,53.08 33.07,53.08 31.74,51.76 26.06,51.76 25.12,50.82 24.45,50.82 24.02,50.38 23.12,50.38 22.5,49.76 22.5,47.24 26.31,43.43 31.39,43.43 33.2,41.62 33.2,40.33 32.61,39.74 31.62,39.74 29.84,37.96 29.84,36.72 30.27,36.29 30.27,28.92 32.07,27.12 32.07,25.75 31.67,25.34 30.55,25.34 24.97,19.76 24.97,18.57 24.29,17.88 23.43,17.88 v1(23.39,17.92)
  BOTTOM w0.14: v1(23.39,17.92) 24.35,16.96 v1(24.35,16.4) 24.35,14.37 22.27,12.28 21.97,12.28 21.19,11.51 U13156.6 ; R2708.1 v1(37.62,51.52)
AMP_PD: length 14.2
  TOP w0.203: U13157.11 32.92,44.42 33.11,44.62 33.7,44.62 34.03,44.95 34.03,45.79 36.14,47.9 D13067.2 35.62,48.44 35.62,49.15 D13066.2 35.85,50.02 35.81,50.02 35.3,50.52 v1(35.3,50.94)
  BOTTOM w0.203: v1(35.3,50.94) 35.99,51.63 R2709.2 36.24,51.84 36.7,52.3 R22089.2 R2708.2 38.6,52.3 38.62,52.31 R20881.1
AN_DPSRC_RBIAS_1: length 2.1
  TOP w0.14: v4(349.72,56.09) U21.N6
  BOTTOM w0.14: v4(349.72,56.09) 349.27,56.54 349.27,56.98 R20690.2
ASEL: length 3.2
  TOP w0.203: v1(30.6,43.02) 31.04,42.58 U13157.14
  BOTTOM w0.203: R67351.1 29.2,43.76 29.51,43.45 R381.1 30.17,43.45 v1(30.6,43.02)
AUD_AZACPU_SCLK: length 201.6
  TOP w0.112: v1(228.83,124.08) 229.16,123.75 U41.G27
  TOP w0.14: v1(308.15,45.64) 307.61,46.17 R21116.1
  IN2 w0.089: v1(323.87,73.75) 323.96,73.66 324.94,73.66 326.19,72.4 326.19,71.09 328.21,69.07 328.21,67.53 328.9,66.84 328.9,65.03 329.35,64.58 329.35,64.53 330.68,63.2 330.68,60.34 330.99,60.03 330.99,58.69 330.84,58.54 330.58,58.54 330.42,58.39 330.42,57.23 330.33,57.14 329.75,57.14 329.66,57.05 329.66,56.68 329.75,56.6 330.33,56.6 330.42,56.51 330.42,56.14 330.33,56.05 329.75,56.05 329.66,55.96 329.66,55.59 329.75,55.5 330.33,55.5 330.42,55.41 330.42,53.97 330.17,53.71 329.41,53.71 328.47,52.77 328.47,52.41 327.71,51.65 327.34,51.65 324.4,48.71 323.85,48.71 323.18,48.05 323.02,48.05 322.93,48.14 322.93,48.71 322.84,48.8 322.47,48.8 322.38,48.71 322.38,48.01 322.29,47.92 321.82,47.92 321.74,48.01 321.74,48.39 321.64,48.49 321.27,48.49 321.19,48.4 321.19,48.28 321.1,48.19 320.19,48.19 319.94,47.93 319.47,47.93 319.18,48.22 318.66,48.22 317.72,47.28 316.91,47.28 315.22,45.6 309.81,45.6 309.27,46.14 308.65,46.14 v1(308.15,45.64)
  IN5 w0.089: v1(228.83,124.08) 229.25,123.66 229.76,123.66 230.78,124.68 231.06,124.68 232.76,126.38 234.64,126.38 235.22,126.97 235.22,132.2 235.61,132.59 261,132.59 262.8,130.79 262.8,129.68 263.03,129.45 263.03,126.23 262.28,125.48 262.28,117.21 264.21,115.28 265.96,115.28 269.28,111.96 269.28,110.13 270.14,109.27 270.14,107.65 271.29,106.49 271.29,103.65 274.42,100.52 274.42,99.08 277.4,96.1 277.4,91.02 282.01,86.42 282.01,85.72 284.21,83.52 284.67,83.52 286.51,81.67 287.49,81.67 291.86,77.31 295.78,77.31 296.74,76.34 296.74,75.59 299.19,73.15 307.24,73.15 307.87,73.78 312.41,73.78 313.2,72.99 314.22,72.99 314.6,72.61 318.79,72.61 319.55,73.37 323.49,73.37 v1(323.87,73.75)
AUD_AZACPU_SCLK_R: length 8.5
  TOP w0.102: U13113.AM2 307.21,53.08 307.21,52.98 307.31,52.88 307.31,52.8
  TOP w0.112: 307.84,49.62 307.84,49.9 307.74,50.01 307.74,52.06 307.31,52.49 307.31,52.8
  TOP w0.14: v1(307.18,45.51) 307.11,45.58 307.11,46.58 R21116.2 307.84,47.32 307.84,49.62
AUD_AZACPU_SDI: length 186.7
  TOP w0.102: 308.12,50.16 308.44,49.84 308.44,49.59
  TOP w0.112: U13113.AN2 307.53,53.05 307.53,52.56 307.95,52.15 307.95,50.33 308.12,50.16
  TOP w0.14: v1(308.35,47.92) 308.44,48.01 308.44,49.59
  IN1 w0.089: v1(279.75,86.4) 279.58,86.23 279.58,81.72 284.86,76.43 286.82,76.43 287.6,75.66 288.03,75.66 288.12,75.75 288.12,76.34 288.21,76.43 288.48,76.43 288.56,76.34 288.56,75.75 288.65,75.66 288.92,75.66 289.01,75.75 289.01,76.34 289.1,76.43 289.36,76.43 289.45,76.34 289.45,75.75 289.54,75.66 290.57,75.66 290.66,75.75 290.66,76.34 290.74,76.43 291.01,76.43 291.1,76.34 291.1,75.75 291.19,75.66 291.46,75.66 291.55,75.75 291.55,76.34 291.63,76.43 291.9,76.43 291.99,76.34 291.99,75.75 292.08,75.66 292.35,75.66 292.43,75.75 292.43,76.34 292.52,76.43 292.79,76.43 292.88,76.34 292.88,75.75 292.97,75.66 293.77,75.66 294.01,75.41 294.14,75.41 294.84,76.11 294.97,76.11 295.15,75.93 295.15,75.8 294.45,75.1 294.45,74.97 294.64,74.79 294.77,74.79 295.47,75.49 295.59,75.49 295.78,75.3 295.78,75.17 295.08,74.47 295.08,74.35 295.27,74.16 295.4,74.16 296.1,74.86 296.22,74.86 296.41,74.67 296.41,74.54 295.71,73.84 295.71,73.72 295.9,73.53 296.03,73.53 296.73,74.23 296.85,74.23 297.04,74.04 297.04,73.91 296.34,73.21 296.34,73.09 296.53,72.9 296.66,72.9 297.36,73.6 297.48,73.6 297.67,73.41 297.67,73.28 296.97,72.58 296.97,72.46 297.58,71.85 301.2,71.85 301.9,71.15 301.9,69.26 305.03,66.13 305.71,66.13 307.49,64.35 307.53,64.35 307.61,64.27 307.61,61.14 308.08,60.67 308.25,60.67 308.5,60.42 308.5,59.91 309.01,59.4 309.01,58.89 309.39,58.51 312.27,58.51 313.28,57.5 314.47,57.5 315.23,56.73 315.23,54.32 314.27,53.36 314.27,51.96 313.71,51.4 313.13,51.4 310.96,49.23 309.68,49.23 308.36,47.92 v1(308.35,47.92)
  IN5 w0.089: v1(279.75,86.4) 279.5,86.4 266.9,99 237.56,99 232.71,103.85 231.39,103.85 230.75,104.49 230.3,104.49 228.95,105.83 228.95,107.05 229.84,107.94 229.84,108.42 230.35,108.93 230.35,109.31 230.83,109.8 230.83,110.25 230.68,110.41 230.68,111.54 230.16,112.07 230.16,113.72 229.1,114.77 225.29,114.77 222.8,117.26 222.8,124.83 v1(222.7,124.93)
  BOTTOM w0.14: v1(222.7,124.93) 221.94,124.17 219.6,124.17 218.33,122.9 213.59,122.9 212.92,123.57 R126.2
AUD_AZACPU_SDI_L: length 20.1
  TOP w0.112: v1(228.84,124.86) 229.16,125.19 U41.G29
  BOTTOM w0.14: R126.1 212.72,124.02 213.89,125.19 214.55,125.19 215.51,124.22 218.76,124.22 220.11,125.57 223.36,125.57 223.93,126.13 225.75,126.13 225.75,126.13 227.15,126.13 227.92,125.36 v1(228.07,125.36) 228.57,124.86 v1(228.84,124.86)
AUD_AZACPU_SDO: length 204.6
  TOP w0.112: U41.G25 229.16,122.18 v1(229.48,122.5)
  TOP w0.14: R21114.1 306.49,46.31 v1(305.79,45.61) ; v1(200.4,45.86) 200.48,45.94 200.48,50.59 200.71,50.82 203.27,50.82 206.5,54.04 207.39,54.04 207.7,54.36 207.7,55.76 208.27,56.33 208.27,57.27 v1(209.7,58.69)
  IN1 w0.089: v1(209.7,58.69) 209.67,58.69 208.1,60.25 208.1,67.47 208.05,67.52 208.05,69.74 208.85,70.54 208.85,71.45 210.78,73.38 210.78,88.4 218.26,95.88 218.26,99.78 222.14,103.66 222.14,104.46 222.9,105.22 222.9,106.79 223.09,106.98 224.59,106.98 225.13,107.52 225.13,119.89 225.75,120.51 225.75,121.17 226.69,122.11 229.09,122.11 v1(229.48,122.5)
  IN4 w0.089: v1(305.79,45.61) 305.79,45.43 304.76,44.4 288.81,44.4 286.43,46.78 272.33,46.78 269.96,44.4 203.41,44.4 202.31,45.51 200.76,45.51 v1(200.4,45.86)
AUD_AZACPU_SDO_R: length 6.2
  TOP w0.112: 307.53,49.59 307.53,51.97 307.06,52.43 U13113.AM1
  TOP w0.14: 307.53,49.59 307.53,49 v1(307.36,48.84) 307.36,48.05 306.6,47.29 R21114.2
AUX_SRCN_TBT_C: length 5.2
  TOP w0.14: v4(346.47,53.49) U21.W11
  BOTTOM w0.14: v4(346.47,53.49) 346.06,53.9 345.3,53.9 344.78,54.42 343.96,54.42 343.92,54.39 342.94,54.39 342.85,54.47 342.41,54.47 C94567.1
AUX_SRCP_TBT_C: length 5.2
  TOP w0.14: U21.Y11 346.27,53.81 346.47,54.01 v4(346.47,54.14)
  BOTTOM w0.14: C94566.1 342.55,54.79 342.98,54.79 343.07,54.7 343.79,54.7 343.83,54.74 344.91,54.74 345.43,54.22 346.19,54.22 346.27,54.14 v4(346.47,54.14)
B_DE0: length 2.7
  TOP w0.14: U13146.6 64.74,34.73 v1(64.93,34.92) 65.18,35.17 R21741.1
  BOTTOM w0.14: R21742.2 65.1,35.09 v1(64.93,34.92)
B_DE0_1: length 5
  TOP w0.14: U13147.6 74.7,43.24 74.79,43.15 75.66,43.15 76.29,43.78 v1(76.29,43.99)
  BOTTOM w0.14: R21910.2 76.97,44.67 v1(76.29,43.99) 76,44.28 R21904.1
B_DE0_2: length 4.7
  TOP w0.14: R21960.1 v1(50.38,37.51) 49.47,37.51 49.45,37.52 U13149.6
  BOTTOM w0.14: R21960.1 v1(50.38,37.51) 50.28,37.41 v1(49.04,37.41)
B_DE0_3: length 4.1
  TOP w0.14: U13148.6 59.08,46.54 59.18,46.45 60.12,46.45 v1(60.16,46.4) R21941.1
  BOTTOM w0.14: v1(59.53,46.24) 60.01,46.24 v1(60.16,46.4) R21941.1
B_DE0_5: length 1.9
  TOP w0.14: U13124.15 27.56,53.06 R21693.2
B_DE1: length 4.6
  TOP w0.14: U13146.11 62.38,36.93 v1(63.27,37.81) 64.3,38.84 R21743.1 R21744.2
B_DE1_1: length 5
  TOP w0.14: R21918.2 R21912.1 74.19,47.49 v1(73.53,46.83) 73.25,46.55 73.25,46.17 72.54,45.46 U13147.11
B_DE1_2: length 4.8
  TOP w0.14: U13149.11 47.14,39.72 47.99,40.57 47.99,40.67 v1(48.33,41.01) 49.13,41.82 R21968.1 R21975.2
B_DE1_3: length 5.3
  TOP w0.14: U13148.11 56.92,48.86 57.5,49.45 57.86,49.45 v1(58.14,49.72) 58.34,49.93 v1(58.92,49.93)
  BOTTOM w0.14: R21955.2 R21949.1 v1(58.92,49.93)
B_DE1_5: length 2.6
  TOP w0.14: U13124.16 27.16,52.46 26.99,52.62 v1(26.31,52.62) 25.93,53 R21694.2
B_EQ0: length 4.2
  TOP w0.14: R21745.1 60.07,29.92 60.07,30.24 v1(60.09,30.27) 60.78,30.96 U13146.34
  BOTTOM w0.14: v1(60.09,30.27) 60.09,30.04 60.52,29.61 R21745.1
B_EQ0_1: length 4.1
  TOP w0.14: R21903.1 69.84,37.99 v1(70.35,38.5) 70.35,38.9 v1(70.61,39.16) 70.94,39.49 U13147.34
  BOTTOM w0.14: R21905.2 69.84,37.99 v1(70.35,38.5)
B_EQ0_2: length 3.8
  TOP w0.14: U13149.34 45.54,34.06 44.99,33.51 44.99,33.05 v1(44.95,33.01) R21959.1
  BOTTOM w0.14: R21959.1 v1(44.95,33.01)
B_EQ0_3: length 4
  TOP w0.14: U13148.34 55.32,42.82 54.71,42.21 v1(54.71,41.9) 54.78,41.83 R21939.1
  BOTTOM w0.14: R21939.1 54.78,41.83 v1(54.71,41.9)
B_EQ0_5: length 3
  TOP w0.14: U13124.13 28.36,52.69 28.57,52.9 29.36,52.9 v1(29.53,52.72) 29.53,53.37 R21689.2
B_EQ1: length 3.4
  TOP w0.14: R21982.1 56.43,35.04 v1(56.54,34.94) 56.6,34.88 57.02,34.88 57.57,34.33 U13146.24
  BOTTOM w0.14: R21982.1 56.43,35.04 v1(56.54,34.94)
B_EQ1_1: length 5.9
  TOP w0.14: R21893.1 v1(65.95,43.6) 66.82,43.6 67.58,42.84 U13147.24
  BOTTOM w0.14: R21893.1 v1(65.95,43.6) v1(67.43,43.6)
B_EQ1_2: length 4.3
  TOP w0.14: R21921.1 41.3,37.84 v1(41.43,37.7) 41.59,37.7 42.16,37.12 U13149.24
  BOTTOM w0.14: R21921.1 41.3,37.84 v1(41.43,37.7)
B_EQ1_3: length 5.3
  TOP w0.14: R21928.1 49.94,47.2 50.41,46.73 50.85,46.73 v1(51.28,46.3) 51.43,46.14 U13148.24
  BOTTOM w0.14: R21929.2 49.71,47.43 50.41,46.73 50.85,46.73 v1(51.28,46.3)
B_EQ1_5: length 1.8
  TOP w0.14: R21690.2 27.96,53.3 U13124.14
B_EQ2: length 5.4
  TOP w0.14: v1(54.08,34.29) 54.4,34.29 54.64,34.54 55.2,34.54 R21886.1 56.18,34 v1(56.43,34.26) 56.56,34.38 57.12,34.38 57.57,33.93 U13146.25
  BOTTOM w0.14: v1(56.43,34.26) 56.18,34 R21886.1
B_EQ2_1: length 4.8
  TOP w0.14: R21894.1 65.54,42.99 v1(66.77,42.99) 66.87,42.89 67.08,42.89 67.53,42.44 U13147.25
  BOTTOM w0.14: R21894.1 65.6,43.25 65.86,42.99 v1(66.77,42.99)
B_EQ2_2: length 5.6
  TOP w0.14: R21922.1 40.2,36.87 40.66,37.33 v1(40.89,37.33) 40.99,37.23 41.65,37.23 42.16,36.72 U13149.25
  BOTTOM w0.14: v1(42.23,37.76) 41.7,37.23 40.99,37.23 v1(40.89,37.33) 40.71,37.33 40.25,36.87 R21922.1
B_EQ2_3: length 5.3
  TOP w0.14: U13148.25 51.96,45.74 51.92,45.79 51.12,45.79 50.74,46.17 v1(50.59,46.17) 50.41,46.35 R21930.1
  BOTTOM w0.14: R21931.2 50.39,46.37 v1(50.59,46.17) 50.72,46.17 51.15,45.74 51.73,45.74 v1(51.89,45.89)
BAT-V:
  vias: v1(104.29,49.67) v1(147.44,49.24)
BATLOW#: length 43.5
  TOP w0.102: U13113.BD13 312.96,58.46 317.6,58.46
  TOP w0.14: 317.6,58.46 317.81,58.25 320.06,58.25 320.2,58.39 320.7,58.39 321.1,58.79 v1(321.1,58.89) R21149.2 ; R67157.2 349.4,61.84 v1(349.91,62.35)
  IN3 w0.079: v1(349.91,62.35) 349.51,61.95 343.63,61.95 342.84,62.74 336.53,62.74 336.06,63.21 336.04,63.21 335.05,64.21 v1(335.05,64.86)
  IN5 w0.089: v1(335.05,64.86) 334.26,64.07 332.33,64.07 330.14,61.88 327.15,61.88 326.7,61.43 324.38,61.43 324.2,61.26 323.44,61.26 322.08,59.9 321.53,59.9 321.1,59.47 v1(321.1,58.89)
BBS_BIT1: length 7.2
  TOP w0.14: U13113.BA41 311.12,72.66 v2(310.79,72.99)
  BOTTOM w0.14: v2(310.79,72.99) 310.7,73.08 310.7,74.4 311.96,75.66 311.96,75.89 v1(312.54,76.47) 313.07,77 R21258.1 313.07,77.67 313.42,78.03 R21251.2
BEEP1: length 4.6
  TOP w0.203: D13038.1 17.66,32.07 17.98,31.75 18.45,31.75 18.76,32.07 D13039.1 19.56,32.07 v1(19.65,31.97)
  BOTTOM w0.14: R21441.2 20.46,30.97 v1(20.37,30.88)
  BOTTOM w0.203: R21441.2 19.91,31.72 v1(19.65,31.97)
BEEP2: length 7.7
  TOP w0.203: v1(23.62,28.87) 23.79,29.05 24.23,29.05 24.28,29.1 C94923.1
  BOTTOM w0.203: R22060.1 C94924.1 21.36,32.22 21.24,32.11 R21441.1 20.95,31.43 20.95,30.47 21.28,30.14 21.86,30.14 v1(22.35,29.66) 23.13,28.87 v1(23.62,28.87)
BEEP3: length 2.1
  TOP w0.203: U13108.34 25.93,30.06 24.96,29.1 C94923.2
BI: length 33.4
  TOP w0.14: PJ1.6 164.35,56.63 164.71,56.99 v1(164.71,57.19) ; Q44.3 175.97,74.21 175.58,73.83 v1(174.95,73.83)
  BOTTOM w0.14: v1(174.95,73.83) 174.54,73.83 173.68,72.97 172.96,72.97 172.11,72.11 172.11,71 172.21,70.9 172.21,69.85 171.54,69.18 165.6,69.18 163.52,67.1 163.52,66.31 163.19,65.98 163.19,61.71 162.73,61.26 162.73,60.09 163.29,59.53 163.29,58.71 162.22,57.64 162.22,56.86 163.05,56.04 PR10.1 163.74,56.04 164.71,57.01 v1(164.71,57.19)
BI_GATE: length 231.1
  TOP w0.14: v1(174.57,62.96) 174.57,62.98 174.92,63.34 174.92,65.52 174.67,65.78 174.09,65.78 173.32,65.02 172.16,65.02 171.98,65.19 171.98,65.37 172.4,65.79 173.51,65.79 173.76,66.04 Q42.5 173.76,67.35 174.16,67.76 174.9,67.76 C853.1 175.18,68.76 R618.2 175.58,68.98 175.71,68.85 175.71,68.72 175.93,68.5 176.5,68.5 176.85,68.85 v1(178.23,68.85) 178.23,69.13 178.05,69.31 177.44,69.31 177.19,69.56 177.19,70.81 v1(177.44,71.06) 177.79,71.06 178.38,71.64 178.38,72.28 178.58,72.48 Q44.2
  IN2 w0.089: v1(195.22,61.05) 194.63,61.64 194.63,62.44 193.52,63.55 193.52,64.23 192.55,65.2 192.55,66.01 192.22,66.33 190,66.33 189.63,66.7 182.78,66.7 182.04,65.96 179.82,65.96 177.88,64.02 175.64,64.02 v1(174.57,62.96)
  IN3 w0.079: v1(44.32,67.45) 43.38,66.51 43.38,64.91 44.21,64.08 45.21,64.08 47.34,61.94 54.3,61.94 56.1,60.14 59.58,60.14 60.13,59.59 60.13,59.37 62.44,57.07 62.84,57.07 64.5,55.4 64.52,55.38 65.78,55.38 66.74,54.42 68.08,54.42 69.74,52.76 72.79,52.76 73.69,51.86 86.19,51.86 88.1,53.77 100.23,53.77 102.46,56 102.46,59.29 103.22,60.05 105.41,60.05 105.68,59.78 105.68,59.31 106.87,58.12 114.64,58.12 115.45,58.94 127.49,58.94 128.11,58.31 145.58,58.31 146.04,57.85 152.12,57.85 153.94,59.68 157.63,59.68 159,61.05 166.1,61.05 171.69,66.64 175.02,66.64 177.23,68.85 v1(178.23,68.85)
  BOTTOM w0.14: R67293.2 25.55,54.45 25.42,54.58 25.42,55.8 25.67,56.05 SW1.1 26.25,56.05 26.71,55.59 28.52,55.59 SW1.2 30.4,57.47 30.4,57.93 31.92,59.45 31.92,61.08 33.04,62.2 35.33,62.2 40.43,67.3 44.17,67.3 v1(44.32,67.45) ; R67295.1 194.3,61.43 194.69,61.05 v1(195.22,61.05)
BL#:
  vias: v1(345.97,90.36)
BL_ON:
  vias: v1(347.16,89.7) v1(347.82,90.36)
BLON_EN:
  vias: v1(352.6,92.02)
BLONCON: length 10.7
  TOP w0.14: v1(354.85,82.38) CN2042.32
  IN4 w0.089: v1(354.85,82.38) 354.85,82.8 353.84,83.81 v1(353.84,88.41)
  BOTTOM w0.14: v1(351.97,89.33) 352.74,89.33 R22069.2 R22068.2 v1(353.84,88.41)
BOARD_ID0: length 11.4
  TOP w0.14: U13113.AL36 306.53,70.19 v2(306.09,70.63)
  BOTTOM w0.14: v2(306.09,70.63) 306.04,70.63 305.58,71.09 305.58,73.07 305.43,73.22 305.43,75.46 v1(305.48,75.51) 305.96,75.99 305.96,76.37 305.85,76.48 305.85,77.99 R21304.2 306.07,78 306.34,78.27 306.34,79.47 305.79,80.03 R21305.1
BOARD_ID1: length 13.1
  TOP w0.14: U13113.AL35 306.35,69.43 v2(305.96,69.82)
  BOTTOM w0.14: v1(306.69,69.84) 306.67,69.82 v2(305.96,69.82) 305.3,70.48 305.3,72.86 305.15,73.01 305.15,75.07 304.79,75.43 R21284.2 304.59,78.02 304.31,78.3 304.31,78.83 304.28,78.86 304.28,79.82 304.67,80.21 R21285.1
BOARD_ID2: length 10
  TOP w0.102: 304.24,74.54 304.62,74.15 304.62,73.47 304.57,73.42 304.57,73.17 304.74,73 304.81,73 305.15,72.66 305.15,72.15 305.46,71.84 U13113.AJ39
  TOP w0.14: R21287.1 303.68,80.12 303.33,79.78 303.33,79.1 303.19,78.96 303.19,78.48 303.44,78.23 R21286.2 303.88,78.03 303.88,77.63 304.36,77.15 304.36,75.45 304.24,75.33 304.24,74.54
BOARD_ID3: length 7.5
  TOP w0.102: U13113.AJ43 305.15,73.7 305.15,74.07 305.3,74.31 305.3,75.25 305.2,75.35
  TOP w0.14: R21289.1 305.33,79.98 305.22,79.87 305.22,78.29 305.03,78.1 R21288.2 304.82,77.76 304.89,77.69 304.89,75.66 305.2,75.35
BOARD_ID4: length 6.2
  TOP w0.14: U13113.AL43 306.85,73.22 306.85,72.97 v2(307.06,72.76)
  BOTTOM w0.14: v2(307.06,72.76) 306.61,72.76 305.99,73.39 R21290.2 306.14,73.71 306.47,74.03 306.47,74.54 306.6,74.67 306.6,75.2 306.7,75.3 v1(306.7,76.12) 306.95,76.37 R21291.1
BOARD_ID5: length 12.2
  TOP w0.102: 305.4,75.91 305.4,75.53 305.5,75.43 305.5,74.38 U13113.AK44
  TOP w0.14: 305.4,75.91 v1(305.4,76.19)
  IN1 w0.089: v1(305.4,76.19) 303.75,77.84 300.58,77.84 299.64,78.78 v1(299.64,79.34)
  BOTTOM w0.14: v1(299.64,79.34) v1(299.64,80) 299.82,80 299.97,79.85 R21292.2 R21293.1
BOARD_ID6: length 15.6
  TOP w0.102: U13113.AK45 305.71,74.68 305.71,75.76
  TOP w0.14: v1(305.38,76.98) 305.91,76.45 305.91,75.97 305.71,75.76 ; v1(297.56,80.08) 297.81,80.33 297.81,80.59 298.7,81.47 R21294.2 R21295.1
  IN1 w0.089: v1(297.56,80.08) 297.61,80.13 300.86,80.13 302.66,78.32 304.03,78.32 v1(305.38,76.98)
BOARD_ID7: length 7.5
  TOP w0.102: U13113.BC22 312.68,62.68 313.13,62.68 313.2,62.75 317.32,62.75
  TOP w0.14: 317.32,62.75 317.47,62.75 317.75,63.03 R21296.2 R21297.1
BOARD_ID8: length 12.6
  TOP w0.102: U13113.BD18 312.89,61.05 314.19,61.05 314.55,61.41 314.55,61.56 314.73,61.74 315.5,61.74 316.95,60.29 317.34,60.29 317.7,59.93
  TOP w0.14: R21298.1 R67022.2 322.22,61.05 321.97,60.8 321.41,60.8 321.26,60.65 319.96,60.65 319.15,59.84 317.79,59.84 317.7,59.93
BOARD_ID9: length 8.2
  TOP w0.102: U13113.BE21 313.53,62.55 316.15,62.55 316.25,62.45 317.58,62.45
  TOP w0.14: v1(318.69,62.64) 317.77,62.64 317.58,62.45
  BOTTOM w0.14: R21300.2 318,61.95 v1(318.69,62.64) 318.88,62.64 319.58,61.94 R21301.1
BOARD_ID11: length 11.6
  TOP w0.102: U13113.BD21 313.04,62.11 313.47,62.11 313.7,62.35 315.97,62.35 316.15,62.17 317.7,62.17
  TOP w0.14: 317.7,62.17 318.89,62.17 319.37,62.65 321.42,62.65 v1(321.6,62.48) 321.8,62.48 322.4,63.08 R67226.2 R67221.1
BOARD_ID12: length 13.6
  TOP w0.102: v2(312.35,62.32) 312.35,62.54 311.91,62.98 U13113.BB22
  IN1 w0.089: v2(312.35,62.32) 312.48,62.45 317.27,62.45 317.52,62.2 319.12,62.2 319.55,62.62 321.2,62.62 v1(321.81,63.24)
  BOTTOM w0.14: v1(321.81,63.24) 321.98,63.07 R67223.2 322.64,63.07 R67225.1 322.07,62.07 v1(321.97,62.17)
BOARD_ID13: length 8.3
  TOP w0.102: U13113.BC19 312.57,61.91 313.57,61.91 313.81,62.15 315.78,62.15 316.05,61.87 316.05,61.76 316.63,61.18
  TOP w0.14: 316.63,61.18 317.72,61.18 317.87,61.33 R67224.2 318,61.81 319.33,61.81 319.45,61.94 R67227.1
BT_POWERON: length 154.3
  TOP w0.14: v1(56.99,51.68) 56.97,51.71 56.97,53 56.48,53.48 56.48,55.39 56.38,55.49 56.38,55.63 54.6,57.41 54.6,60.21 53.82,61 CN2068.54
  IN3 w0.079: v1(187.95,59.1) 187.65,59.1 186.71,58.15 182.22,58.15 181.8,58.57 178.54,58.57 176.46,56.49 175.22,56.49 174.64,55.91 172.73,55.91 170.96,54.14 170.96,52.82 168.37,50.23 94,50.23 89.97,46.2 89,46.2 88,45.2 74.92,45.2 74.71,44.99 73.92,44.99 73.42,45.49 67.97,45.49 66.7,46.76 65.89,46.76 64.98,47.67 62.54,47.67 62.54,47.67 61.41,47.67 60.6,48.48 60.33,48.48 59.58,49.24 58.22,49.24 56.99,50.47 v1(56.99,51.68)
  BOTTOM w0.14: v1(187.95,59.1) 188.26,59.41 R67312.1
BUFRST: length 10.1
  TOP w0.127: v2(149.2,117.37) U13114.BF9
  BOTTOM w0.14: TP13106.1 148.53,108.74 148.53,113.8 149.04,114.32 149.04,115.46 148.76,115.74 148.76,116.93 v2(149.2,117.37)
C_GPU_TBT_AUXN: length 4.8
  TOP w0.14: C94556.2 R20841.2 335.05,50 334.82,50.23 334.82,51.88 334.23,52.47 U13025.25
C_GPU_TBT_AUXP: length 4.9
  TOP w0.14: C94555.2 R20842.1 334.28,50 334.5,50.22 334.5,51.75 333.83,52.42 U13025.24
C_GPU_TBT_D0: length 1.6
  TOP w0.14: C93687.2 330.8,58.26 331.52,58.26 331.56,58.3 U13025.9
C_GPU_TBT_D0#: length 1.6
  TOP w0.14: U13025.10 331.56,57.9 331.52,57.94 330.74,57.94 C94548.2
C_GPU_TBT_D1: length 2.8
  TOP w0.14: U13025.12 331.56,57.1 331.52,57.06 329.49,57.06 C94553.2
C_GPU_TBT_D1#: length 2.8
  TOP w0.14: C94554.2 329.43,56.48 329.69,56.74 331.52,56.74 331.56,56.7 U13025.13
C_GPU_TBT_D2: length 1.6
  TOP w0.14: C94551.2 330.79,55.85 331.39,55.85 331.44,55.9 U13025.15
C_GPU_TBT_D2#: length 1.6
  TOP w0.14: C94552.2 330.74,55.53 331.31,55.53 331.35,55.5 U13025.16
C_GPU_TBT_D3: length 2.9
  TOP w0.14: U13025.18 331.6,54.7 331.57,54.67 330.93,54.67 330.74,54.47 329.53,54.47 C94549.2
C_GPU_TBT_D3#: length 2.9
  TOP w0.14: U13025.19 331.6,54.3 331.55,54.35 331.06,54.35 330.87,54.16 329.52,54.16 C94550.2
C_INT_DP_AUXN: length 14
  TOP w0.14: Q7903.3 249.08,164.34 v1(248.74,164.68) ; CN2043.17 250.71,171.92 250.4,171.61 250.4,171.29 251.15,170.55 251.15,169.15 251.29,169 251.47,169 R20985.2 251.61,168.64 251.49,168.53 251.04,168.53 250.92,168.42 250.92,168.28 251.11,168.1 ESD8.9 ESD8.2 251.11,166.34 250.72,165.95 250.72,165.59 250.82,165.49 251.06,165.49 251.35,165.19 251.35,165.07 251.23,164.94 v1(251.23,164.81) 251.61,164.81 251.73,164.68 251.73,164.4 251.61,164.28 C94740.1
  IN2 w0.089: v1(251.23,164.81) 250.97,164.56 248.86,164.56 v1(248.74,164.68)
C_INT_DP_AUXP: length 14.3
  TOP w0.14: CN2043.15 250.08,171.69 250.08,171.16 250.83,170.41 250.83,169.33 R20986.1 250.61,168.62 ESD8.10 ESD8.1 250.6,166.65 249.1,166.65 248.28,165.83 248.28,164.76 248.08,164.56 v1(248.08,164.53) 248.31,164.3 C94742.1 ; v1(245.51,164.68) 245.85,164.34 Q7904.3
  IN2 w0.089: v1(245.51,164.68) 245.57,164.62 247.99,164.62 v1(248.08,164.53)
C_OUT_DP_TXN0: length 4.2
  TOP w0.14: C94719.1 241.7,168.47 D13080.2 241.61,169.02 241.29,169.33 241.29,170.63 241.78,171.11 241.78,171.56 CN2043.3
C_OUT_DP_TXN1: length 5
  TOP w0.14: C94738.1 D13082.2 244.25,169.02 243.97,169.3 243.97,170.82 244.13,170.99 244.13,172.55 CN2043.6
C_OUT_DP_TXN2: length 4.3
  TOP w0.14: C94736.1 D13084.2 246.69,169.02 246.35,169.36 246.35,170.26 245.63,170.99 245.63,171.56 CN2043.9
C_OUT_DP_TXN3: length 5.6
  TOP w0.14: C94721.2 D13086.2 248.81,169.02 248.54,169.29 248.54,170.29 247.14,171.7 247.14,172.56 CN2043.12
C_OUT_DP_TXP0: length 4.2
  TOP w0.14: CN2043.1 241.46,171.6 241.46,171.24 240.98,170.76 240.98,169.28 240.71,169.02 D13079.2 240.56,168.47 C94726.1
C_OUT_DP_TXP1: length 5.1
  TOP w0.14: CN2043.4 243.82,172.6 243.82,171.12 243.65,170.95 243.65,169.21 243.45,169.02 D13081.2 C94737.1
C_OUT_DP_TXP2: length 4.3
  TOP w0.14: C94735.1 D13083.2 245.7,168.99 246.03,169.32 246.03,170.13 245.31,170.86 245.31,171.6 CN2043.7
C_OUT_DP_TXP3: length 5.6
  TOP w0.14: CN2043.10 246.82,172.6 246.82,171.56 248.22,170.16 248.22,169.23 248.01,169.02 D13085.2 C94720.2
C_OUT_EDP_TXN0: length 7.9
  TOP w0.14: U13079.39 336.75,76.32 336.79,76.36 338.36,76.36 339,75.72 340.59,75.72 341.65,76.79 342.3,76.79 342.87,77.36 342.87,77.67 C94677.1
C_OUT_EDP_TXN1: length 9.8
  TOP w0.14: U13079.36 336.75,75.11 336.79,75.16 337.77,75.16 338.17,74.76 341.03,74.76 342.09,75.82 343.03,75.82 344.38,77.18 344.38,77.66 C94688.1
C_OUT_EDP_TXN2: length 13.4
  TOP w0.14: v1(340.46,74.25) 340.17,73.96 339.39,73.96 339.25,74.1 337.82,74.1 337.64,74.27 336.93,74.27 336.88,74.32 U13079.34 ; C94690.1 v1(345.97,77.21)
  IN5 w0.089: v1(345.97,77.21) 345.66,77.51 345.66,77.74 345.41,77.99 343.99,77.99 341.22,75.22 341.22,74.11 341.02,73.91 340.81,73.91 v1(340.46,74.25)
C_OUT_EDP_TXN3: length 17.9
  TOP w0.14: v1(339.7,72.6) 339.46,72.36 339.15,72.36 338.44,73.08 336.77,73.08 336.73,73.11 U13079.31 ; C94694.1 v1(347.49,77.21)
  IN5 w0.089: v1(339.7,72.6) 339.9,72.41 340.18,72.41 340.25,72.48 340.25,72.74 339.57,73.42 339.57,74.72 343.58,78.73 346.24,78.73 347.2,77.78 347.2,77.5 v1(347.49,77.21)
C_OUT_EDP_TXP0: length 7.9
  TOP w0.14: U13079.40 336.75,76.71 336.79,76.67 338.49,76.67 339.13,76.04 340.46,76.04 341.52,77.11 342.17,77.11 342.55,77.49 342.55,77.75 342.46,77.84 342.28,77.84 C94676.1
C_OUT_EDP_TXP1: length 9.8
  TOP w0.14: C94684.1 343.81,77.85 344.01,77.85 344.06,77.79 344.06,77.31 342.89,76.14 341.96,76.14 340.9,75.07 338.3,75.07 337.9,75.47 336.79,75.47 336.75,75.51 U13079.37
C_OUT_EDP_TXP2: length 13.4
  TOP w0.14: v1(345.13,77.21) 345.21,77.28 C94689.1 ; v1(340.46,73.35) 340.17,73.64 339.26,73.64 339.12,73.78 337.69,73.78 337.51,73.96 336.98,73.96 336.94,73.92 U13079.33
  IN5 w0.089: v1(340.46,73.35) 340.46,73.56 340.63,73.73 341.09,73.73 341.4,74.03 341.4,75.15 344.06,77.82 345.34,77.82 345.49,77.67 345.49,77.33 345.36,77.21 v1(345.13,77.21)
C_OUT_EDP_TXP3: length 17.9
  TOP w0.14: v1(339.7,71.81) 339.46,72.05 339.02,72.05 338.31,72.76 336.93,72.76 336.88,72.71 U13079.30 ; v1(346.73,77.21) C94693.1
  IN5 w0.089: v1(346.73,77.21) 347.02,77.5 347.02,77.7 346.17,78.55 343.66,78.55 339.75,74.64 339.75,73.5 340.43,72.81 340.43,72.41 340.25,72.23 339.8,72.23 339.7,72.13 v1(339.7,71.81)
C_PCIE_RXN3_C: length 3.4
  TOP w0.079: U21.K22 351.2,48.33 351.2,47.57 350.67,47.04 350.67,46.64
  TOP w0.14: C94577.1 350.67,46.64
C_PCIE_RXN4_C: length 4.2
  TOP w0.079: 352.57,47.15 352.57,47.16 352.57,47.16 352.57,48.33 U21.F22
  TOP w0.14: 352.57,47.15 352.57,46.32 352.3,46.04 351.89,46.04 351.56,45.71 C94579.1
C_PCIE_RXP3_C: length 3.3
  TOP w0.079: 350.4,46.64 350.4,46.75 350.51,46.85 350.51,47.1 351.04,47.64 351.04,48.03 U21.K23
  TOP w0.14: 350.4,46.64 350.4,45.87 350.26,45.73 350.26,45.58 350.21,45.53 C94578.1
C_PCIE_RXP4_C: length 4.1
  TOP w0.079: U21.F23 352.73,48.03 352.73,47.33 352.84,47.22 352.84,47.21
  TOP w0.14: C94580.1 352.04,45.15 351.96,45.23 351.96,45.36 351.82,45.5 351.82,45.6 352,45.77 352.41,45.77 352.84,46.21 352.84,47.21
C_PEG_TX0: length 13.1
  TOP w0.079: 224.21,109.99 224.22,109.99 224.28,110.04 224.36,110.04 224.43,109.98 224.82,109.98 224.98,109.82 226.22,109.82 226.44,110.04 226.44,110.18 U41.C10
  TOP w0.14: C94277.2 214.76,109.61 215.32,109.61 216.18,110.47 221.63,110.47 222.02,110.07 223.78,110.07 223.87,109.99 224.21,109.99
C_PEG_TX1: length 12
  TOP w0.079: U41.A11 225.55,111.08 225.61,111.14 225.61,111.23 225.42,111.42 225.07,111.42 224.65,111.01 224.22,111.01 224.17,110.95 224.15,110.95
  TOP w0.14: 224.15,110.95 223.43,110.95 223.2,111.18 214.74,111.18 C94275.2
C_PEG_TX2: length 11.4
  TOP w0.079: 224.15,112.04 224.21,112.04 224.21,112.05 224.44,112.05 224.58,112.19 225.36,112.19 225.55,111.99 225.55,111.79 225.79,111.56 226.25,111.56 U41.C12
  TOP w0.14: 224.15,112.04 223.92,112.04 223.77,111.89 215.8,111.89 C94273.2
C_PEG_TX3: length 11.2
  TOP w0.079: 224.15,112.6 224.17,112.6 224.22,112.66 224.73,112.66 225.07,112.99 225.5,112.99 225.61,112.88 225.61,112.76 225.51,112.66 U41.A13
  TOP w0.14: C94271.2 215.76,113.48 215.92,113.63 216.03,113.63 216.29,113.37 216.29,113.27 216.95,112.6 224.15,112.6
C_PEG_TX4: length 12.1
  TOP w0.079: U41.C14 226.27,113.16 225.79,113.16 225.55,113.39 225.55,113.57 225.36,113.77 224.56,113.77 224.48,113.69 224.22,113.69 224.17,113.63 224.15,113.63
  TOP w0.14: C94269.2 215.77,114.9 217.35,113.33 223.74,113.33 224.05,113.63 224.15,113.63
C_PEG_TX5: length 9.8
  TOP w0.079: 224.15,114.16 224.17,114.16 224.22,114.21 224.71,114.21 225.07,114.57 225.25,114.57 225.37,114.45 225.37,114.34 U41.A15
  TOP w0.14: 224.15,114.16 223.69,114.16 223.57,114.04 217.65,114.04 216.94,114.76 216.94,114.93 C94267.2
C_PEG_TX6: length 13
  TOP w0.079: U41.C16 226.27,114.73 225.79,114.73 225.55,114.97 225.55,115.14 225.36,115.34 224.58,115.34 224.44,115.19 224.21,115.19 224.21,115.19 224.15,115.19
  TOP w0.14: C94265.2 217.19,116.93 217.33,116.79 217.59,116.79 217.89,116.49 217.89,115.22 218.35,114.76 223.18,114.76 223.61,115.19 224.15,115.19
C_PEG_TX7: length 11.4
  TOP w0.079: U41.A17 225.57,115.81 225.62,115.86 225.62,116.08 225.56,116.14 225.07,116.14 224.7,115.77 224.22,115.77 224.17,115.72 224.15,115.72
  TOP w0.14: 224.15,115.72 223.79,115.72 223.56,115.96 222.3,115.96 221.82,115.47 218.87,115.47 218.6,115.74 218.6,116.42 218.87,116.69 219.34,116.69 219.48,116.83 219.48,117.27 219.32,117.43 218.93,117.43 C94263.2
C_PEG_TX8: length 11.4
  TOP w0.079: U41.B18 226.15,116.6 226.27,116.72 226.27,116.83 226.17,116.93 224.49,116.93 224.37,116.81 224.22,116.81 224.17,116.75 224.15,116.75
  TOP w0.14: 224.15,116.75 223.86,116.75 223.78,116.67 222.79,116.67 222.57,116.89 222.2,116.89 221.49,116.18 220.58,116.18 220.19,116.57 220.19,116.96 220.35,117.12 220.35,117.4 219.86,117.9 219.86,118.46 219.97,118.57 219.97,118.8 219.64,119.13 219.39,119.13 219.22,118.96 218.96,118.96 C94261.2
C_PEG_TX9: length 11.2
  TOP w0.079: U41.B19 225.79,117.5 225.79,117.69 225.64,117.85 224.97,117.85 224.65,117.52 224.29,117.52 224.23,117.58 224.21,117.58
  TOP w0.14: 224.21,117.58 223.27,117.58 222.64,118.2 222.13,118.2 221.63,117.71 221.43,117.71 221.15,117.99 221.15,118.2 221.53,118.58 221.53,119.08 221.24,119.37 220.89,119.37 220.8,119.47 220.8,119.82 220.55,120.07 220.09,120.07 219.98,120.17 219.98,120.62 219.73,120.87 219.19,120.87 219.07,120.74 218.96,120.74 C94259.2
C_PEG_TX10: length 11.2
  TOP w0.079: 224.21,118.28 224.22,118.28 224.23,118.29 224.23,118.3 224.44,118.5 226.17,118.5 226.25,118.43 226.25,118.29 226.13,118.17 U41.B20
  TOP w0.14: 224.21,118.28 223.26,118.28 222.9,118.65 222.6,118.65 219.5,121.75 218.26,121.75 217.88,121.37 217.66,121.37 C94257.2
C_PEG_TX11: length 10.7
  TOP w0.079: 224.21,119.16 224.22,119.16 224.28,119.1 224.65,119.1 224.98,119.42 225.56,119.42 225.75,119.23 225.75,119.11 U41.B21
  TOP w0.14: C94255.2 217.72,123.11 217.77,123.11 217.91,122.97 219.66,122.97 223,119.63 223.48,119.63 223.95,119.16 224.21,119.16
C_PEG_TX12: length 9.7
  TOP w0.079: 223.96,120.07 224.17,120.07 224.3,120.2 224.85,120.2 224.97,120.08 226.17,120.08 226.28,119.97 226.28,119.85 226.18,119.75 U41.B22
  TOP w0.14: C94253.2 219.05,123.65 219.6,123.65 223.18,120.07 223.96,120.07
C_PEG_TX13: length 9.8
  TOP w0.079: U41.B23 225.77,120.67 225.77,120.82 225.59,121 225,121 224.87,120.87 224.43,120.87 224.34,120.96 223.92,120.96 223.86,121.01 223.84,121.01
  TOP w0.14: 223.84,121.01 223.56,121.01 223.19,121.38 223.19,121.45 219.79,124.85 219.55,124.85 218.95,125.44 218.69,125.44 C94251.2
C_PEG_TX14: length 9
  TOP w0.079: U41.B24 226.18,121.32 226.27,121.42 226.27,121.55 226.17,121.65 224.85,121.65 224.7,121.8 223.92,121.8 223.86,121.75 223.84,121.75
  TOP w0.14: 223.84,121.75 223.58,121.75 220.99,124.34 220.99,125.26 220.55,125.69 220.46,125.69 C94249.2
