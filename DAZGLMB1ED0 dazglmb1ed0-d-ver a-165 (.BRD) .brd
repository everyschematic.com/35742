# Allegro board DAZGLMB1ED0 dazglmb1ed0-d-ver a-165 (.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FBA_DBI3: length 36.4
  TOP w0.102: U13135.E3 203.49,141.5 203.49,140 v4(203.03,139.54)
  TOP w0.216: U13114.AC48 176.19,133.81 v4(176.51,134.13)
  IN4 w0.14: v4(176.51,134.13) 176.51,134.1 176.92,133.69 178.36,133.69 178.53,133.52 186.63,133.52 187.66,132.49 199.86,132.49 200.2,132.83 200.2,133.58 200.7,134.08 200.7,138.7 201.32,139.33 202.82,139.33 v4(203.03,139.54)
FBA_DBI4: length 23
  TOP w0.216: U13114.BB51 v4(178.62,120.15) ; v4(196.99,116.6) U13136.E3
  IN4 w0.081: v4(196.99,116.6) 196.67,116.28 196.67,115.69
  IN4 w0.14: v4(178.62,120.15) 178.62,120.13 179.05,119.7 180.26,119.7 181.02,118.94 188.39,118.94 192.48,114.85 196.4,114.85 196.71,115.16 196.71,115.65 196.67,115.69 196.67,115.69
FBA_DBI5: length 22.2
  TOP w0.216: U13114.AV50 177.56,123.34 177.85,123.63 v4(177.91,123.63) ; v4(196.34,122.45) U13136.E12
  IN4 w0.081: 196.67,121.61 196.67,122.13 v4(196.34,122.45)
  IN4 w0.14: 196.67,121.61 196.67,121.56 196.36,121.25 183.41,121.25 180.64,124.02 178.86,124.02 178.68,123.84 178.12,123.84 v4(177.91,123.63)
FBA_DBI6: length 31.9
  TOP w0.216: U13114.AM48 176.46,127.82 v4(176.52,127.82) ; v4(203.49,122.45) 203.17,122.78 U13136.R12
  IN4 w0.081: v4(203.49,122.45) 203.17,122.78 203.17,123.36
  IN4 w0.14: 203.17,123.36 203.2,123.39 203.2,124.04 202.63,124.61 202.63,125.72 200.17,128.18 176.88,128.18 176.52,127.81 v4(176.52,127.82)
FBA_DBI7: length 35.2
  TOP w0.216: U13114.AR49 176.91,125.41 v4(177.21,125.71) ; v4(203.49,117.25) U13136.R3
  IN4 w0.14: v4(177.21,125.71) 177.21,125.7 177.57,125.34 178.08,125.34 179.02,126.28 199.03,126.28 199.53,125.79 199.53,125.49 199.22,125.18 199.22,120.21 201.06,118.37 202.35,118.37 203.47,117.25 v4(203.49,117.25)
FBA_DEBUG0: length 5.3
  TOP w0.102: U13114.Y50 177.59,135.91 v4(177.91,136.23)
  BOTTOM w0.14: v4(177.91,136.23) 177.91,136.2 177.99,136.12 v1(181.45,136.12) R21503.1
FBA_DEBUG1: length 5.5
  TOP w0.216: U13114.AR50 177.61,125.41 v4(177.91,125.71)
  BOTTOM w0.14: v4(177.91,125.71) 178.4,126.2 180.68,126.2 181.44,125.44 R21504.1
FBA_EDC0: length 23.5
  TOP w0.102: U13135.T3 195.69,142.15 v4(195.69,142.8)
  TOP w0.216: v4(176.51,139.1) 176.19,139.41 U13114.R48
  IN4 w0.14: v4(176.51,139.1) 176.51,139.12 176.87,139.49 183.1,139.49 184.21,140.6 189.52,140.6 192.76,143.84 195.25,143.84 195.4,143.7 195.4,143.1 v4(195.69,142.8)
FBA_EDC1: length 22.2
  TOP w0.216: v4(176.51,137) 176.19,137.31 U13114.V48 ; U13135.T12 195.69,135.65 v4(195.69,135.65)
  IN4 w0.14: v4(176.51,137) 176.58,136.93 176.58,136.29 177.29,135.57 177.95,135.57 178.46,135.06 190.49,135.06 191.92,136.49 193.34,136.49 194.18,135.65 v4(195.69,135.65)
FBA_EDC2: length 35.7
  TOP w0.102: v4(203.49,135) 203.49,135.65 U13135.D12
  TOP w0.216: v4(173.01,132.03) 173.32,131.71 U13114.AF44
  IN4 w0.14: v4(173.01,132.03) 173.01,132 173.37,131.64 184.89,131.64 186.06,130.47 200.74,130.47 203.22,132.96 203.22,133.64 203.49,133.91 v4(203.49,135)
FBA_EDC3: length 35.9
  TOP w0.216: v4(203.49,142.15) U13135.D3 ; v4(176.51,134.9) 176.19,135.21 U13114.AA48
  IN4 w0.14: v4(176.51,134.9) 176.88,135.27 177.39,135.27 178.41,134.25 187.93,134.25 188.39,133.8 198.9,133.8 199.31,134.2 199.31,136.62 199.02,136.9 199.02,138.73 200.68,140.4 201.73,140.4 201.82,140.48 203,140.48 203.49,140.98 v4(203.49,142.15)
FBA_EDC4: length 19.6
  TOP w0.216: v4(195.69,116.6) U13136.D3 ; U13114.BB52 178.96,120.49 v4(179.3,120.15)
  IN4 w0.081: v4(195.69,116.6) 195.37,116.28 194.15,116.28
  IN4 w0.14: 194.15,116.28 194.15,116.28 193.95,116.28 193.49,116.74 192.17,116.74 189.32,119.6 181.98,119.6 180.87,120.71 179.86,120.71 v4(179.3,120.15)
FBA_EDC5: length 20.7
  TOP w0.216: v4(195.69,123.1) U13136.D12 ; U13114.AT50 177.59,124.71 v4(177.91,124.4)
  IN4 w0.14: v4(177.91,124.4) 178.05,124.4 178.45,124.8 180.84,124.8 183.84,121.81 192.12,121.81 193.42,123.1 v4(195.69,123.1)
FBA_EDC6: length 33.3
  TOP w0.216: U13114.AK48 176.12,128.91 v4(175.81,128.6) ; v4(204.14,123.1) U13136.T12
  IN4 w0.14: v4(175.81,128.6) 176.2,128.99 177.4,128.99 177.52,128.87 184.55,128.87 184.7,128.72 200.88,128.72 203.73,125.87 203.73,124.38 203.77,124.34 203.77,123.48 v4(204.14,123.1)
FBA_EDC7: length 36.3
  TOP w0.102: U13114.AR51 178.92,126.07 179.55,126.07 v4(179.92,125.7)
  TOP w0.216: v4(204.14,116.6) U13136.T3
  IN4 w0.081: 203.8,115.69 203.82,115.7 203.82,116.28 v4(204.14,116.6)
  IN4 w0.14: 203.8,115.69 203.67,115.55 201.23,115.55 200.88,115.9 200.88,117.35 198,120.23 198,121.15 198.32,121.46 198.68,121.82 198.68,124.89 198.48,125.08 181.74,125.08 181.12,125.7 v4(179.92,125.7)
FBA_PLL_AVDD: length 105.8
  TOP w0.254: U13114.L38 169.16,142.19 v4(168.83,141.85) ; v4(150.64,137.02) 150.55,137.02 U13114.V11 ; v4(171.61,126.52) 171.91,126.81 U13114.AN42 ; v4(154.16,141.86) 154.46,142.16 U13114.L17 ; v4(171.61,132.03) 171.92,131.71 U13114.AF42 ; U13114.L29 162.86,142.18 v4(162.54,141.86)
  TOP w0.508: L4245.1 C95048.2 166.04,101.95 166.17,101.82 169.74,101.82 171.42,103.5 171.42,104.44 173.32,106.34 175.08,106.34 176.16,107.42 176.16,108.13 176.14,108.14 176.14,110.86 v1(175.66,111.34)
  IN1 w0.381: v4(162.54,141.86) 162.02,141.34 158.82,141.34 158.69,141.22 157.98,141.22 157.86,141.34 155.11,141.34 154.59,141.86 v4(154.16,141.86) 154.16,141.69 153.77,141.29 153.23,141.29 153.08,141.44 152.45,141.44 151.2,140.2 151.2,137.58 v4(150.64,137.02)
  IN4 w0.35: 181,117.41 178.97,117.41 177.57,118.81 176.19,118.81 172.56,122.44 172.56,123.15 170.58,125.13 170.58,126.68 171.09,127.19 171.09,131.13 171.61,131.65 v4(171.61,132.03) ; 169,141.85 v4(168.83,141.85) 168.28,141.31 163.12,141.31 162.57,141.86 v4(162.54,141.86)
  IN4 w0.381: 181,117.41 180.33,118.07 179.12,118.07 177.18,120 177.18,120.33 176.68,120.84 175,120.84 173.15,122.7 173.15,123.38 171.09,125.44 171.09,126 v4(171.61,126.52) ; 171.39,132.03 v4(171.61,132.03)
  IN4 w0.508: 169,141.85 169.77,141.09 170.5,141.09 170.94,140.66 170.94,132.48 171.39,132.03 ; v1(175.66,111.34) 175.53,111.47 175.53,113.12 176.55,114.14 178.33,114.14 178.84,114.65 180.11,114.65 181,115.54 181,117.41
  BOTTOM w0.203: C95060.1 150.67,137.05 v4(150.64,137.02) ; C95054.2 171.16,126.96 v4(171.61,126.52) ; v4(162.54,141.86) 162.55,141.85 C95053.2
FBA_VREFC: length 14
  TOP w0.25: U13136.K13 v4(200.24,123.75)
  TOP w0.254: U13135.K13 v4(200.24,135)
  TOP w0.406: v1(200.43,130.9) C95691.1 R21859.2 R21862.2 C95711.1 201.18,126.53 v4(201.17,126.51)
  BOTTOM w0.406: v4(200.24,135) 199.66,134.43 199.66,134.13 200.58,133.22 v1(200.58,133.06) R21860.2 200.58,131.05 v1(200.43,130.9) ; v4(200.24,123.75) 200.81,124.32 v1(200.81,125.37) 200.81,126.15 v4(201.17,126.51)
FBA_VREFC_CTL: length 2.6
  TOP w0.14: Q7876.3 202.81,128.11 v1(202.79,128.13) 202.31,128.62 R21862.1
FBB_CMD0: length 29
  TOP w0.102: 171.72,171.83 171.78,171.83 171.83,171.88 173.7,171.88 U13137.H4
  TOP w0.216: 171.72,171.83 170.94,171.83 v1(167.09,167.98) 167.09,156.34 166.01,155.26 166.01,153.03 166.68,152.35 166.68,149.05 167.06,148.67 U13114.B35
FBB_CMD1: length 26.6
  TOP w0.102: 171.92,170.6 172.41,170.6 U13137.K2
  TOP w0.136: 170.86,170.35 171.17,170.66 171.87,170.66 171.92,170.6
  TOP w0.17: 170.86,170.35 v4(170.8,170.29)
  TOP w0.216: U13114.A35 167.06,152.59 166.62,153.03 166.62,154.88 167.69,155.95 v1(167.69,164.91) 167.69,167.54 170.43,170.29 v4(170.8,170.29)
  BOTTOM w0.216: R22015.1 170.31,170.78 v4(170.8,170.29)
FBB_CMD2: length 27.3
  TOP w0.102: U13114.D35 167.41,147.46 167.41,149.5 ; U13137.M4 173.72,169.91 171.72,169.91
  TOP w0.216: 167.41,149.5 167.41,154.78 168.3,155.67 168.3,160.44 168.72,160.87 v1(168.72,161.81) 170.9,163.98 170.9,169.34 171.41,169.86 171.67,169.86 171.72,169.91
FBB_CMD3: length 25.4
  TOP w0.102: 173.22,164.08 173.58,164.08 173.8,164.29 175.09,164.29 175.36,164.56 175.36,168.14 175.03,168.48 175.03,169.9 U13137.L5
  TOP w0.216: U13114.A36 167.76,154.29 168.9,155.44 v1(168.9,159.76) 173.22,164.08
FBB_CMD4: length 27.3
  TOP w0.102: 173.97,163.98 175.1,163.98 175.58,164.46 175.58,168.24 175.26,168.56 175.26,170.31 174.98,170.58 174.35,170.58 U13137.L4 ; 168.08,149.44 168.08,149.08 167.76,148.75 U13114.B36
  TOP w0.216: 173.97,163.98 169.51,159.52 v1(169.51,158.08) 169.51,155.13 168.08,153.7 168.08,149.44
FBB_CMD5: length 27.5
  TOP w0.102: U13137.K5 175.04,170.91 175.48,170.46 175.48,168.64 175.79,168.33 175.79,164.31 175.16,163.67 ; 168.42,151.6 168.38,151.56 168.38,148.99 168.11,148.71 168.11,148.37 167.76,148.02 U13114.C36
  TOP w0.216: 168.42,151.6 168.42,153.2 170.12,154.91 v1(170.12,156.76) 170.12,159.27 174.52,163.67 175.16,163.67
FBB_CMD6: length 28.6
  TOP w0.102: 174.89,163.18 175.14,163.18 176.01,164.04 176.01,168.45 175.71,168.74 175.71,170.87 175.35,171.23 174.35,171.23 U13137.K4 ; U13114.C38 168.81,148.16 168.81,148.66 168.68,148.79 168.6,148.87 168.6,150.94 168.75,151.1
  TOP w0.216: 174.89,163.18 v1(170.73,159.02) 170.73,154.55 168.75,152.57 168.75,151.1
FBB_CMD7: length 27.3
  TOP w0.102: 168.94,150.75 168.85,150.66 168.85,148.98 169.16,148.68 U13114.B38 ; U13137.J5 175.41,171.56 175.94,171.02 175.94,168.84 176.23,168.55 176.23,163.88 175.26,162.91 175.26,162.68
  TOP w0.216: 168.94,150.75 169.07,150.88 169.07,152.38 171.34,154.65 v1(171.34,155.41) 171.34,158.74 175.26,162.66 175.26,162.68
FBB_CMD8: length 27.7
  TOP w0.102: U13137.J4 174.35,171.88 175.59,171.88 176.17,171.3 176.17,168.94 176.44,168.67 176.44,163.74 175.84,163.14 175.84,162.49
  TOP w0.17: U13114.A38 169.16,150.38
  TOP w0.216: 175.84,162.49 175.84,162.25 v1(171.95,158.36) 171.95,154.75 169.44,152.24 169.44,150.66 169.16,150.38
FBB_CMD9: length 29.9
  TOP w0.102: 176.45,162.49 176.45,163.29 176.66,163.5 176.66,168.77 176.4,169.03 176.4,171.17 177.11,171.88 178.25,171.88 U13137.J11 ; 169.54,150.21 169.54,147.49 U13114.D38
  TOP w0.216: 169.54,150.21 169.77,150.44 169.77,151.93 172.56,154.73 v1(172.56,156.3) 172.56,158.11 176.45,161.99 176.45,162.49
FBB_CMD10: length 26.6
  TOP w0.102: 177.06,163.57 177.06,163.82 176.89,163.99 176.89,168.87 176.63,169.13 176.63,170.99 177.3,171.66 177.82,171.66 U13137.J10
  TOP w0.216: U13114.A39 169.83,149.24 169.83,149.98 170.27,150.41 170.27,151.93 173.17,154.83 v1(173.17,157.47) 177.06,161.36 177.06,163.57
FBB_CMD11: length 26.1
  TOP w0.102: U13137.L10 177.82,170.16 177.15,170.16 176.86,169.86 176.86,169.23 177.11,168.97 177.11,164.1 177.67,163.54 177.67,163.24 ; U13114.B39 169.86,148.71 170.16,149.02 170.16,149.86
  TOP w0.216: 170.16,149.86 170.61,150.3 170.61,151.76 173.78,154.93 v1(173.78,155.67) 173.78,157.22 177.67,161.1 177.67,163.24
FBB_CMD12: length 27.6
  TOP w0.102: 178.28,162.97 178.28,163.32 177.34,164.25 177.34,169.09 177.08,169.35 177.08,169.8 177.22,169.93 178.25,169.93 U13137.L11 ; 170.92,150.61 170.92,150.25 170.38,149.71 170.38,148.89 170.18,148.69 170.18,148.29 169.86,147.96 U13114.C39
  TOP w0.216: 178.28,162.97 v1(178.28,160.85) 174.39,156.96 174.39,155.09 170.92,151.63 170.92,150.61
FBB_CMD13: length 26.7
  TOP w0.102: U13137.M11 178.25,169.28 177.77,169.28 177.57,169.09 177.57,164.55 178.43,163.69 ; U13114.C41 171.26,147.86 170.91,148.21 170.91,148.66 170.61,148.96 170.61,149.55 170.86,149.8
  TOP w0.216: 178.43,163.69 178.89,163.24 R22014.2 178.89,160.6 v1(177.24,158.94) 175,156.71 175,155.25 171.27,151.52 171.27,150.21 170.86,149.8
FBB_CMD14: length 28.7
  TOP w0.102: 180.92,170.45 180.79,170.58 179.55,170.58 U13137.K12
  TOP w0.216: U13114.B41 171.26,148.69 170.88,149.07 170.88,149.37 171.6,150.08 171.6,151.4 175.61,155.41 175.61,156.46 v1(181.56,162.41) 181.56,169.81 180.92,170.45
FBB_CMD15: length 31.4
  TOP w0.102: U13137.H11 178.9,171.88 181,171.88
  TOP w0.216: U13114.A41 171.92,149.87 171.92,151.19 175.97,155.24 176.12,155.24 176.22,155.34 176.22,156.21 v1(182.9,162.89) 182.9,170.8 181.82,171.88 181,171.88
FBB_CMD16: length 30.3
  TOP w0.102: U13114.B49 177.19,148.84 177.19,149.44 177.66,149.92 178.11,149.92 179.37,148.65 ; 200.94,149.44 200.94,150.4 200.88,150.46 200.88,152.3 U13138.M4
  TOP w0.216: 179.37,148.65 179.85,148.17 184.6,148.17 v1(185.29,147.49) 199.16,147.49 200.94,149.28 200.94,149.44
FBB_CMD17: length 28.7
  TOP w0.102: U13138.K2 200.26,150.99 200.26,150.42 200.21,150.37 200.21,149.49 200.05,149.33 ; 180.97,148.77 179.94,148.77 179.56,149.16 179.16,149.16 178.19,150.12 177.45,150.12 176.86,149.53 U13114.A49
  TOP w0.216: 200.05,149.33 v4(199.97,149.25) 198.94,148.22 v1(188.89,148.22) 186.08,148.22 185.53,148.77 180.97,148.77
  BOTTOM w0.216: R22017.1 199.41,148.69 v4(199.97,149.25)
FBB_CMD18: length 28.3
  TOP w0.102: U13114.A48 176.25,149.21 177.36,150.32 178.28,150.32 179.03,149.57 179.65,149.57 179.85,149.37 180.97,149.37 ; U13138.H4 198.94,152.31 199.42,152.31 199.57,152.15 199.57,150.5 199.49,150.41 199.49,150.04 199.36,149.91 199.36,149.57
  TOP w0.216: 180.97,149.37 186.28,149.37 v1(186.72,148.93) 198.71,148.93 199.36,149.57
FBB_CMD19: length 28.6
  TOP w0.102: 193.31,153.28 193.34,153.31 193.52,153.31 194.24,154.03 197.24,154.03 197.65,153.62 198.93,153.62 U13138.J5 ; U13114.D47 175.79,147.44 175.79,149.29 177.02,150.53 178.62,150.53 179.22,149.93
  TOP w0.216: 179.22,149.93 181.71,149.93 182.18,150.4 v1(188.39,150.4) 190.43,150.4 193.31,153.28
FBB_CMD20: length 27.9
  TOP w0.102: U13114.A47 175.46,149.34 176.86,150.74 178.91,150.74 179.24,150.41 180.97,150.41 ; 192.71,153.54 193.35,153.54 194.04,154.23 197.32,154.23 197.7,153.86 199.33,153.86 199.59,153.59 199.59,152.96 U13138.J4
  TOP w0.216: 192.71,153.54 190.16,150.99 v1(184.96,150.99) 181.91,150.99 181.33,150.41 180.97,150.41
FBB_CMD21: length 28.7
  TOP w0.102: 192.81,153.86 193.08,153.86 193.66,154.44 197.41,154.44 197.78,154.07 199.5,154.07 199.92,153.65 U13138.K5 ; 180.92,150.86 179.4,150.86 179.26,151 176.76,151 175.13,149.38 175.13,149.05 175.46,148.73 U13114.B47
  TOP w0.216: 180.92,150.86 181.68,151.63 v1(189.94,151.63) 192.16,153.86 192.81,153.86
FBB_CMD22: length 31.2
  TOP w0.102: 176.72,151.27 174.91,149.45 174.91,148.86 175.11,148.66 175.11,148.16 U13114.C47 ; U13138.K4 200.24,152.96 200.24,153.96 199.94,154.27 197.86,154.27 197.34,154.79 193.55,154.79 192.88,154.12 191.28,154.12
  TOP w0.216: 191.28,154.12 189.4,152.24 v1(186.79,152.24) 181.43,152.24 180.46,151.27 176.72,151.27
FBB_CMD23: length 31.4
  TOP w0.102: U13138.L5 200.57,154.02 200.11,154.47 197.95,154.47 197.42,154.99 193.14,154.99 192.87,154.73 191.28,154.73 ; 174.68,149.69 174.68,148.99 174.41,148.71 174.41,148.37 174.06,148.02 U13114.C45
  TOP w0.216: 174.68,149.69 176.63,151.63 179.95,151.63 181.22,152.9 v1(188.51,152.9) 190.34,154.73 191.28,154.73
FBB_CMD24: length 32.5
  TOP w0.102: 191.28,155.34 192.04,155.34 192.17,155.21 197.49,155.21 198.03,154.67 200.42,154.67 200.8,154.3 200.8,153.6 200.89,153.5 200.89,152.96 U13138.L4 ; 174.41,149.87 174.41,149.06 174.06,148.71 U13114.B45
  TOP w0.216: 191.28,155.34 191.18,155.34 191.08,155.44 189.66,155.44 187.88,153.66 v1(185.01,153.66) 181.13,153.66 179.42,151.96 176.5,151.96 174.41,149.87
FBB_CMD25: length 32.7
  TOP w0.102: U13138.L11 200.89,156.86 200.89,155.72 200.05,154.88 198.11,154.88 197.58,155.41 192.53,155.41 192.22,155.72 191.56,155.72
  TOP w0.216: 191.56,155.72 191,156.28 189.12,156.28 187.38,154.53 v1(182.9,154.53) 181.13,154.53 178.89,152.29 176.35,152.29 174.06,150 U13114.A45
FBB_CMD26: length 34.7
  TOP w0.102: U13114.D44 173.71,147.46 173.71,149.42 ; 191.89,156.25 192.2,156.25 192.83,155.62 197.68,155.62 198.22,155.08 199.84,155.08 200.67,155.91 200.67,156.43 U13138.L10
  TOP w0.216: 191.89,156.25 191.21,156.94 188.36,156.94 186.71,155.28 v1(181.02,155.28) 178.36,152.62 176.22,152.62 173.71,150.11 173.71,149.42
FBB_CMD27: length 32.4
  TOP w0.102: 192.15,156.73 193.06,155.82 197.78,155.82 198.32,155.28 198.8,155.28 199.17,155.66 199.17,156.43 U13138.J10
  TOP w0.216: 192.15,156.73 192.15,156.86 191.18,157.83 v1(184.22,157.83) 182.32,157.83 179.45,154.96 179.45,154.55 177.85,152.95 176.09,152.95 173.36,150.22 U13114.A44
FBB_CMD28: length 34.8
  TOP w0.102: 193.11,156.18 193.36,156.18 193.52,156.02 197.91,156.02 198.37,155.57 198.7,155.57 198.94,155.81 198.94,156.86 U13138.J11 ; U13114.B44 173.36,148.66 173.03,148.99 173.03,150.35 173.21,150.52
  TOP w0.216: 173.21,150.52 176.14,153.46 177.46,153.46 178.66,154.65 178.66,155.03 182.21,158.59 v1(186.02,158.59) 191.38,158.59 192.58,157.4 192.58,156.71 193.11,156.18
FBB_CMD29: length 36.2
  TOP w0.102: 173,150.78 172.78,150.56 172.78,148.89 173.01,148.66 173.01,148.16 U13114.C44 ; v1(193.05,156.9) 193.73,156.23 198.14,156.23 198.29,156.38 198.29,156.86 U13138.H11
  TOP w0.216: v1(193.05,156.9) 193.05,157.94 191.56,159.43 v1(183.41,159.43) 182.14,159.43 178.02,155.31 178.02,154.88 177.21,154.07 176.29,154.07 173,150.78
  BOTTOM w0.216: v1(193.05,156.9) 193.34,156.61 R22016.2
FBB_CMD30: length 36.6
  TOP w0.102: U13114.C42 171.96,148.05 172.31,148.4 172.31,148.71 172.56,148.96 172.56,150.84 ; U13138.K12 199.59,158.16 199.1,158.16 198.95,158.3 198.95,159.38
  TOP w0.216: 172.56,150.84 176.22,154.5 176.78,154.5 177.43,155.15 177.43,155.68 v1(181.95,160.2) 198.38,160.2 198.95,159.63 198.95,159.38
FBB_CMD31: length 40.4
  TOP w0.102: 201,159.59 200.89,159.48 200.89,157.51 U13138.M11 ; U13114.B42 171.96,148.66 172.33,149.04 172.33,149.63 172.24,149.72
  TOP w0.216: 172.24,149.72 172.24,151.02 176.08,154.87 176.51,154.87 176.83,155.19 176.83,155.95 181.68,160.8 v1(189.76,160.8) 190.68,161.72 198.9,161.72 199.77,160.85 200.53,160.85 201.19,160.19 201.19,159.77 201,159.59
FBB_DBI0: length 25.2
  TOP w0.17: v4(164.64,148.16) 164.96,147.85 U13114.C32
  TOP w0.216: U13137.R3 v4(173.05,167.33)
  IN4 w0.081: 172.11,167.66 172.11,167.66 172.72,167.66 v4(173.05,167.33)
  IN4 w0.14: 172.11,167.66 171.97,167.66 171.91,167.72 171.31,167.72 170.68,167.1 170.68,156.38 165.53,151.22 165.53,149.04 v4(164.64,148.16)
FBB_DBI1: length 27.3
  TOP w0.216: U13114.E33 165.66,146.45 v4(165.97,146.76) ; U13137.R12 179.22,167.66 v4(178.9,167.33)
  IN4 w0.081: v4(178.9,167.33) 178.9,167.33 178.57,167.01 178.04,167.01
  IN4 w0.14: v4(165.97,146.76) 166.88,147.66 166.88,147.92 167.96,149.01 167.96,149.8 176.83,158.67 176.83,166.06 177.78,167.01 178.04,167.01
FBB_DBI2: length 39.2
  TOP w0.102: U13137.E12 178.9,174.48 v4(178.9,175.13)
  TOP w0.17: U13114.E44 173.36,146.47 v4(173.06,146.77)
  IN4 w0.081: v4(178.9,175.13) 179.22,174.81 179.22,173.67 179.38,173.51 181.22,173.51
  IN4 w0.14: v4(173.06,146.77) 173.4,147.11 173.4,149.72 185.25,161.57 185.25,170.31 182.05,173.51 181.22,173.51
FBB_DBI3: length 43.9
  TOP w0.102: 175.09,174.7 174.87,174.48 173.7,174.48 U13137.E3
  TOP w0.17: v4(176.43,174.12) 175.85,174.7 175.09,174.7
  TOP w0.216: v4(170.17,145.36) 169.86,145.05 U13114.G39
  IN4 w0.081: 181.04,172.86 181.04,172.86 177.39,172.86 177.12,173.13 177.12,173.44 v4(176.43,174.12)
  IN4 w0.14: v4(170.17,145.36) 171.47,146.66 171.47,148.71 183.72,160.96 183.72,170.79 181.66,172.86 181.04,172.86
FBB_DBI4: length 27
  TOP w0.216: U13138.E3 196.67,151.98 196.83,151.82 196.83,151.82 v4(196.99,151.66) ; v4(176.51,140.43) 176.82,140.11 U13114.P49
  IN4 w0.081: v4(196.99,151.66) 196.43,151.66 196.1,151.98 194.79,151.98
  IN4 w0.14: v4(176.51,140.43) 176.89,140.81 182.27,140.81 184.42,142.95 185.4,142.95 190.62,148.17 190.62,149.16 193.54,152.08 194.47,152.08 194.56,151.98 194.79,151.98
FBB_DBI5: length 29.4
  TOP w0.216: U13114.L48 176.19,142.21 v4(176.51,142.53) ; v4(196.34,157.51) U13138.E12
  IN4 w0.081: 196.02,156.7 196.02,156.7 196.02,157.18 v4(196.34,157.51)
  IN4 w0.14: v4(176.51,142.53) 176.51,142.5 176.88,142.13 179.47,142.13 179.72,142.38 179.72,143.45 179.98,143.7 179.98,145.63 181.72,147.37 183.58,147.37 192.55,156.35 195.79,156.35 196.02,156.57 196.02,156.7
FBB_DBI6: length 38.6
  TOP w0.216: v4(177.21,146.76) U13114.D50
  TOP w0.229: U13138.R12 203.17,157.83 v4(203.49,157.51)
  IN4 w0.081: v4(203.49,157.51) 203.49,157.62 203.17,157.95 203.17,159.15
  IN4 w0.14: 203.17,159.15 203.17,159.2 202.35,160.02 202.35,160.9 201.33,161.92 191.72,161.92 179.78,149.98 179.78,147.34 178.73,146.29 177.68,146.29 v4(177.21,146.76)
FBB_DBI7: length 32.2
  TOP w0.102: 179.6,144.97 178.72,144.97 178.41,144.66 177.91,144.66 U13114.H50
  TOP w0.216: U13138.R3 v4(202.84,152.31) ; 179.6,144.97 180.18,145.56 181.22,145.56 v4(181.68,145.1)
  IN4 w0.081: v4(202.84,152.31) 202.48,152.67 201.88,152.67 201.85,152.63 201.28,152.63 201.28,152.63
  IN4 w0.14: v4(181.68,145.1) 182.21,144.57 182.72,144.57 193.28,155.13 198,155.13 200.5,152.63 201.28,152.63
FBB_DEBUG0: length 6.7
  TOP w0.102: U13114.C35 167.06,147.99 166.71,148.34 166.71,148.64 166.34,149.01 166.34,150.89
  TOP w0.216: 166.34,150.89 166.34,151.84 165.93,152.25 v4(165.93,152.29)
  BOTTOM w0.14: v4(165.93,152.29) 166.47,152.82 R21511.1
FBB_DEBUG1: length 4.7
  TOP w0.216: v4(177.91,148.86) U13114.B50
  BOTTOM w0.14: v4(177.91,148.86) 177.45,149.32 R21513.1
FBB_EDC0: length 22.5
  TOP w0.102: v4(172.4,166.68) 173.05,166.68 U13137.T3
  TOP w0.17: U13114.B33 166.02,148.87 166.02,150.27 v4(165.91,150.38)
  IN4 w0.14: v4(165.91,150.38) 166.26,150.74 166.26,150.94 171.28,155.96 171.28,166.09 171.6,166.41 172.13,166.41 v4(172.4,166.68)
FBB_EDC1: length 26.9
  TOP w0.216: U13114.E35 167.06,146.38 v4(166.74,146.06) ; U13137.T12 179.55,166.68 v4(179.55,166.68)
  IN4 w0.14: v4(166.74,146.06) 166.77,146.06 167.55,146.84 167.55,147.58 168.57,148.61 168.57,149.39 178.2,159.01 178.2,164.14 179.55,165.49 v4(179.55,166.68)
FBB_EDC2: length 39.8
  TOP w0.102: v4(180.2,174.48) 179.55,174.48 U13137.D12
  TOP w0.17: U13114.G44 173.36,145.06 v4(173.06,145.36)
  IN4 w0.14: v4(180.2,174.48) 180.48,174.2 182.61,174.2 184.25,172.56 184.25,172.13 186.07,170.31 186.07,161.35 173.98,149.27 173.98,146.29 v4(173.06,145.36)
FBB_EDC3: length 43.6
  TOP w0.216: U13137.D3 v4(173.05,174.48) ; U13114.H38 169.16,144.28 v4(168.84,143.96)
  IN4 w0.14: v4(168.84,143.96) 169.23,144.35 169.23,148.84 181.31,160.91 181.31,170.13 180.93,170.52 176.27,170.52 174.82,171.97 174.82,172.78 174.6,172.99 174.6,173.39 174.75,173.54 174.75,173.95 174.21,174.5 173.06,174.5 v4(173.05,174.48)
FBB_EDC4: length 24.7
  TOP w0.216: v4(177.91,140.43) 177.59,140.11 U13114.P50 ; v4(195.69,151.66) U13138.D3
  IN4 w0.081: v4(195.69,151.66) 195.37,151.33 195.37,150.77
  IN4 w0.14: v4(177.91,140.43) 178.31,140.02 180.39,140.02 180.62,140.25 182.8,140.25 184.69,142.14 185.94,142.14 192.48,148.68 194.46,148.68 195.06,149.29 195.06,150.41 195.37,150.72 195.37,150.77
FBB_EDC5: length 28.3
  TOP w0.216: U13114.J48 176.12,143.61 v4(175.79,143.28) ; v4(195.69,158.16) U13138.D12
  IN4 w0.14: v4(195.69,158.16) 191.18,158.16 181.63,148.61 181.63,147.89 179.37,145.63 179.37,144.26 178.79,143.69 176.17,143.69 175.79,143.3 v4(175.79,143.28)
FBB_EDC6: length 37.2
  TOP w0.216: v4(204.14,158.16) 204.14,158.16 U13138.T12 ; v4(178.61,147.46) 178.26,147.11 U13114.D51
  IN4 w0.081: 203.82,159.09 203.82,158.48 v4(204.14,158.16)
  IN4 w0.14: v4(178.61,147.46) 179.09,147.94 179.09,150.46 191.09,162.46 201.96,162.46 203.72,160.71 203.72,159.19 203.82,159.09
FBB_EDC7: length 32.8
  TOP w0.102: U13114.F51 178.64,145.33 179.45,145.33
  TOP w0.17: U13138.T3 v4(204.14,151.66)
  TOP w0.216: 179.45,145.33 180.31,146.19 v4(181.07,146.19)
  IN4 w0.081: v4(204.14,151.66) 203.82,151.98 203.82,151.98 203.82,152.53 203.72,152.63 203.16,152.63 203.11,152.68
  IN4 w0.14: 203.11,152.68 202.36,153.43 200.51,153.43 198.26,155.69 192.85,155.69 183.89,146.73 181.66,146.73 181.12,146.19 v4(181.07,146.19)
FBB_VREFC: length 32.5
  TOP w0.254: v4(200.24,158.81) U13138.K13
  TOP w0.3: v4(180.2,171.23) U13137.K13
  BOTTOM w0.406: v4(200.24,158.81) 200.93,159.5 200.93,160.49 200.35,161.08 C95751.1 200.85,161.5 201.16,161.81 201.16,163.82 200.93,164.05 191.3,164.05 185.82,169.53 v1(185.82,169.54) R21866.2 R21864.2 C95731.1 R21867.2 182.13,170.5 181.32,170.5 181.1,170.73 180.54,170.73 180.2,171.07 v4(180.2,171.23)
FBB_VREFC_CTL: length 2.3
  BOTTOM w0.14: R21866.1 186.25,171.8 186.38,171.67 Q7877.3 v1(186.82,170.37)
FBC_CMD0: length 46.4
  TOP w0.102: 143.48,150.59 144.44,151.55 144.77,151.55 145.16,151.17 148.01,151.17 148.63,150.55 149.38,150.55 149.75,150.18 149.75,148.82 149.91,148.67 149.91,148.17 U13114.C11 ; 127.94,171.83 128.46,171.83 128.51,171.88 130.26,171.88 U13139.H4
  TOP w0.216: 143.48,150.59 142.43,150.59 140.79,152.23 v1(135.92,152.23) 135.36,152.23 130.65,156.94 130.34,156.94 125.71,161.57 125.71,168.46 126.36,169.11 126.36,170.74 127.45,171.83 127.94,171.83
FBC_CMD1: length 42.9
  TOP w0.102: 143.91,151.4 144.29,151.78 144.85,151.78 145.26,151.38 148.09,151.38 148.71,150.76 149.46,150.76 149.95,150.27 149.95,149.06 150.26,148.76 U13114.B11 ; 127.43,170.66 128.27,170.66 128.35,170.58 128.95,170.58 U13139.K2
  TOP w0.216: 143.91,151.4 143.71,151.2 142.66,151.2 141.03,152.82 v1(137.18,152.82) 135.63,152.82 130.88,157.57 130.55,157.57 126.3,161.82 126.3,168.21 126.96,168.87 126.96,170.42 v4(127.2,170.66) 127.43,170.66
  BOTTOM w0.216: v4(127.2,170.66) 127.19,170.65 R22019.1
FBC_CMD2: length 39.7
  TOP w0.102: 127.69,169.83 127.8,169.94 130.26,169.94 U13139.M4 ; U13114.A11 150.26,150.25 149.55,150.96 148.79,150.96 148.18,151.58 145.34,151.58 144.91,152.01 144.09,152.01
  TOP w0.216: 144.09,152.01 142.69,152.01 141.28,153.42 v1(138.58,153.42) 135.9,153.42 128.3,161.02 128.3,162.52 127.55,163.26 127.55,169.69 127.69,169.83
FBC_CMD3: length 40.3
  TOP w0.102: U13139.L5 131.57,169.93 131.57,168.5 131.93,168.14 131.93,164.59 131.56,164.22 130.83,164.22 ; 144.79,152.42 145.43,151.78 148.26,151.78 148.88,151.16 149.63,151.16 150.62,150.18 150.62,147.69 150.39,147.46 150.39,147.24 U13114.D11
  TOP w0.216: 130.83,164.22 130.22,164.22 129.51,163.52 129.51,160.67 136.16,154.02 v1(139.87,154.02) 141.53,154.02 143.13,152.42 144.79,152.42
FBC_CMD4: length 38.5
  TOP w0.102: U13114.A12 150.96,150.12 149.72,151.37 148.96,151.37 148.34,151.98 145.59,151.98 144.55,153.03 ; U13139.L4 130.91,170.58 131.55,170.58 131.77,170.36 131.77,168.59 132.14,168.21 132.14,164.49 131.63,163.97 131.19,163.97 131.01,163.8
  TOP w0.216: 131.01,163.8 130.7,163.8 130.14,163.24 130.14,160.9 136.43,154.61 v1(141.27,154.61) 141.78,154.61 143.36,153.03 144.55,153.03
FBC_CMD5: length 38
  TOP w0.102: 131.49,163.49 132.36,164.36 132.36,168.28 131.97,168.67 131.97,170.54 131.61,170.91 U13139.K5 ; 145.13,152.9 145.84,152.19 148.43,152.19 149.05,151.57 149.8,151.57 151.33,150.04 151.33,149.02 151.27,148.96 150.96,148.65 U13114.B12
  TOP w0.216: 131.49,163.49 131.26,163.49 130.83,163.06 130.83,161.08 v1(136.7,155.21) 142.02,155.21 143.6,153.64 144.39,153.64 145.13,152.9
FBC_CMD6: length 39.4
  TOP w0.102: U13114.C12 150.96,148.06 151.31,148.41 151.31,148.71 151.53,148.93 151.53,150.13 149.88,151.77 149.13,151.77 148.51,152.39 146.08,152.39 144.92,153.55 ; U13139.K4 130.91,171.23 131.92,171.23 132.18,170.97 132.18,168.76 132.58,168.36 132.58,163.94 132.19,163.55
  TOP w0.216: 132.19,163.55 131.44,162.81 131.44,161.33 136.96,155.81 v1(140.33,155.81) 142.27,155.81 143.83,154.25 144.23,154.25 144.92,153.55
FBC_CMD7: length 38.4
  TOP w0.102: U13139.J5 131.97,171.56 132.38,171.15 132.38,168.84 132.79,168.43 132.79,163.57 132.57,163.35 ; U13114.C14 152.04,148.13 152.04,148.63 151.76,148.91 151.76,150.21 149.99,151.98 149.22,151.98 148.6,152.59 146.33,152.59 146.02,152.9
  TOP w0.216: 146.02,152.9 142.46,156.47 v1(139.09,156.47) 137.16,156.47 132.05,161.58 132.05,162.83 132.57,163.35
FBC_CMD8: length 38.4
  TOP w0.102: U13114.B14 152.36,148.72 152.01,149.07 152.01,150.25 150.08,152.18 149.3,152.18 148.68,152.8 146.76,152.8 146.2,153.36 ; U13139.J4 130.91,171.88 132.16,171.88 132.58,171.46 132.58,168.92 132.99,168.51 132.99,163.09
  TOP w0.216: 132.99,163.09 132.66,162.75 132.66,161.82 v1(137.41,157.06) 142.7,157.06 144.74,155.03 144.74,154.82 146.2,153.36
FBC_CMD9: length 37.2
  TOP w0.102: 133.27,162.55 133.27,163.21 133.22,163.26 133.22,168.57 132.79,169.01 132.79,170.99 133.68,171.88 134.82,171.88 U13139.J11 ; 147.62,153.23 147.85,153 148.77,153 149.39,152.38 150.16,152.38 152.36,150.18 U13114.A14
  TOP w0.216: 147.62,153.23 146.96,153.23 145.33,154.86 145.33,155.28 142.91,157.7 v1(142.44,157.7) 137.66,157.7 133.27,162.09 133.27,162.55
FBC_CMD10: length 38
  TOP w0.102: 147.87,153.61 148.28,153.2 148.85,153.2 149.47,152.58 150.24,152.58 152.7,150.13 152.7,147.45 U13114.D14 ; 133.88,162.55 133.88,163.12 133.45,163.54 133.45,168.63 132.99,169.09 132.99,170.79 133.79,171.58 134.46,171.58 U13139.J10
  TOP w0.216: 133.88,162.55 133.88,162.35 137.79,158.44 v1(141.19,158.44) 143.02,158.44 145.94,155.51 145.94,154.93 147.26,153.61 147.87,153.61
FBC_CMD11: length 34.4
  TOP w0.102: U13114.A15 153.06,150.06 150.33,152.79 149.55,152.79 148.93,153.41 148.48,153.41 147.82,154.07 ; 134.49,162.93 133.68,163.74 133.68,168.69 133.19,169.18 133.19,170.08 133.34,170.23 134.45,170.23 U13139.L10
  TOP w0.216: 147.82,154.07 147.57,154.07 146.55,155.08 146.55,155.75 143.25,159.05 v1(139.95,159.05) 138.04,159.05 134.49,162.6 134.49,162.93
FBC_CMD12: length 35.3
  TOP w0.102: U13139.L11 134.81,169.93 133.56,169.93 133.4,169.77 133.4,169.26 133.91,168.75 133.91,163.99 134.88,163.02 ; U13114.B15 153.06,148.71 153.41,149.06 153.41,150 150.41,153 149.65,153 148.91,153.74
  TOP w0.216: 134.88,163.02 134.99,162.92 135.44,162.92 v1(138.45,159.91) 143.28,159.91 147.16,156.03 147.16,155.26 148.69,153.74 148.91,153.74
FBC_CMD13: length 35.4
  TOP w0.102: 134.38,163.92 134.14,164.17 134.14,169.09 134.33,169.28 134.81,169.28 U13139.M11 ; 148.89,154.14 149.83,153.2 150.52,153.2 153.71,150.01 153.71,148.96 153.41,148.66 153.41,148.16 U13114.C15
  TOP w0.216: 134.38,163.92 134.79,163.52 135.78,163.52 v1(136.19,163.11) 138.5,160.8 v1(139.72,160.8) 143.24,160.8 147.77,156.26 147.77,155.26 148.89,154.14
  BOTTOM w0.216: R22018.2 136.14,163.06 v1(136.19,163.11)
FBC_CMD14: length 33.1
  TOP w0.102: U13114.C17 154.11,148.16 154.11,149 154.11,149.92 150.62,153.41 150.11,153.41 149.75,153.76 ; U13139.K12 136.11,170.58 137.5,170.58 137.56,170.53
  TOP w0.216: 149.75,153.76 148.38,155.13 148.38,156.5 v1(141.24,163.63) 141.24,168.49 139.37,170.37 138.75,170.37 138.57,170.19 137.9,170.19 137.56,170.53
FBC_CMD15: length 34.2
  TOP w0.102: 137.56,172 137.41,172 137.31,171.9 135.44,171.9 U13139.H11 ; U13114.B17 154.81,148.86 154.81,149.55 150.72,153.64 150.39,153.64 150.13,153.89 150.13,153.94
  TOP w0.216: 150.13,153.94 148.99,155.08 148.99,156.75 142.01,163.74 v1(142.01,165.45) 142.01,168.62 138.62,172 137.56,172
FBC_CMD16: length 36.2
  TOP w0.102: 159.84,152.16 159.84,151.07 159.68,150.92 159.68,149.06 159.36,148.74 U13114.B24 ; 156.14,171.95 155.63,171.95 155.57,171.89 153.74,171.89 U13140.M4
  TOP w0.136: 160.04,153.1 160.04,152.37 159.84,152.16
  TOP w0.216: 156.14,171.95 156.26,172.08 156.94,172.08 v1(157.93,171.09) 166.49,162.53 166.49,156.6 163.91,154.02 160.55,154.02 160.04,153.51 160.04,153.1
FBC_CMD17: length 34.2
  TOP w0.102: U13140.K2 155.03,171.21 156.23,171.21 156.53,171.51
  TOP w0.17: 159.53,153.25 159.56,153.23 159.56,151.15 159.36,150.95 U13114.A24
  TOP w0.216: 159.53,153.25 159.53,153.86 160.07,154.4 163.45,154.4 165.89,156.84 165.89,161.91 v1(158.42,169.38) 158.41,169.38 156.53,171.26 v4(156.53,171.52) 156.53,171.51
  BOTTOM w0.216: v4(156.53,171.52) 156.53,171.27 156.92,170.88 R22021.1
FBC_CMD18: length 35.8
  TOP w0.102: U13140.H4 153.75,169.93 153.75,170.47 153.85,170.57 155.73,170.57 155.91,170.39 156.05,170.39
  TOP w0.17: U13114.D23 159,147.45 159,153.02 158.94,153.09
  TOP w0.216: 156.05,170.39 156.5,170.39 158.9,167.99 v1(158.9,167.61) 165.3,161.21 165.3,157.09 163.06,154.86 159.35,154.86 158.94,154.44 158.94,153.09
FBC_CMD19: length 25.3
  TOP w0.102: 153.47,164.12 153.23,164.36 152.32,164.36 152.05,164.63 152.05,168.16 152.32,168.43 152.32,170.15 152.42,170.26 U13140.J5
  TOP w0.17: U13114.A23 158.66,152.73 158.34,153.05
  TOP w0.216: 158.34,153.05 158.34,155.92 156.94,157.32 156.94,161.46 v1(155.14,163.26) 154.29,164.12 153.47,164.12
FBC_CMD20: length 26.8
  TOP w0.102: U13114.B23 158.66,148.64 158.33,148.96 158.33,149.36 158.41,149.44 158.41,152.47 157.74,153.14 157.74,153.38 ; 153.18,163.79 153.18,163.82 152.88,164.13 152.1,164.13 151.84,164.38 151.84,168.24 152.11,168.51 152.11,170.24 152.46,170.58 153.1,170.58 U13140.J4
  TOP w0.216: 157.74,153.38 157.74,155.63 156.31,157.06 156.31,159.76 v1(153.44,162.63) 153.44,163.53 153.18,163.79
FBC_CMD21: length 26.9
  TOP w0.102: 152.81,163.31 152.37,163.75 152.09,163.75 151.63,164.21 151.63,168.31 151.91,168.6 151.91,170.41 152.41,170.91 U13140.K5 ; U13114.C23 158.31,148.16 158.31,148.61 158.11,148.81 158.11,152.31 157.14,153.28
  TOP w0.216: 152.81,163.31 152.81,163.06 152.81,163.05 152.81,162.36 155.39,159.78 v1(155.39,159.78) 155.7,159.47 155.7,156.81 157.14,155.36 157.14,153.28
FBC_CMD22: length 27.9
  TOP w0.102: U13114.C21 157.26,148.03 157.61,148.38 157.61,148.67 157.84,148.91 157.84,151.9 156.55,153.19 ; U13140.K4 153.1,171.23 152.44,171.23 151.71,170.5 151.71,168.68 151.41,168.38 151.41,163.99 152.22,163.19
  TOP w0.216: 152.22,163.19 152.22,162.11 v1(153.65,160.67) 155.09,159.24 155.09,156.57 156.55,155.11 156.55,153.19
FBC_CMD23: length 26.7
  TOP w0.102: 155.95,153.28 157.58,151.65 157.58,148.99 157.26,148.67 U13114.B21 ; U13140.L5 152.48,171.56 151.68,170.76 151.51,170.58 151.51,168.77 151.2,168.46 151.2,163.65 151.61,163.24 151.61,162.93
  TOP w0.216: 155.95,153.28 155.95,154.86 154.49,156.32 154.49,158.99 v1(151.61,161.87) 151.61,162.93
FBC_CMD24: length 26.9
  TOP w0.102: 150.98,162.93 150.98,168.56 151.3,168.88 151.3,170.67 152.52,171.88 153.1,171.88 U13140.L4 ; U13114.A21 157.26,151.46 155.35,153.37
  TOP w0.216: 155.35,153.37 155.35,154.61 153.88,156.09 153.88,158.76 v1(152.24,160.39) 150.98,161.65 150.98,162.93
FBC_CMD25: length 29.8
  TOP w0.102: 154.76,153.33 156.91,151.18 156.91,147.46 U13114.D20 ; 150.39,162.96 150.76,163.33 150.76,168.68 151.1,169.02 151.1,171.12 150.34,171.88 149.2,171.88 U13140.L11
  TOP w0.216: 154.76,153.33 154.76,154.35 153.27,155.84 153.27,158.48 150.36,161.38 v1(150.36,162.35) 150.36,162.93 150.39,162.96
FBC_CMD26: length 26.7
  TOP w0.102: U13140.L10 149.55,171.58 150.22,171.58 150.9,170.91 150.9,169.1 150.53,168.74 150.53,164.48 150.31,164.25 150.31,163.59 ; 154.16,153.38 156.56,150.98 U13114.A20
  TOP w0.216: 154.16,153.38 154.16,154.07 152.65,155.59 152.65,158.23 v1(150.41,160.47) 149.75,161.13 149.75,163.03 150.31,163.59
FBC_CMD27: length 26.5
  TOP w0.102: 149.96,164.08 149.96,164.28 150.31,164.63 150.31,168.88 150.69,169.26 150.69,169.87 150.4,170.16 149.62,170.16 U13140.J10 ; 153.56,153.38 156.23,150.71 156.23,149.04 156.56,148.71 U13114.B20
  TOP w0.216: 149.96,164.08 149.07,163.19 149.07,160.95 150.87,159.15 v1(150.87,159.15) 152.04,157.98 152.04,155.24 153.56,153.72 153.56,153.38
FBC_CMD28: length 28.2
  TOP w0.102: U13140.J11 149.2,169.93 150.27,169.93 150.49,169.71 150.49,169.38 150.08,168.97 150.08,164.7 149.56,164.19 ; U13114.C20 156.21,148.16 156.21,148.71 156.01,148.91 156.01,150.43 153.06,153.38
  TOP w0.216: 149.56,164.19 149.17,163.8 148.81,163.8 148.44,163.42 148.44,160.72 v1(151.28,157.88) 151.43,157.73 151.43,155.01 153.06,153.38
FBC_CMD29: length 28.5
  TOP w0.102: U13114.C18 155.16,148.07 155.51,148.42 155.51,148.7 155.77,148.96 155.77,150.05 152.37,153.45 ; U13140.H11 149.2,169.28 149.68,169.28 149.85,169.11 149.85,164.87 149.21,164.23 v4(148.91,164.23)
  TOP w0.216: 152.37,153.45 150.82,154.99 150.82,157.47 147.72,160.57 v1(147.72,162.09) 147.72,163.57 148.38,164.23 v4(148.91,164.23)
  BOTTOM w0.216: v4(148.91,164.23) 148.91,163.8 148.94,163.77 R22020.2
FBC_CMD30: length 29.1
  TOP w0.102: 151.91,153.28 151.91,153.25 155.51,149.66 155.51,149.08 155.16,148.73 U13114.B18 ; 146.65,169.94 147.8,169.94 147.9,170.04 147.9,170.58 U13140.K12
  TOP w0.216: 146.65,169.94 146.32,169.94 146.02,169.64 146.02,166.38 145.05,165.41 v1(145.05,162.4) 150.21,157.24 150.21,154.98 151.91,153.28
FBC_CMD31: length 31.5
  TOP w0.102: 151.34,153.39 155.16,149.58 U13114.A18 ; U13140.M11 148.55,171.88 146.68,171.88 146.57,171.99
  TOP w0.216: 151.34,153.39 149.6,155.13 149.6,156.99 144.29,162.29 v1(144.29,165.37) 144.29,170.91 145.49,172.1 146.46,172.1 146.57,171.99
FBC_DBI0: length 31.6
  TOP w0.17: v4(145.71,148.89) 146.03,149.21 U13114.A5
  TOP w0.216: v4(129.61,167.33) U13139.R3
  IN4 w0.081: 128.72,167.66 129.29,167.66 v4(129.61,167.33)
  IN4 w0.14: 128.72,167.66 127.96,167.66 127.66,167.35 127.66,162.68 140.58,149.75 143.58,149.75 144.23,149.1 145.5,149.1 v4(145.71,148.89)
FBC_DBI1: length 29.8
  TOP w0.216: U13139.R12 135.78,167.66 135.46,167.34 v4(135.46,167.33) ; U13114.C8 148.16,147.85 v4(147.84,148.16)
  IN4 w0.081: 134.6,167.01 135.14,167.01 v4(135.46,167.33)
  IN4 w0.14: v4(147.84,148.16) 147.84,148.27 148.23,148.66 148.23,151.22 145.82,153.64 141.88,153.64 133.71,161.8 133.71,166.32 134.4,167.01 134.6,167.01
FBC_DBI2: length 45.5
  TOP w0.102: v4(135.46,175.13) 135.46,174.48 U13139.E12
  TOP w0.216: U13114.J18 155.16,143.58 v4(155.47,143.26)
  IN4 w0.081: 137.02,175.46 136.56,175.46 136.47,175.55 135.88,175.55 v4(135.46,175.13)
  IN4 w0.14: 137.02,175.46 137.37,175.11 138.59,175.11 141.35,172.36 141.35,162.95 144.69,159.6 147.31,159.6 155.09,151.83 155.09,143.62 155.45,143.26 v4(155.47,143.26)
FBC_DBI3: length 44.5
  TOP w0.102: v4(130.91,174.48) 130.26,174.48 U13139.E3
  TOP w0.216: U13114.F12 150.96,145.75 v4(151.32,146.11)
  IN4 w0.14: v4(151.32,146.11) 151.66,146.45 151.66,147.26 152.04,147.64 152.04,148.05 151.66,148.43 151.66,151.7 146.52,156.84 143.2,156.84 138.53,161.5 138.53,170.15 138.73,170.35 138.73,170.76 138.45,171.03 138.02,171.03 137.84,170.86 135.25,170.86 134.97,171.14 133.52,171.14 132.17,172.48 132.17,173.82 131.9,174.1 131.42,174.1 131.04,174.48 v4(130.91,174.48)
FBC_DBI4: length 38.5
  TOP w0.216: v4(154.4,167.98) U13140.E3 ; U13114.D29 162.86,147.08 v4(162.54,146.76)
  IN4 w0.081: v4(154.4,167.98) U13140.E3 154.08,165.83 154.07,165.83
  IN4 w0.14: v4(162.54,146.76) 163.14,147.36 163.14,150.11 163.62,150.59 163.62,152.75 164.46,153.59 164.89,153.59 167.43,156.13 167.43,162.88 164.56,165.75 158.06,165.75 156.23,163.92 154.67,163.92 154.02,164.58 154.02,165.65 154.07,165.7 154.07,165.83
FBC_DBI5: length 37
  TOP w0.216: U13140.E12 v4(148.55,167.33) ; v4(161.77,146.76) 161.46,146.45 U13114.E27
  IN1 w0.081: 149.45,167.01 148.88,167.01 v4(148.55,167.33)
  IN1 w0.14: 149.45,167.01 149.64,167.01 153.44,163.21 162.89,163.21 165.25,160.85 165.25,157.32 162.94,155.01 162.3,155.01 161.49,154.19 161.49,149.44 162.45,148.48 162.45,147.88 162.15,147.58 162.15,147.13 161.78,146.76 v4(161.77,146.76)
FBC_DBI6: length 40.7
  TOP w0.102: v4(147.25,174.48) 147.9,174.48 U13140.R12
  TOP w0.216: v4(156.24,146.06) 156.56,145.75 U13114.F20
  IN4 w0.14: v4(147.25,174.48) 147.25,174.48 146.98,174.75 145.22,174.75 144.42,173.95 144.42,173.51 142.46,171.55 142.46,163.41 145.49,160.39 147.44,160.39 155.97,151.87 155.97,148.53 156.61,147.89 156.61,146.4 156.27,146.06 v4(156.24,146.06)
FBC_DBI7: length 41.2
  TOP w0.216: v4(160.44,146.76) 160.76,146.45 U13114.E26 ; v4(153.75,173.83) 153.75,173.84 154.07,174.16 U13140.R3
  IN4 w0.14: v4(153.75,173.83) 153.75,173.83 152.55,172.64 152.55,172.11 150.44,169.99 149.91,169.99 149.58,169.66 146.4,169.66 146.2,169.46 146.2,163.74 146.76,163.19 149.65,163.19 160.04,152.8 160.04,148.48 160.83,147.69 160.83,147.15 v4(160.44,146.76)
FBC_DEBUG0: length 5
  TOP w0.127: U13114.A9 148.76,149.31 148.76,149.81 v4(149.15,150.2)
  BOTTOM w0.14: v1(148.64,153.03) 148.66,153 R21510.1 149.49,150.54 v4(149.15,150.2)
FBC_DEBUG1: length 13.1
  TOP w0.102: v4(160.78,153.38) 160.4,153 160.4,152.31 160.04,151.96 160.04,150.97 159.89,150.82 159.89,148.88 159.71,148.7 159.71,148.32 159.36,147.97 U13114.C24
  BOTTOM w0.14: v4(160.78,153.38) 157.37,153.38 156.99,153 v1(154.88,153) R21512.1
FBC_EDC0: length 31
  TOP w0.102: U13139.T3 129.61,166.68 v4(129.61,166.03)
  TOP w0.17: v4(145.71,147.46) U13114.D5
  IN4 w0.14: v4(145.71,147.46) 146.1,147.85 146.1,149.95 145.94,150.11 145.56,150.11 145.08,150.59 145.08,151.25 144.75,151.58 140.05,151.58 128.57,163.06 128.57,163.77 129.61,164.81 v4(129.61,166.03)
FBC_EDC1: length 28.9
  TOP w0.17: U13114.D8 148.16,147.15 v4(147.84,147.46)
  TOP w0.216: U13139.T12 136.11,166.68 v4(136.11,166.68)
  IN4 w0.14: v4(147.84,147.46) 148.15,147.46 148.79,148.1 148.79,151.68 146.17,154.3 142.36,154.3 135.28,161.38 135.28,165.32 135.88,165.93 135.88,166.46 v4(136.11,166.68)
FBC_EDC2: length 39.5
  TOP w0.102: U13139.D12 136.11,174.48 v4(136.76,174.48)
  TOP w0.216: v4(154.14,146.76) 154.46,146.45 U13114.E17
  IN4 w0.14: v4(154.14,146.76) 154.53,147.15 154.53,148.17 153.94,148.75 153.94,151.96 147.43,158.47 144.29,158.47 140.51,162.25 140.51,172.16 138.79,173.88 138.36,174.3 136.94,174.3 v4(136.76,174.48)
FBC_EDC3: length 43.4
  TOP w0.102: v4(151.27,147.46) 150.85,147.46 150.64,147.26 150.64,146.73 U13114.E12
  TOP w0.216: v4(129.61,174.48) U13139.D3
  IN4 w0.081: v4(129.61,174.48) 130.13,174.48 130.59,174.03 130.59,173.63 130.58,173.63
  IN4 w0.14: 130.58,173.63 130.58,173.6 131.34,172.85 131.34,171.93 133.25,170.01 134.88,170.01 135.17,170.3 137.68,170.3 137.82,170.17 137.82,161.13 142.79,156.15 146.2,156.15 150.77,151.58 150.77,147.97 v4(151.27,147.46)
FBC_EDC4: length 35
  TOP w0.216: v4(163.87,146.76) 163.56,146.45 U13114.E30 ; v4(154.4,166.68) U13140.D3
  IN4 w0.081: v4(154.4,166.68) 154.72,166.36 155.98,166.36
  IN4 w0.14: 155.98,166.36 165.03,166.36 168.17,163.22 168.17,156.02 165.17,153.03 164.74,153.03 164.18,152.47 164.18,150.49 163.47,149.77 163.47,147.14 163.85,146.76 v4(163.87,146.76)
FBC_EDC5: length 38.5
  TOP w0.102: v4(162.2,150.56) 162.55,150.2 162.55,148.82 U13114.B29
  TOP w0.216: v4(147.9,166.68) U13140.D12
  IN4 w0.14: v4(147.9,166.68) 147.91,166.67 147.91,164.56 148.62,163.85 150.69,163.85 152.83,161.71 157.8,161.71 159.35,163.26 162.86,163.26 165.25,160.87 165.25,157.32 162.66,154.73 161.64,154.73 161.16,154.25 161.16,150.87 161.47,150.56 v4(162.2,150.56)
FBC_EDC6: length 41.2
  TOP w0.216: U13114.G21 157.26,145.05 v4(157.57,145.36) ; v4(148.55,174.48) U13140.T12
  IN4 w0.081: 146.2,173.92 146.46,174.18 146.74,174.18 146.76,174.16 147.47,174.16 147.5,174.18 148.25,174.18 v4(148.55,174.48)
  IN4 w0.14: 146.2,173.92 145.67,173.92 143.02,171.27 143.02,163.64 145.59,161.08 147.95,161.08 157.17,151.86 157.17,145.74 157.55,145.36 v4(157.57,145.36)
FBC_EDC7: length 43.9
  TOP w0.17: v4(154.4,175.13) U13140.T3
  TOP w0.216: v4(159.67,146.76) 159.36,146.45 U13114.E24
  IN4 w0.081: v4(154.4,175.13) 154.07,174.81 153.58,174.81 153.42,174.66 153.42,174.3 153.28,174.16 152.85,174.16
  IN4 w0.14: v4(159.67,146.76) 159.28,147.16 159.28,152.77 149.42,162.63 146.45,162.63 145.1,163.98 145.1,167.9 145.66,168.46 145.66,169.96 145.92,170.22 149.35,170.22 149.96,170.83 150.36,170.83 151.46,171.93 151.46,172.79 151.89,173.21 152.21,173.21 152.7,173.7 152.7,174.01 152.85,174.16
FBC_VREFC: length 19.5
  TOP w0.254: v4(136.76,171.23) U13139.K13 ; v4(147.25,171.23) U13140.K13
  BOTTOM w0.406: v4(136.76,171.23) 136.97,171.03 C95791.1 137.55,170.62 138.09,170.07 138.55,170.07 140.36,171.87 v1(140.36,173.27) 140.36,174.59 140.98,175.22 R21872.2 R21869.2 C95771.1 R21870.2 146.69,171.8 v4(147.25,171.23)
FBC_VREFC_CTL: length 2.1
  BOTTOM w0.14: Q7878.3 R21872.1 141.96,176 v1(141.83,175.86)
FBD_CMD0: length 33.6
  TOP w0.102: U13141.H4 121.46,126.41 121.46,124.5 121.6,124.36
  TOP w0.216: U13114.AD2 143.58,132.73 139.59,132.73 138.96,132.09 138.96,131.46 138.53,131.03 138.53,128.25 136.51,126.24 ; 136.51,126.24 v1(136.51,126.23) ; 136.51,126.24 131.57,121.29 123.78,121.29 121.69,123.38 121.69,124.27 121.6,124.36
FBD_CMD1: length 30.7
  TOP w0.102: U13141.K2 122.77,125.1 122.77,124.62 122.72,124.57 122.72,123.74 v4(122.9,123.57)
  TOP w0.216: U13114.AD1 143.21,133.06 139.29,133.06 138.49,132.26 138.49,131.91 137.92,131.33 137.92,128.48 v1(135.08,125.65) 131.37,121.94 124.07,121.94 123.26,122.74 122.9,123.11 v4(122.9,123.57)
  BOTTOM w0.216: v4(122.9,123.57) 122.93,123.54 R22022.1
FBD_CMD2: length 32
  TOP w0.102: 123.51,123.91 123.51,124.29 123.44,124.36 123.44,126.42 U13141.M4 ; 139.06,133.34 142.95,133.34 143.07,133.46 145.01,133.46 U13114.AD4
  TOP w0.216: 123.51,123.91 123.51,123.38 124.25,122.65 131.24,122.65 v1(133.32,124.73) 137.31,128.72 137.31,131.59 139.06,133.34
FBD_CMD3: length 27.3
  TOP w0.102: U13141.L5 123.4,127.68 124.83,127.68 125.22,128.07 128.78,128.07 129.03,127.83 129.03,127.52 129.31,127.25 129.31,126.58
  TOP w0.216: 129.31,126.58 130.86,125.04 132.33,125.04 v1(136.42,129.12) 136.7,129.41 136.7,131.85 138.53,133.67 142.88,133.67 143.02,133.81 U13114.AC1
FBD_CMD4: length 29
  TOP w0.102: U13141.L4 122.77,127.05 122.77,127.69 122.97,127.88 124.72,127.88 125.12,128.28 129,128.28 129.81,127.46 ; U13114.AC2 143.75,133.81 143.41,134.15 142.89,134.15 142.72,133.97 138.32,133.97
  TOP w0.216: 129.81,127.46 129.81,126.94 131.11,125.65 132.05,125.65 v1(134.89,128.49) 136.09,129.69 136.09,132.08 136.87,132.86 137.21,132.86 138.32,133.97
FBD_CMD5: length 28.4
  TOP w0.102: 138.09,134.3 142.56,134.3 142.62,134.36 143.6,134.36 143.8,134.16 144.09,134.16 144.44,133.81 U13114.AC3 ; 130.67,126.95 130.3,127.32 130.3,127.5 129.32,128.48 125.01,128.48 124.64,128.11 122.81,128.11 122.45,127.74 U13141.K5
  TOP w0.216: 130.67,126.95 130.93,126.69 132.05,126.69 v1(133.5,128.13) 135.48,130.12 135.48,132.33 136.44,133.29 137.08,133.29 138.09,134.3
FBD_CMD6: length 29.2
  TOP w0.102: 130.81,127.52 129.65,128.68 124.88,128.68 124.54,128.34 122.41,128.34 122.12,128.05 122.12,127.05 U13141.K4 ; 136.2,133.84 136.2,133.84 137.14,133.84 137.89,134.58 143.53,134.58 143.81,134.86 144.31,134.86 U13114.AA3
  TOP w0.216: 136.2,133.84 136.19,133.85 136.13,133.85 134.87,132.58 134.87,130.37 132.02,127.52 v1(131.99,127.52) 130.81,127.52
FBD_CMD7: length 27.9
  TOP w0.102: 130.81,128.13 130.68,128.13 129.93,128.89 124.76,128.89 124.44,128.57 122.26,128.57 121.8,128.11 U13141.J5 ; U13114.AA2 143.78,135.21 143.46,134.89 137.58,134.89 137.04,134.34 136.2,134.34
  TOP w0.216: 136.2,134.34 135.59,134.34 134.26,133.01 134.26,130.62 v1(134.03,130.39) 131.77,128.13 130.81,128.13
FBD_CMD8: length 28
  TOP w0.102: 131.11,128.74 130.7,128.74 130.36,129.09 124.64,129.09 124.34,128.8 121.98,128.8 121.47,128.29 121.47,127.05 U13141.J4
  TOP w0.216: 131.11,128.74 131.52,128.74 v1(132.79,130.01) 133.65,130.88 133.65,133.26 135.34,134.94 136.55,134.94 136.82,135.21 U13114.AA1
FBD_CMD9: length 30.2
  TOP w0.102: 131.31,129.4 131.2,129.29 124.52,129.29 124.25,129.02 122.01,129.02 121.48,129.56 121.48,130.95 U13141.J11 ; U13114.AA4 145.02,135.55 142.95,135.55
  TOP w0.216: 142.95,135.55 135.1,135.55 133.04,133.49 133.04,131.13 v1(131.52,129.61) 131.31,129.4
FBD_CMD10: length 26.9
  TOP w0.102: U13141.J10 121.8,129.63 122.17,129.25 124.15,129.25 124.39,129.5 130.18,129.5 130.68,129.99 130.81,129.99
  TOP w0.216: 130.81,129.99 130.98,129.99 v1(132.2,131.21) 132.43,131.44 132.43,133.75 134.84,136.16 136.49,136.16 136.74,135.91 U13114.Y1
FBD_CMD11: length 26.6
  TOP w0.102: 141.88,136.23 143.38,136.23 143.7,135.91 U13114.Y2 ; 130.66,130.53 129.84,129.7 124.3,129.7 124.05,129.46 123.57,129.46 123.2,129.83 123.2,130.52 U13141.L10
  TOP w0.216: 130.66,130.53 131.82,131.68 v1(131.82,132.6) 131.82,134.1 134.49,136.77 136.39,136.77 136.93,136.23 141.88,136.23
FBD_CMD12: length 28.1
  TOP w0.102: 130.26,130.98 129.19,129.9 124.2,129.9 123.96,129.66 123.66,129.66 123.42,129.89 123.42,130.95 U13141.L11 ; 142.24,136.51 143.56,136.51 143.8,136.26 144.11,136.26 144.46,135.91 U13114.Y3
  TOP w0.216: 130.26,130.98 130.88,131.6 v1(130.88,133.54) 130.88,134.03 134.23,137.38 136.29,137.38 137.03,136.64 142.11,136.64 142.24,136.51
FBD_CMD13: length 28.1
  TOP w0.102: 129.69,130.99 128.8,130.11 124.44,130.11 124.07,130.47 124.07,130.95 U13141.M11 ; 142.62,136.77 143.61,136.77 143.82,136.97 144.32,136.97 U13114.V3
  TOP w0.216: 129.69,130.99 v1(129.69,131) 129.69,131.26 130.27,131.84 130.27,134.28 v1(131.31,135.32) 133.98,137.99 136.19,137.99 137.15,137.02 142.36,137.02 142.62,136.77
  BOTTOM w0.216: R22023.2 129.53,130.84 v1(129.69,131)
FBD_CMD14: length 26.6
  TOP w0.102: 122.77,133.48 122.77,132.25 U13141.K12 ; U13114.V2 143.74,137.31 143.42,136.99 143.11,136.99 142.46,137.63 142.26,137.63
  TOP w0.216: 122.77,133.48 123.39,134.1 123.39,135.54 v1(125.19,137.35) 129.81,137.35 131.06,138.6 136.6,138.6 137.56,137.63 142.26,137.63
FBD_CMD15: length 28
  TOP w0.102: 121.47,133.46 121.47,131.59 U13141.H11
  TOP w0.216: 121.47,133.46 121.31,133.62 121.31,134.39 125.05,138.14 v1(128.19,138.14) 129.56,138.14 130.62,139.2 136.63,139.2 137.82,138.01 142.56,138.01 U13114.V1
FBD_CMD16: length 36.2
  TOP w0.102: 121.43,153.25 121.43,152.47 121.47,152.43 121.47,150.65 U13142.M4 ; 139.59,143.45 140.48,142.56 142.65,142.56 142.82,142.74 143.58,142.74 143.78,142.54 144.09,142.54 144.41,142.21 U13114.L3
  TOP w0.216: 139.59,143.45 139.59,145.58 139.83,145.82 139.83,148.19 v1(138.91,149.11) 136.93,151.1 135.65,151.1 131.24,155.5 123.4,155.5 121.43,153.53 121.43,153.25
FBD_CMD17: length 32.7
  TOP w0.102: 122.13,153.25 122.15,153.23 122.15,152.5 122.12,152.47 122.12,151.95 U13142.K2 ; 139.24,143.42 140.33,142.33 142.83,142.33 143.01,142.52 143.42,142.52 143.72,142.21 U13114.L2
  TOP w0.216: 122.13,153.25 122.13,153.3 122.44,153.6 v4(122.73,153.6) 124.04,154.91 130.98,154.91 v1(137.51,148.38) 139.51,146.38 139.51,145.95 139.24,145.68 139.24,143.42
  BOTTOM w0.216: v4(122.73,153.6) 122.8,153.66 R22024.1
FBD_CMD18: length 30.6
  TOP w0.102: 123.25,153.21 122.81,152.76 122.81,152.62 122.79,152.6 122.79,150.73 122.88,150.64 123.43,150.64 U13142.H4 ; 138.91,143.37 140.25,142.03 142.87,142.03 143.05,142.21 U13114.L1
  TOP w0.216: 123.25,153.21 124.13,154.08 130.57,154.08 132.02,152.63 132.08,152.63 v1(136.07,148.63) 138.91,145.8 138.91,143.37
FBD_CMD19: length 28.6
  TOP w0.102: U13142.J5 123.43,149.34 124.85,149.34 125.21,148.98 128.41,148.98 129.51,150.08 ; U13114.M4 144.97,141.9 143.17,141.9 143.04,141.76 140.14,141.76 138.53,143.37
  TOP w0.216: 129.51,150.08 130.5,151.07 132.79,151.07 v1(134.79,149.07) 138.53,145.34 138.53,143.37
