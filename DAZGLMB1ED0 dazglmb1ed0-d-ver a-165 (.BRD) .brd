# Allegro board DAZGLMB1ED0 dazglmb1ed0-d-ver a-165 (.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
LPC_LAD1: length 296.1
  TOP w0.102: v2(309.52,63.47) 309.92,63.06 U13113.AV22
  TOP w0.14: U49.9 179.14,62.4 179.2,62.34 179.65,62.34 180.18,61.81 v1(180.18,61.81)
  IN2 w0.089: v2(309.52,63.47) 309.39,63.34 309.39,62.07 308.99,61.67 307.6,61.67 306.73,60.8 306.27,60.8 305.65,60.18 305.65,56.6 305.37,56.32 305.37,54.11 305.14,53.88 304.16,53.88 303.93,53.64 298.49,53.64 296.85,52 293.74,52 293.39,51.65 291.55,51.65 290.52,52.68 290.52,52.8 289.48,53.84 289.48,54.73 287.76,56.44 286.48,56.44 286.17,56.75 282.58,56.75 278.83,53 264.43,53 264.1,52.67 249.9,52.67 247.64,50.42 241.63,50.42 240.93,51.12 234.25,51.12 233.78,50.65 230.02,50.65 229.55,51.12 202.76,51.12 201.44,52.44 196.94,52.44 194.24,55.14 194.24,60.34 193.9,60.67 186.92,60.67 184.96,62.63 183.39,62.63 181,62.63 v1(180.18,61.81) 179.7,61.33 179.18,61.33 178.39,60.54 175.49,60.54 175.3,60.35 174.44,60.35 174.44,60.34 172.87,58.77 171.35,58.77 166.94,54.36 158.02,54.36 156.6,55.79 148.3,55.79 147.36,56.73 146.23,56.73 145.88,57.08 133.57,57.08 130.1,53.61 128.1,53.61 127.06,52.57 108.45,52.57 107.63,53.39 101.41,53.39 100.59,52.57 96.54,52.57 93.88,49.91 84.19,49.91 83.19,48.91 78.41,48.91 78.02,48.52 73.39,48.52 72.79,47.91 69.09,47.91 67.96,49.04 66.92,49.04 65.42,50.54 65.42,50.89 65.17,51.15 65.17,51.83 61.87,55.12 58.17,55.12 55.42,57.88 v1(55.09,57.88)
  BOTTOM w0.14: v1(55.09,57.88) 54.1,56.89 R21715.1
LPC_LAD1_C: length 4.9
  TOP w0.14: v1(54.1,57.88) 53.97,58 CN2068.66
  BOTTOM w0.14: v1(54.1,57.88) 53.98,58 R21997.1 52.46,57.61 R21715.2 52.46,55.87 R21996.1
LPC_LAD2: length 304.3
  TOP w0.14: v1(180.84,61.81) 180.84,61.81 180.37,62.28 180.2,62.28 179.79,62.69 179.33,62.69 179.22,62.8 U49.8 ; v1(46.76,53.81) 46.38,53.81 45.92,53.36 R21716.1 ; v2(308.63,61.31) 308.73,61.31 309.16,61.74 U13113.AT19
  IN2 w0.089: v2(308.63,61.31) 308.12,60.8 307.14,60.8 306.85,60.51 306.43,60.51 306.24,60.31 306.24,59.12 306.69,58.66 306.69,56.73 306.33,56.38 305.86,56.38 305.67,56.18 305.67,53.99 305.26,53.58 304.28,53.58 304.05,53.35 298.61,53.35 296.15,50.89 291.76,50.89 291.26,51.39 290.03,51.39 288.31,53.12 288.31,54.96 287.38,55.89 282.13,55.89 278.95,52.71 264.8,52.71 264.47,52.38 250.02,52.38 247.76,50.12 241.51,50.12 240.81,50.83 234.44,50.83 233.97,50.35 229.9,50.35 229.42,50.83 202.51,50.83 201.27,52.07 196.9,52.07 193.95,55.02 193.95,59.91 193.49,60.37 185.81,60.37 183.85,62.34 181.37,62.34 v1(180.84,61.81) 180.07,61.04 179.3,61.04 178.51,60.25 175.73,60.25 173.96,58.47 171.47,58.47 167.06,54.07 157.9,54.07 156.47,55.5 147.92,55.5 147.31,56.1 146.39,56.1 145.71,56.79 133.69,56.79 130.16,53.26 128.16,53.26 127.18,52.28 96.66,52.28 94,49.62 84.31,49.62 83.31,48.61 78.53,48.61 78.14,48.23 73.52,48.23 72.91,47.62 68.97,47.62 67.84,48.75 66.8,48.75 66.73,48.82 66.5,48.82 65.13,50.19 65.13,50.77 64.7,51.2 64.28,51.2 62.14,53.34 62.14,54.02 61.33,54.83 58.05,54.83 56.61,56.27 47.76,56.27 46.83,55.33 46.83,53.88 v1(46.76,53.81)
LPC_LAD2_C: length 13.5
  TOP w0.14: v1(46.71,53.1) 46.71,52.84 R22003.1 47.13,51.33 Q7890.1 46.15,51.31 R21716.2 45.57,51.54 v1(45.11,52.01) ; CN2068.68 51.81,57.5 v1(51.71,57.6)
  IN1 w0.089: v1(46.71,53.1) 46.71,52.98 46.98,52.7 47.95,52.7 50.07,54.82 50.07,55.96 v1(51.71,57.6)
LPC_LAD3: length 301.8
  TOP w0.102: U13113.BD16 312.87,60.07 313.32,60.39 314.93,60.39 v1(315.11,60.56)
  TOP w0.14: v1(181.66,61.31) 181.38,61.59 181.38,61.94 180.69,62.62 180.34,62.62 179.93,63.03 179.47,63.03 179.3,63.2 U49.7 ; v1(51.99,51.93) 51.99,51.83 51.62,51.47 R21717.1
  IN2 w0.089: v1(51.99,51.93) 51.99,52.14 53.54,53.69 58.46,53.69 58.84,54.07 61.38,54.07 61.85,53.59 61.85,52.77 66.1,48.53 66.61,48.53 66.68,48.45 67.72,48.45 68.85,47.32 73.03,47.32 73.47,47.77 75.25,47.77 75.81,47.21 78.4,47.21 79.52,48.32 83.43,48.32 84.43,49.32 94.12,49.32 96.78,51.99 127.31,51.99 128.28,52.96 130.28,52.96 133.81,56.49 145.57,56.49 146.19,55.88 146.19,55.31 146.91,54.59 156.97,54.59 157.78,53.78 167.19,53.78 171.59,58.18 174.08,58.18 175.85,59.95 178.63,59.95 179.42,60.75 180.82,60.75 181.38,61.31 v1(181.66,61.31) 181.66,61.59 182.12,62.05 183.73,62.05 185.69,60.08 193.36,60.08 193.66,59.79 193.66,54.9 196.81,51.75 201.07,51.75 202.28,50.53 229.3,50.53 229.78,50.06 234.09,50.06 234.56,50.53 240.56,50.53 241.26,49.83 247.88,49.83 249.16,51.12 258.31,51.12 258.45,51.26 260.43,51.26 260.59,51.42 264.28,51.42 265.28,52.42 270,52.42 270.55,51.86 289.15,51.86 289.91,51.1 291.14,51.1 291.64,50.6 296.28,50.6 298.73,53.06 304.17,53.06 304.4,53.29 305.54,53.29 306.6,54.35 306.6,55.97 306.98,56.35 306.98,58.64 307.66,59.33 307.66,60.2 307.87,60.4 308.45,60.4 308.82,60.77 311.6,60.77 311.81,60.98 314.7,60.98 v1(315.11,60.56)
LPC_LAD3_C: length 11.9
  TOP w0.14: Q7891.1 50.68,49.99 v1(51.02,50.33) 51.02,50.87 50.12,51.77 R22005.1 51.29,52.26 R21717.2 51.59,52.25 51.76,52.42 52.04,52.42 53.82,54.19 53.82,55.52 54.2,55.9 54.2,56.68 53.88,57 CN2068.70
LPC_LFRAME#: length 303
  TOP w0.102: v1(315.76,60.56) 315.76,60.46 315.28,59.98 314.79,59.98 314.61,60.16 313.41,60.16 U13113.BE16
  TOP w0.14: v1(182.29,61.51) 182.01,61.79 182.01,61.81 180.86,62.96 180.48,62.96 180.07,63.37 179.62,63.37 179.39,63.6 U49.6 177.1,63.6 v1(176.96,63.75)
  IN2 w0.089: v1(315.76,60.56) 315.37,60.18 314.19,60.18 313.72,60.65 311.93,60.65 311.77,60.48 308.94,60.48 308.5,60.04 308.5,58.49 307.61,57.6 307.61,54.45 306.85,53.69 306.35,53.69 305.66,53 304.52,53 304.21,52.69 301.46,52.69 300.24,51.46 299.55,51.46 298.85,50.77 297.62,50.77 297.16,50.31 291.52,50.31 291.02,50.81 289.79,50.81 289.03,51.57 269.62,51.57 269.25,51.2 264.82,51.2 264.74,51.13 260.71,51.13 260.55,50.97 258.74,50.97 258.16,50.38 248.85,50.38 248,49.54 241.14,49.54 240.44,50.24 234.71,50.24 234.24,49.77 232.84,49.77 232.25,49.18 230.25,49.18 229.18,50.24 201.92,50.24 200.85,51.31 196.83,51.31 193.36,54.78 193.36,58.89 193.24,59.02 192.43,59.02 191.66,59.79 185.57,59.79 183.6,61.76 182.54,61.76 v1(182.29,61.51) 182.14,61.36 182.14,61.05 181.54,60.46 179.55,60.46 178.75,59.66 175.97,59.66 174.2,57.89 171.71,57.89 167.31,53.48 157.66,53.48 156.85,54.3 146.79,54.3 145.89,55.2 145.89,55.72 145.41,56.2 133.95,56.2 130.42,52.67 128.4,52.67 127.43,51.69 96.9,51.69 94.24,49.03 84.55,49.03 83.55,48.03 79.71,48.03 78.59,46.92 75.69,46.92 75.13,47.48 73.59,47.48 73.15,47.03 73.15,47.03 72.41,46.3 69.46,46.3 67.59,48.16 66.56,48.16 66.49,48.23 65.98,48.23 v1(60.8,53.41)
  BOTTOM w0.14: v1(60.8,53.41) 60.32,52.92 59.33,52.92 58.94,53.32 58.94,54.08 57.3,55.72 57.3,56.35 57.73,56.79 59.38,56.79 59.59,57 R21719.2
LVN: length 81.7
  TOP w0.203: U13157.23 30.88,38.98 30.65,38.75 v1(30.65,38.07)
  TOP w0.508: v1(83.26,42.79) 84.91,42.79 87.42,45.3 87.42,48.71 86.43,49.7 CN2039.3 ; L4236.2 29.48,37.48 30.02,38.02 v1(30.02,38.04) 30.63,38.04 v1(30.65,38.07)
  IN1 w0.508: v1(30.65,38.07) 30.65,37.66 31.43,36.88 31.43,36.61 32.06,35.98 34.16,35.98 38.09,32.05 38.09,31.56 38.84,30.81 40.19,30.81 40.46,31.08 42.18,31.08 42.77,31.67 45.41,31.67 46.35,32.6 46.35,33.37 46.68,33.7 47.7,33.7 48.51,32.88 50.28,32.88 51.44,34.05 55.47,34.05 56.43,33.09 57.91,33.09 58.57,32.43 63.29,32.43 64.35,31.37 64.83,31.37 65.12,31.67 69.9,31.67 70.64,32.41 71.69,32.41 73.78,34.51 74.02,34.51 74.29,34.78 74.3,34.78 75.53,36.01 75.53,36.8 76.35,37.61 76.35,37.64 77.46,38.75 77.78,38.75 77.96,38.57 78.13,38.57 80.28,40.73 82.14,40.73 83.26,41.85 v1(83.26,42.79)
  BOTTOM w0.508: C94631.2 30.36,37.78 v1(30.65,38.07)
LX:
  vias: v1(347.11,68.75)
M_A_A0: length 57.8
  TOP w0.216: v1(242.34,54.89) 242.44,54.79 CN2063.144 ; v1(245.52,105.36) 245.18,105.7 U41.AH3
  IN1 w0.14: v1(242.34,54.89) 242.01,55.21 241.34,55.21 238.95,57.61 238.95,57.96 238.56,58.35 238.56,69.72 239.19,70.36 239.19,73.63 238.56,74.26 238.56,79.69 242.65,83.79 242.65,99.94 244.45,101.73 244.45,104.29 v1(245.52,105.36)
M_A_A1: length 53.3
  TOP w0.079: 249.78,103.9 249.78,106.07 U41.AP4
  TOP w0.216: CN2063.133 245.18,60.6 244.89,60.3 244.89,59.84 244.3,59.25 v1(243.94,59.25) ; v1(247.67,102.07) 248.41,102.07 249.78,103.45 249.78,103.9
  IN1 w0.14: v1(243.94,59.25) 243.94,63.22 244.22,63.5 244.22,72.48 244.35,72.61 244.35,79.63 247.16,82.45 247.16,100.48 247.67,100.98 v1(247.67,102.07)
M_A_A2: length 57.1
  TOP w0.216: CN2063.132 245.44,55.71 244.47,56.68 v1(243.96,56.68) ; U41.AN4 249.33,106.34 249.04,106.05 v1(248.89,106.05)
  IN1 w0.079: 248.46,102.84 248.46,105.62 v1(248.89,106.05)
  IN1 w0.14: 248.46,102.84 248.61,102.68 248.61,100.66 248.05,100.11 248.05,82.08 245.24,79.27 245.24,72.61 245.57,72.28 245.57,68.7 245.11,68.25 245.11,64.58 245.57,64.12 245.57,63.78 245.11,63.32 245.11,62.25 244.9,62.04 244.9,58.08 244.77,57.95 244.77,56.86 244.59,56.68 v1(243.96,56.68)
M_A_A3: length 56.9
  TOP w0.079: 249.45,103.85 249.45,103.98 249.63,104.16 249.63,106.19 249.7,106.26 249.7,106.65 250.06,107.01 U41.AP5
  TOP w0.216: v1(247.67,102.84) 248.43,102.84 249.45,103.85 ; v1(244.06,57.96) 244.57,58.47 244.57,58.74 245.41,59.58 245.41,60.09 245.69,60.36 CN2063.131
  IN1 w0.14: v1(247.67,102.84) 248.15,102.35 248.15,100.84 247.61,100.29 247.61,82.27 244.79,79.45 244.79,72.42 244.67,72.3 244.67,62.44 244.4,62.17 244.4,58.3 v1(244.06,57.96)
M_A_A4: length 55.8
  TOP w0.216: U41.AP2 250.45,104.68 v1(250.53,104.68) ; CN2063.128 246.44,54.59 246.32,54.7 246.32,55.8 v1(246.91,56.38)
  IN1 w0.14: v1(246.91,56.38) 247.12,56.17 247.47,56.17 247.72,56.42 247.72,61.72 248,62 248,63.82 248.38,64.2 248.38,65.71 248.76,66.08 248.76,68.82 249.26,69.32 249.26,70.51 248.76,71.01 248.76,72.01 249.26,72.5 249.26,75.29 248.53,76.02 248.53,77.81 249.26,78.54 249.26,80.14 250.28,81.16 250.28,99.19 250.88,99.79 250.88,101.6 250.68,101.81 250.68,103 250.08,103.6 250.08,104.23 v1(250.53,104.68)
M_A_A5: length 53.2
  TOP w0.216: U41.AP1 v1(250.52,103.96) ; v1(246.93,55.01) CN2063.126
  IN1 w0.14: v1(250.52,103.96) 250.96,103.51 250.96,101.85 251.34,101.47 251.34,99.62 250.72,99 250.72,80.98 249.7,79.96 249.7,67.1 249.25,66.65 249.25,64.08 248.48,63.31 248.48,61.85 248.17,61.54 248.17,56.24 v1(246.93,55.01)
M_A_A6: length 57.3
  TOP w0.216: U41.AP3 250.45,105.32 v1(250.52,105.32) ; CN2063.127 246.69,60.36 v1(246.81,60.24)
  IN1 w0.14: v1(246.81,60.24) 246.84,60.28 246.84,61.47 247.42,62.05 247.42,63.98 247.94,64.49 247.94,66.63 248.08,66.77 248.17,66.77 248.31,66.91 248.31,67.19 248.17,67.33 247.82,67.33 247.68,67.47 247.68,67.75 247.82,67.89 248.17,67.89 248.31,68.03 248.31,68.31 248.17,68.45 248.08,68.45 247.94,68.59 247.94,68.87 248.08,69.01 248.31,69.01 248.45,69.15 248.45,69.42 248.31,69.56 248.08,69.56 247.94,69.7 247.94,69.98 248.08,70.12 248.46,70.12 248.6,70.26 248.6,70.54 248.46,70.68 247.82,70.68 247.68,70.82 247.68,71.1 247.82,71.24 248.18,71.24 248.32,71.38 248.32,71.66 248.18,71.8 248.08,71.8 247.94,71.94 247.94,72.38 248.08,72.52 248.6,72.52 248.74,72.66 248.74,72.94 248.6,73.08 248.08,73.08 247.94,73.22 247.94,73.5 248.08,73.64 248.67,73.64 248.81,73.78 248.81,74.06 248.67,74.2 248.08,74.2 247.94,74.34 247.94,74.62 248.08,74.76 248.6,74.76 248.74,74.9 248.74,75.18 248.6,75.32 248.08,75.32 247.94,75.46 247.94,79.45 249.83,81.34 249.83,99.37 250.43,99.97 250.43,101.67 250.08,102.02 250.08,103.17 249.86,103.39 249.86,104.67 v1(250.52,105.32)
M_A_A7: length 58.3
  TOP w0.216: v1(245.41,57.66) 245.57,57.5 247.18,57.5 247.4,57.29 247.4,56.1 247.93,55.57 CN2063.122 ; v1(248.89,103.96) U41.AN1
  IN1 w0.14: v1(245.41,57.66) 245.35,57.73 245.35,61.86 245.56,62.07 245.56,63.14 246.01,63.59 246.01,64.3 245.56,64.76 245.56,65.21 245.7,65.35 245.9,65.35 246.04,65.49 246.04,65.76 245.9,65.9 245.7,65.9 245.56,66.04 245.56,66.32 245.7,66.46 245.9,66.46 246.04,66.6 246.04,66.88 245.9,67.02 245.7,67.02 245.56,67.16 245.56,68.06 246.01,68.52 246.01,72.46 245.68,72.79 245.68,73.24 245.82,73.38 245.9,73.38 246.04,73.52 246.04,73.8 245.9,73.94 245.82,73.94 245.68,74.08 245.68,74.36 245.82,74.5 246.37,74.5 246.51,74.64 246.51,74.92 246.37,75.05 245.82,75.05 245.68,75.19 245.68,79.08 248.5,81.9 248.5,99.92 249.07,100.49 249.07,102.58 248.89,102.76 v1(248.89,103.96)
M_A_A8: length 57.5
  TOP w0.216: v1(248.92,105.4) 249.03,105.4 U41.AN3 ; CN2063.125 247.18,60.57 247.33,60.42 247.33,59.39 v1(246.79,58.85)
  IN1 w0.14: v1(248.92,105.4) 249.65,104.67 249.65,103.29 249.86,103.08 249.86,101.75 249.97,101.64 249.97,100.14 249.39,99.56 249.39,81.53 247.4,79.54 247.4,78.85 247.26,78.71 246.71,78.71 246.57,78.57 246.57,78.29 246.71,78.15 247.26,78.15 247.4,78.01 247.4,77.73 247.26,77.59 246.71,77.59 246.57,77.45 246.57,77.17 246.71,77.03 247.26,77.03 247.4,76.89 247.4,76.61 247.26,76.47 246.71,76.47 246.57,76.33 246.57,76.05 246.71,75.92 247.26,75.92 247.4,75.78 247.4,74.12 246.93,73.65 246.93,71.89 247.29,71.53 247.29,71.31 246.93,70.96 246.93,70.62 247.07,70.48 247.35,70.48 247.49,70.34 247.49,70.06 247.35,69.92 247.07,69.92 246.93,69.78 246.93,62.19 246.39,61.65 246.39,59.25 v1(246.79,58.85)
M_A_A9: length 58.1
  TOP w0.216: v1(251.4,106) 251.49,106 U41.AT4 ; v1(249.16,56.4) 249.16,56.4 248.68,56.88 248.68,58.11 248.18,58.61 CN2063.121
  IN1 w0.14: v1(251.4,106) 251.89,105.51 251.89,103.78 251.33,103.22 251.33,101.92 251.8,101.45 251.8,99.45 251.17,98.82 251.17,80.79 250.18,79.81 250.18,66.95 249.7,66.46 249.7,63.21 249.09,62.6 249.09,61.61 248.66,61.18 248.66,56.9 v1(249.16,56.4)
M_A_A10: length 55.5
  TOP w0.216: U41.AH2 245.38,104.72 v1(245.52,104.72) ; v1(239.69,57.6) 239.69,56.15 240.16,55.69 240.16,54.73 239.94,54.51 CN2063.146
  IN1 w0.14: v1(239.69,57.6) 239.39,57.9 239.39,58.2 239.01,58.58 239.01,69.55 239.64,70.17 239.64,73.88 239,74.52 239,79.51 243.1,83.6 243.1,100.08 244.67,101.64 244.67,103.86 v1(245.52,104.72)
M_A_A11: length 57.7
  TOP w0.216: U41.AN2 249.29,105.05 v1(248.89,104.65) ; v1(246.79,58.15) 247.27,58.15 247.92,57.5 247.92,56.26 248.44,55.74 CN2063.120
  IN1 w0.14: v1(246.79,58.15) 246.79,57.49 246.51,57.21 246.05,57.21 245.95,57.31 245.95,61.83 246.48,62.37 246.48,73.83 246.96,74.3 246.96,75.1 246.56,75.5 246.3,75.5 246.13,75.68 246.13,78.9 248.94,81.71 248.94,99.74 249.51,100.31 249.51,102.73 249.43,102.82 249.43,104.11 v1(248.89,104.65)
M_A_A12: length 56.9
  TOP w0.216: v1(253.01,106.07) 252.72,106.35 U41.AU4 ; CN2063.119 248.69,60.72 248.97,60.44 248.97,58.82 249.2,58.58 249.2,57.74 v1(249.19,57.73)
  IN1 w0.14: v1(253.01,106.07) 252.17,105.22 252.17,103.5 251.65,102.98 251.65,102.01 252.27,101.39 252.27,99.29 251.61,98.63 251.61,80.61 250.63,79.63 250.63,74.04 251.18,73.49 251.18,67.32 250.14,66.28 250.14,63.02 249.54,62.42 249.54,61.43 249.11,61 249.11,60.55 249.24,60.41 249.42,60.41 249.56,60.27 249.56,59.99 249.42,59.85 249.24,59.85 249.11,59.71 249.11,59.43 249.24,59.29 249.42,59.29 249.56,59.15 249.56,58.87 249.42,58.74 249.24,58.74 249.11,58.6 249.11,57.81 v1(249.19,57.73)
M_A_A13: length 60.1
  TOP w0.216: v1(242.99,105.38) 242.85,105.38 U41.AE3 ; CN2063.158 236.94,55.25 236.62,55.57 236.62,56.23 v1(237.05,56.66)
  IN1 w0.14: v1(237.05,56.66) 236.89,56.66 236.37,57.19 236.37,59.54 236.51,59.68 236.61,59.68 236.75,59.82 236.75,60.1 236.61,60.24 236.51,60.24 236.37,60.38 236.37,60.66 236.51,60.8 236.61,60.8 236.75,60.94 236.75,61.22 236.61,61.36 236.22,61.36 236.08,61.5 236.08,61.78 236.22,61.92 236.61,61.92 236.75,62.06 236.75,62.34 236.61,62.48 236.24,62.48 236.08,62.63 236.08,64.47 236.75,65.14 236.75,67.91 236.08,68.58 236.08,71.09 236.22,71.23 236.61,71.23 236.75,71.37 236.75,71.65 236.61,71.78 236.22,71.78 236.08,71.92 236.08,79.77 240.86,84.55 240.86,100.21 243.43,102.77 243.43,104.89 242.99,105.33 v1(242.99,105.38)
M_A_ACT#: length 54.3
  TOP w0.216: U41.AU3 252.72,105.7 v1(253.03,105.4) ; CN2063.114 249.93,55.06 250.34,55.46 250.34,55.64 250.67,55.97 250.67,58.16 v1(250.95,58.44)
  IN1 w0.14: v1(250.95,58.44) 250.95,58.53 251.34,58.93 251.34,61.42 252.53,62.61 252.53,66.31 253.75,67.53 253.75,101.64 253.46,101.92 253.46,104.97 v1(253.03,105.4)
M_A_ALERT#: length 57.1
  TOP w0.216: v1(250.13,56.08) 249.85,55.81 249.85,55.5 249.44,55.08 CN2063.116 ; U41.AU5 252.73,107.01 v1(253.02,106.72)
  IN1 w0.14: v1(250.13,56.08) 250.21,56.08 252.72,58.6 252.72,60.92 255.09,63.29 255.09,99.28 254.78,99.59 254.78,105.2 254.02,105.96 253.77,105.96 v1(253.02,106.72)
M_A_BA#0: length 59.5
  TOP w0.216: v1(245.53,106.68) 245.42,106.8 245.25,106.8 U41.AH5 ; v1(238.04,57.61) 239.03,56.62 239.03,55.23 238.94,55.13 CN2063.150
  IN1 w0.14: v1(238.04,57.61) 238.04,57.5 237.56,57.01 237.34,57.01 237,57.35 237,57.62 237.64,58.27 237.64,80.07 241.75,84.18 241.75,100.21 244.01,102.47 244.01,104.47 244.66,105.12 244.66,105.81 v1(245.53,106.68)
M_A_BA#1: length 57
  TOP w0.216: U41.AH1 245.04,104.39 245.39,104.04 v1(245.49,104.04) ; CN2063.145 240.18,60.55 v1(239.69,60.06)
  IN1 w0.14: v1(245.49,104.04) 244.88,103.43 244.88,101.55 243.54,100.21 243.54,92.53 243.68,92.39 243.81,92.39 243.95,92.25 243.95,91.97 243.81,91.83 243.68,91.83 243.54,91.69 243.54,91.41 243.68,91.27 243.81,91.27 243.95,91.13 243.95,90.85 243.81,90.71 243.68,90.71 243.54,90.57 243.54,90.3 243.68,90.16 243.81,90.16 243.95,90.02 243.95,89.74 243.81,89.6 243.68,89.6 243.54,89.46 243.54,89.18 243.68,89.04 243.81,89.04 243.95,88.9 243.95,88.62 243.81,88.48 243.68,88.48 243.54,88.34 243.54,88.06 243.68,87.92 243.81,87.92 243.95,87.78 243.95,87.5 243.81,87.36 243.68,87.36 243.54,87.22 243.54,86.94 243.68,86.8 243.81,86.8 243.95,86.66 243.95,86.38 243.81,86.24 243.68,86.24 243.54,86.1 243.54,85.82 243.68,85.69 243.81,85.69 243.95,85.55 243.95,85.27 243.81,85.13 243.68,85.13 243.54,84.99 243.54,84.71 243.68,84.57 243.81,84.57 243.95,84.43 243.95,84.15 243.81,84.01 243.68,84.01 243.54,83.87 243.54,83.42 240.08,79.96 240.08,79.32 239.94,79.18 239.59,79.18 239.45,79.04 239.45,78.76 239.59,78.63 239.94,78.63 240.08,78.49 240.08,78.21 239.94,78.07 239.59,78.07 239.45,77.93 239.45,77.65 239.59,77.51 239.94,77.51 240.08,77.37 240.08,76.21 239.94,76.07 239.59,76.07 239.45,75.93 239.45,75.65 239.59,75.51 239.94,75.51 240.08,75.37 240.08,69.99 239.85,69.76 239.85,69.31 239.71,69.17 239.6,69.17 239.46,69.04 239.46,68.76 239.6,68.62 239.71,68.62 239.85,68.48 239.85,68.2 239.71,68.06 239.6,68.06 239.46,67.92 239.46,67.64 239.6,67.5 239.71,67.5 239.85,67.36 239.85,67.08 239.71,66.94 239.6,66.94 239.46,66.8 239.46,66.52 239.6,66.38 239.71,66.38 239.85,66.24 239.85,60.22 v1(239.69,60.06)
M_A_BG#0: length 55.9
  TOP w0.216: v1(253.02,104.09) 252.9,104.09 U41.AU1 ; CN2063.115 249.69,60.82 249.49,60.62 249.49,59.21 249.96,58.74 v1(250.01,58.74)
  IN1 w0.14: v1(250.01,58.74) 250.57,59.3 250.57,61.75 251.54,62.72 251.54,66.42 252.82,67.7 252.82,73.43 252.68,73.57 252.38,73.57 252.24,73.71 252.24,73.99 252.38,74.13 252.68,74.13 252.82,74.27 252.82,74.55 252.68,74.69 252.38,74.69 252.24,74.83 252.24,75.11 252.38,75.25 252.68,75.25 252.82,75.38 252.82,75.66 252.68,75.8 252.38,75.8 252.24,75.94 252.24,76.22 252.38,76.36 252.68,76.36 252.82,76.5 252.82,76.78 252.68,76.92 252.38,76.92 252.24,77.06 252.24,77.34 252.38,77.48 252.68,77.48 252.82,77.62 252.82,77.9 252.68,78.04 252.38,78.04 252.24,78.18 252.24,78.46 252.38,78.6 252.68,78.6 252.82,78.74 252.82,79.02 252.68,79.16 252.38,79.16 252.24,79.3 252.24,79.58 252.38,79.72 252.68,79.72 252.82,79.86 252.82,98.49 253.16,98.83 253.16,101.54 252.72,101.97 252.72,103.79 v1(253.02,104.09)
M_A_BG#1: length 53.8
  TOP w0.216: U41.AU2 252.6,105.05 252.91,104.75 v1(253.01,104.75) ; CN2063.113 250.18,60.27 v1(250,60.09)
  IN1 w0.14: v1(253.01,104.75) 252.45,104.19 252.45,103.12 252.25,102.92 252.25,101.86 252.71,101.4 252.71,99.11 252.05,98.45 252.05,80.42 251.8,80.17 251.8,75.07 251.66,74.93 251.21,74.93 251.07,74.79 251.07,74.51 251.21,74.37 251.49,74.37 251.63,74.23 251.63,73.12 251.77,72.98 252.24,72.98 252.38,72.84 252.38,72.57 252.24,72.43 251.77,72.43 251.63,72.29 251.63,72.01 251.77,71.87 252.24,71.87 252.38,71.73 252.38,71.45 252.24,71.31 251.77,71.31 251.63,71.17 251.63,70.89 251.77,70.75 252.24,70.75 252.38,70.61 252.38,70.33 252.24,70.19 251.77,70.19 251.63,70.05 251.63,69.77 251.77,69.63 252.08,69.63 252.38,69.34 252.38,67.89 251.1,66.61 251.1,62.91 250,61.81 v1(250,60.09)
M_A_CAS#: length 58.9
  TOP w0.216: v1(243,103.4) 242.8,103.4 U41.AD1 ; CN2063.156 237.44,55.72 237.43,55.72 v1(237.43,55.9)
  IN1 w0.14: v1(243,103.4) 243,102.89 240.41,100.3 240.41,84.74 235.64,79.96 235.64,68.01 235.78,67.87 236.17,67.87 236.31,67.73 236.31,67.45 236.17,67.31 235.78,67.31 235.64,67.17 235.64,66.89 235.78,66.75 236.17,66.75 236.31,66.61 236.31,66.33 236.17,66.19 235.78,66.19 235.64,66.05 235.64,61.25 235.92,60.97 235.92,57 236.47,56.46 236.47,55.49 236.75,55.21 237.26,55.21 237.43,55.39 v1(237.43,55.9)
M_A_CB0: length 2.2
  TOP w0.14: CN2063.92 255.44,54.9 v1(255.49,54.95)
  BOTTOM w0.14: v1(255.49,54.95) 255.21,54.68 R21396.2
M_A_CB1: length 2.5
  TOP w0.14: CN2063.91 255.69,60.44 v1(255.75,60.37)
  BOTTOM w0.14: v1(255.75,60.37) 255.54,60.58 R21397.2
M_A_CB2: length 3.4
  TOP w0.14: CN2063.101 253.18,60.08 v1(253.23,60.04)
  BOTTOM w0.14: v1(253.23,60.04) 252.37,60.9 R21398.2
M_A_CB3: length 8.2
  TOP w0.14: CN2063.105 252.18,60.89 252.75,60.33 252.75,58.41 v1(253.23,57.93)
  BOTTOM w0.14: v1(253.23,57.93) 253.99,58.69 253.99,60.42 254.48,60.9 R21399.2
M_A_CB4: length 5.6
  TOP w0.14: v1(255.43,56.4) 256.44,55.39 CN2063.88
  BOTTOM w0.14: v1(255.43,56.4) 256.18,55.65 R21401.2
M_A_CB5: length 6
  TOP w0.14: v1(255.77,58.92) 256.69,59.84 CN2063.87
  BOTTOM w0.14: v1(255.77,58.92) 256.64,59.79 R21402.2
M_A_CB6: length 2.4
  TOP w0.14: CN2063.100 253.44,54.96 v1(253.33,55.06)
  BOTTOM w0.14: R21403.2 253.64,54.76 v1(253.33,55.06)
M_A_CB7: length 5.5
  TOP w0.14: v1(253.33,56.38) 252.44,55.49 CN2063.104
  BOTTOM w0.14: v1(253.33,56.38) 252.6,55.65 R21404.2
M_A_CKE0: length 54.1
  TOP w0.216: U41.AT1 251.87,104.38 251.87,103.13 252.46,102.54 253.22,102.54 253.89,103.22 v1(253.89,103.32) ; v1(251.84,59.68) 251.84,60.09 251.18,60.74 CN2063.109
  IN1 w0.14: v1(251.84,59.68) 251.84,61.29 254.19,63.65 254.19,64.22 254.05,64.36 253.79,64.36 253.65,64.5 253.65,64.78 253.79,64.92 254.05,64.92 254.19,65.06 254.19,65.5 254.05,65.64 253.11,65.64 252.97,65.78 252.97,66.06 253.11,66.2 254.05,66.2 254.19,66.34 254.19,66.51 253.89,66.81 253.89,67.05 254.19,67.35 254.19,98.9 254.15,98.94 254.15,101.92 253.89,102.18 v1(253.89,103.32)
M_A_CKE1: length 55.4
  TOP w0.216: v1(251.87,58.37) 251.45,57.95 251.45,55.44 250.93,54.92 CN2063.110 ; U41.AT2 252.22,104.68 252.22,104.15 252.8,103.57 253.33,103.57 253.73,103.97 v1(253.9,103.97)
  IN1 w0.14: v1(253.9,103.97) 254.53,103.34 254.53,99.41 254.65,99.29 254.65,63.48 252.28,61.11 252.28,58.78 v1(251.87,58.37)
M_A_CLKN0: length 59
  TOP w0.14: v1(242.31,59.55) 242.6,59.26 242.74,59.26 243.79,60.3 243.79,60.63 243.69,60.74 CN2063.139 ; v1(245.53,103.39) 245.38,103.24 245.26,103.24 244.68,103.82 244.68,104.68 U41.AG2
  IN1 w0.089: v1(242.31,59.55) 242.31,58.84 242.23,58.77 241.9,58.77 240.99,57.86 240.81,57.86 240.6,58.07 240.6,58.35 241.54,59.3 241.54,60.45 241.63,60.54 241.94,60.54 242.13,60.73 242.13,61.29 241.94,61.47 241.63,61.47 241.54,61.56 241.54,61.98 241.63,62.07 241.94,62.07 242.13,62.26 242.13,62.82 241.94,63 241.63,63 241.54,63.09 241.54,68.26 242.18,68.9 242.18,74.43 241.77,74.83 241.77,79.26 245.64,83.12 245.64,101.38 246.15,101.89 246.15,103 246.01,103.14 245.78,103.14 v1(245.53,103.39)
M_A_CLKN1: length 62.4
  TOP w0.14: v1(242.43,56.51) 242.72,56.21 242.72,55.86 243.53,55.06 243.53,54.97 243.44,54.88 CN2063.140 ; v1(246.38,104.05) 246.73,104.4 U41.AK1
  IN1 w0.089: v1(246.38,104.05) 246.61,104.28 246.78,104.28 246.88,104.18 246.88,103.15 246.74,103.01 246.74,101.64 246.25,101.14 246.25,82.83 242.8,79.39 242.8,78.76 243.06,78.51 243.34,78.51 243.43,78.42 243.43,78 243.34,77.91 243.16,77.91 242.98,77.72 242.98,77.43 242.78,77.22 242.78,76.57 242.95,76.4 243.24,76.4 243.33,76.31 243.33,75.9 243.24,75.81 242.56,75.81 242.39,75.63 242.39,75.06 242.58,74.87 243.31,74.87 243.43,74.76 243.43,74.25 243.33,74.15 242.96,74.15 242.78,73.96 242.78,73.4 242.96,73.22 243.1,73.22 243.18,73.13 243.18,72.71 243.1,72.62 242.96,72.62 242.78,72.43 242.78,71.7 242.96,71.51 243.13,71.51 243.31,71.34 243.31,71.09 243.13,70.91 242.96,70.91 242.78,70.73 242.78,70.17 243.1,69.84 243.1,69.47 242.78,69.15 242.78,68.48 242.19,67.89 242.19,67.35 242.47,67.08 243.22,67.08 243.31,66.99 243.31,66.57 243.22,66.48 242.33,66.48 242.14,66.29 242.14,65.74 242.33,65.55 242.89,65.55 242.98,65.46 242.98,63.22 242.72,62.97 242.72,62.39 242.98,62.14 242.98,61.69 242.72,61.44 242.72,60.86 242.98,60.61 242.98,57.44 242.93,57.39 242.93,56.68 242.75,56.51 v1(242.43,56.51)
M_A_CLKP0: length 59.1
  TOP w0.14: v1(245.53,102.75) 245.33,102.95 245.13,102.95 244.39,103.7 244.39,104.32 U41.AG1 ; v1(242.31,58.27) 242.31,58.67 242.6,58.97 242.86,58.97 244.08,60.18 244.08,60.63 244.18,60.74 CN2063.137
  IN1 w0.089: v1(242.31,58.27) 242.31,58.39 242.1,58.6 241.97,58.6 241.06,57.69 240.74,57.69 240.43,58 240.43,58.42 241.38,59.36 241.38,60.52 241.56,60.71 241.87,60.71 241.96,60.8 241.96,61.22 241.87,61.31 241.56,61.31 241.38,61.49 241.38,62.05 241.56,62.24 241.87,62.24 241.96,62.33 241.96,62.75 241.87,62.84 241.56,62.84 241.38,63.02 241.38,68.33 242.01,68.97 242.01,74.36 241.61,74.76 241.61,79.33 245.47,83.19 245.47,101.45 245.98,101.96 245.98,102.94 245.94,102.98 245.75,102.98 245.53,102.76 v1(245.53,102.75)
M_A_CLKP1: length 62.4
  TOP w0.14: v1(243.3,56.51) 243.01,56.21 243.01,55.99 243.82,55.18 243.82,54.97 243.91,54.88 243.91,53.61 CN2063.138 ; U41.AK2 246.73,105.05 v1(246.38,104.71)
  IN1 w0.089: v1(243.3,56.51) 243.1,56.71 243.1,57.32 243.15,57.37 243.15,60.68 242.89,60.93 242.89,61.37 243.15,61.63 243.15,62.21 242.89,62.46 242.89,62.9 243.15,63.15 243.15,65.53 242.96,65.72 242.4,65.72 242.31,65.81 242.31,66.23 242.4,66.31 243.29,66.31 243.47,66.5 243.47,67.06 243.29,67.25 242.53,67.25 242.36,67.42 242.36,67.82 242.94,68.41 242.94,69.08 243.27,69.4 243.27,69.91 242.94,70.24 242.94,70.66 243.03,70.75 243.2,70.75 243.47,71.02 243.47,71.41 243.2,71.68 243.03,71.68 242.94,71.77 242.94,72.36 243.03,72.45 243.17,72.45 243.35,72.64 243.35,73.2 243.17,73.39 243.03,73.39 242.94,73.47 242.94,73.89 243.03,73.98 243.4,73.98 243.6,74.18 243.6,74.83 243.38,75.04 242.65,75.04 242.56,75.13 242.56,75.56 242.63,75.64 243.31,75.64 243.5,75.83 243.5,76.38 243.31,76.57 243.02,76.57 242.94,76.64 242.94,77.16 243.15,77.36 243.15,77.65 243.23,77.74 243.41,77.74 243.6,77.93 243.6,78.49 243.41,78.67 243.13,78.67 242.97,78.83 242.97,79.32 246.42,82.76 246.42,101.07 246.91,101.57 246.91,102.94 247.05,103.08 247.05,104.25 246.85,104.45 246.64,104.45 v1(246.38,104.71)
M_A_CS#0: length 60.7
  TOP w0.216: CN2063.149 239.18,59.73 237.32,57.87 234.98,57.87 234.49,58.35 v1(234.49,59.71) ; v1(241.36,106.65) 241.49,106.65 241.79,106.96 U41.AD5
  IN1 w0.14: v1(234.49,59.71) 233.67,60.53 233.67,82.49 238.39,87.2 238.39,99.69 242.03,103.34 242.03,105.98 v1(241.36,106.65)
M_A_CS#1: length 61
  TOP w0.216: v1(242.98,104.73) 242.85,104.73 U41.AE2 ; CN2063.157 237.18,60.88 236.16,59.85 235.24,59.85 v1(235.15,59.76)
  IN1 w0.14: v1(235.15,59.76) 235.15,60.65 234.59,61.21 234.59,77.74 234.79,77.94 234.79,78.3 234.59,78.5 234.59,78.78 234.86,79.06 234.86,79.42 234.59,79.69 234.59,80.06 235.23,80.7 235.23,80.9 234.77,81.36 234.77,81.56 234.97,81.76 235.17,81.76 235.63,81.3 235.83,81.3 236.02,81.49 236.02,81.69 235.56,82.15 235.56,82.35 235.76,82.55 235.96,82.55 236.42,82.09 236.62,82.09 236.81,82.29 236.81,82.48 236.36,82.94 236.36,83.14 236.55,83.34 236.75,83.34 237.21,82.88 237.41,82.88 237.6,83.08 237.6,83.27 237.15,83.73 237.15,83.93 237.34,84.13 237.54,84.13 238,83.67 238.2,83.67 238.4,83.87 238.4,84.06 237.94,84.52 237.94,84.72 238.13,84.92 238.33,84.92 238.79,84.46 238.99,84.46 239.29,84.76 239.29,85.06 238.91,85.44 238.91,85.69 239.64,86.42 239.64,100.12 242.57,103.06 242.57,104.32 v1(242.98,104.73)
M_A_DQ0: length 61.6
  TOP w0.14: v1(276.46,56.68) 277.44,55.7 CN2063.4 ; v1(266.44,108.04) 266.1,108.37 265.63,108.37 265.4,108.14 265.4,107.78 U41.BR6
  IN1 w0.089: v1(276.46,56.68) 275.4,57.74 275.4,78.11 274.86,78.65 274.86,89.24 272.44,91.66 272.44,99.55 271.32,100.67 271.32,103.63 270.96,103.98 270.96,104.4 270.72,104.65 270.72,104.98 267.98,107.72 266.76,107.72 v1(266.44,108.04)
M_A_DQ1: length 61.1
  TOP w0.14: CN2063.8 v1(276.44,55.21) ; U41.BT6 265.89,107.94 266.24,107.59 266.97,107.59 267.23,107.33 v1(267.23,107.05)
  IN1 w0.089: v1(267.23,107.05) 267.46,107.28 268.01,107.28 270.43,104.86 270.43,104.47 270.67,104.23 270.67,103.8 271.03,103.45 271.03,100.55 272.15,99.42 272.15,91.47 274.55,89.06 274.55,78.55 275.11,77.99 275.11,75.6 275.02,75.51 274.81,75.51 274.72,75.42 274.72,75.25 274.81,75.16 275.02,75.16 275.11,75.07 275.11,74.89 275.02,74.8 274.81,74.8 274.72,74.71 274.72,74.53 274.81,74.45 275.02,74.45 275.11,74.36 275.11,56.54 v1(276.44,55.21)
M_A_DQ2: length 61.6
  TOP w0.079: U41.BP3 265.01,105.47 265.36,105.47 265.48,105.35 266.19,105.35
  TOP w0.14: v1(273.07,58.95) 273.53,59.41 273.53,60.12 274.19,60.77 CN2063.17 ; v1(267.25,105.19) 266.45,105.19 266.29,105.35 266.19,105.35
  IN1 w0.089: v1(267.25,105.19) 267.25,105.18 268.32,104.11 268.32,103.88 268.76,103.44 268.76,103.01 269.12,102.65 269.12,99.72 269.21,99.63 269.21,99.2 269.3,99.11 269.55,99.11 269.64,99.02 269.64,98.84 269.55,98.75 269.3,98.75 269.21,98.66 269.21,98.48 269.3,98.4 269.55,98.4 269.64,98.31 269.64,98.13 269.55,98.04 269.3,98.04 269.21,97.95 269.21,97.77 269.3,97.68 269.55,97.68 269.64,97.6 269.64,97.42 269.55,97.33 269.3,97.33 269.21,97.24 269.21,97.06 269.3,96.97 269.55,96.97 269.64,96.88 269.64,96.71 269.55,96.62 269.3,96.62 269.21,96.53 269.21,96.35 269.3,96.26 269.55,96.26 269.64,96.17 269.64,95.99 269.55,95.91 269.3,95.91 269.21,95.82 269.21,95.64 269.3,95.55 269.55,95.55 269.64,95.46 269.64,95.28 269.55,95.19 269.3,95.19 269.21,95.11 269.21,94.93 269.3,94.84 269.55,94.84 269.64,94.75 269.64,94.57 269.55,94.48 269.3,94.48 269.21,94.39 269.21,94.22 269.3,94.13 269.55,94.13 269.64,94.04 269.64,93.86 269.55,93.77 269.3,93.77 269.21,93.68 269.21,93.51 269.3,93.42 269.55,93.42 269.64,93.33 269.64,93.15 269.55,93.06 269.3,93.06 269.21,92.97 269.21,92.79 269.3,92.71 269.55,92.71 269.64,92.62 269.64,92.44 269.55,92.35 269.3,92.35 269.21,92.26 269.21,91.7 272.21,88.71 272.21,59.55 272.81,58.95 v1(273.07,58.95)
M_A_DQ3: length 61.6
  TOP w0.102: 266.34,106.37 266.03,106.06 265.73,106.06 265.46,105.79 U41.BR3
  TOP w0.14: v1(273.05,60.4) 273.19,60.53 CN2063.21 ; 266.34,106.37 266.75,106.37 267.1,106.01 v1(267.1,105.86)
  IN1 w0.089: v1(273.05,60.4) 272.51,60.94 272.51,88.82 269.93,91.39 269.93,91.69 270.02,91.77 270.44,91.77 270.53,91.86 270.53,92.04 270.44,92.13 270.02,92.13 269.93,92.22 269.93,92.4 270.02,92.49 270.44,92.49 270.53,92.57 270.53,92.75 270.44,92.84 270.02,92.84 269.93,92.93 269.93,93.11 270.02,93.2 270.44,93.2 270.53,93.29 270.53,93.46 270.44,93.55 270.02,93.55 269.93,93.64 269.93,93.82 270.02,93.91 270.44,93.91 270.53,94 270.53,94.17 270.44,94.26 270.02,94.26 269.93,94.35 269.93,94.53 270.02,94.62 270.44,94.62 270.53,94.71 270.53,94.89 270.44,94.97 270.02,94.97 269.93,95.06 269.93,95.24 270.02,95.33 270.44,95.33 270.53,95.42 270.53,95.6 270.44,95.69 270.02,95.69 269.93,95.77 269.93,95.95 270.02,96.04 270.44,96.04 270.53,96.13 270.53,96.31 270.44,96.4 270.02,96.4 269.93,96.49 269.93,96.66 270.02,96.75 270.44,96.75 270.53,96.84 270.53,97.02 270.44,97.11 270.02,97.11 269.93,97.2 269.93,97.37 270.02,97.46 270.44,97.46 270.53,97.55 270.53,97.73 270.44,97.82 270.02,97.82 269.93,97.91 269.93,98.09 270.02,98.18 270.44,98.18 270.53,98.26 270.53,98.44 270.44,98.53 270.02,98.53 269.93,98.62 269.93,99.32 269.41,99.84 269.41,102.77 269.05,103.13 269.05,103.56 268.68,103.94 268.68,104.17 268.01,104.84 268.01,104.99 267.14,105.86 v1(267.1,105.86)
M_A_DQ4: length 61.6
  TOP w0.14: CN2063.3 277.68,60.03 v1(276.47,58.82) ; U41.BN5 264.05,107.95 v1(264.09,108)
  IN1 w0.089: v1(276.47,58.82) 275.69,59.6 275.69,78.23 275.15,78.78 275.15,89.36 272.73,91.78 272.73,99.67 271.61,100.79 271.61,103.75 271.26,104.1 271.26,104.52 271.01,104.77 271.01,105.1 268.1,108.01 267.01,108.01 266.6,108.42 266.03,108.42 265.29,107.68 264.41,107.68 v1(264.09,108)
M_A_DQ5: length 61.8
  TOP w0.112: v1(264.92,108.08) U41.BP6
  TOP w0.14: v1(276.43,60.22) 276.68,60.48 CN2063.7
  IN1 w0.089: v1(276.43,60.22) 275.98,60.66 275.98,78.35 275.44,78.9 275.44,89.48 273.32,91.6 273.32,91.9 273.24,91.99 273.11,91.99 273.02,92.08 273.02,92.26 273.11,92.34 273.24,92.34 273.32,92.43 273.32,92.61 273.24,92.7 273.11,92.7 273.02,92.79 273.02,92.97 273.11,93.06 273.24,93.06 273.32,93.14 273.32,93.32 273.24,93.41 273.11,93.41 273.02,93.5 273.02,93.68 273.11,93.77 273.24,93.77 273.32,93.86 273.32,94.03 273.24,94.12 273.11,94.12 273.02,94.21 273.02,94.39 273.11,94.48 273.24,94.48 273.32,94.57 273.32,94.74 273.24,94.83 273.11,94.83 273.02,94.92 273.02,95.1 273.11,95.19 273.24,95.19 273.32,95.28 273.32,95.46 273.24,95.54 273.11,95.54 273.02,95.63 273.02,95.81 273.11,95.9 273.24,95.9 273.32,95.99 273.32,96.17 273.24,96.26 273.11,96.26 273.02,96.34 273.02,96.52 273.11,96.61 273.24,96.61 273.32,96.7 273.32,96.88 273.24,96.97 273.11,96.97 273.02,97.06 273.02,97.23 273.11,97.32 273.24,97.32 273.32,97.41 273.32,97.59 273.24,97.68 273.11,97.68 273.02,97.77 273.02,97.94 273.11,98.03 273.24,98.03 273.32,98.12 273.32,98.3 273.24,98.39 273.11,98.39 273.02,98.48 273.02,98.66 273.11,98.75 273.24,98.75 273.32,98.83 273.32,99.49 271.9,100.91 271.9,103.87 271.55,104.22 271.55,104.65 271.3,104.89 271.3,105.35 270.54,106.12 270.54,106.78 269.88,107.43 269.24,107.43 268.37,108.3 267.13,108.3 266.72,108.72 265.56,108.72 265.21,108.36 265.2,108.36 v1(264.92,108.08)
M_A_DQ6: length 61.7
  TOP w0.102: 264.94,104.18 264.94,104.83 U41.BP2
  TOP w0.14: v1(268.17,103.37) 265.75,103.37 264.94,104.18 ; v1(272.99,57.45) 274.44,56 CN2063.16
  IN1 w0.089: v1(272.99,57.45) 273.15,57.6 273.15,58.08 272.99,58.23 272.02,58.23 271.89,58.37 271.89,58.58 271.98,58.67 272.32,58.67 272.41,58.76 272.41,58.94 272.32,59.03 271.99,59.03 271.9,59.12 271.9,84.22 271.81,84.31 271.63,84.31 271.55,84.39 271.55,84.57 271.63,84.66 271.81,84.66 271.9,84.75 271.9,84.93 271.81,85.02 271.63,85.02 271.55,85.11 271.55,85.28 271.63,85.37 271.81,85.37 271.9,85.46 271.9,85.64 271.81,85.73 271.63,85.73 271.55,85.82 271.55,85.99 271.63,86.08 271.81,86.08 271.9,86.17 271.9,86.35 271.81,86.44 271.63,86.44 271.55,86.53 271.55,86.71 271.63,86.79 271.81,86.79 271.9,86.88 271.9,87.06 271.81,87.15 271.63,87.15 271.55,87.24 271.55,87.42 271.63,87.51 271.81,87.51 271.9,87.59 271.9,87.77 271.81,87.86 271.63,87.86 271.55,87.95 271.55,88.13 271.63,88.22 271.81,88.22 271.9,88.31 271.9,88.6 268.92,91.58 268.92,99.51 268.83,99.6 268.83,102.38 268.42,102.79 268.42,103.12 v1(268.17,103.37)
M_A_DQ7: length 61.9
  TOP w0.079: U41.BN3 263.96,105.52 264.22,105.26 264.22,104.32 264.23,104.31
  TOP w0.14: 264.23,104.31 264.23,104.23 265.73,102.73 267.38,102.73 v1(268.17,101.95) ; v1(272.94,55.95) 273.44,55.46 CN2063.20
  IN1 w0.089: v1(272.94,55.95) 272.32,56.57 272.32,57.42 271.6,58.14 271.6,76.67 271.51,76.76 271.34,76.76 271.25,76.85 271.25,77.02 271.34,77.11 271.51,77.11 271.6,77.2 271.6,77.38 271.51,77.47 271.34,77.47 271.25,77.56 271.25,77.73 271.34,77.82 271.51,77.82 271.6,77.91 271.6,78.09 271.51,78.18 271.34,78.18 271.25,78.27 271.25,78.45 271.34,78.53 271.51,78.53 271.6,78.62 271.6,78.8 271.51,78.89 271.34,78.89 271.25,78.98 271.25,79.16 271.34,79.25 271.51,79.25 271.6,79.33 271.6,79.51 271.51,79.6 271.34,79.6 271.25,79.69 271.25,79.87 271.34,79.96 271.51,79.96 271.6,80.05 271.6,80.22 271.51,80.31 271.34,80.31 271.25,80.4 271.25,80.58 271.34,80.67 271.51,80.67 271.6,80.76 271.6,80.93 271.51,81.02 271.34,81.02 271.25,81.11 271.25,81.29 271.34,81.38 271.51,81.38 271.6,81.47 271.6,81.65 271.51,81.73 271.34,81.73 271.25,81.82 271.25,82 271.34,82.09 271.51,82.09 271.6,82.18 271.6,82.36 271.51,82.45 271.34,82.45 271.25,82.54 271.25,82.71 271.34,82.8 271.51,82.8 271.6,82.89 271.6,83.07 271.51,83.16 271.34,83.16 271.25,83.25 271.25,83.42 271.34,83.51 271.51,83.51 271.6,83.6 271.6,83.78 271.51,83.87 271.34,83.87 271.25,83.96 271.25,88.83 268.63,91.46 268.63,99.38 268.53,99.48 268.53,101.58 v1(268.17,101.95)
M_A_DQ8: length 58.4
  TOP w0.14: CN2063.28 271.44,54.66 271.17,54.93 v1(271.17,55.32) ; v1(263.39,104.84) 263.36,104.84 262.97,105.24 262.97,106.03 U41.BL4
  IN1 w0.089: v1(271.17,55.32) 270.02,56.46 270.02,56.84 270.11,56.93 270.44,56.93 270.53,57.02 270.53,57.2 270.44,57.29 270.11,57.29 270.02,57.38 270.02,59.24 269.64,59.62 269.64,88.18 266.71,91.11 266.71,103.06 264.68,105.1 263.65,105.1 v1(263.39,104.84)
M_A_DQ9: length 58.5
  TOP w0.14: CN2063.25 272.19,60 v1(271.14,58.95) ; v1(262.25,106.68) 262.58,107.01 U41.BL5
  IN1 w0.089: v1(271.14,58.95) 270.23,59.86 270.23,88.42 267.3,91.35 267.3,91.64 267.39,91.73 267.52,91.73 267.61,91.82 267.61,92 267.52,92.09 267.39,92.09 267.3,92.18 267.3,92.35 267.39,92.44 267.52,92.44 267.61,92.53 267.61,92.71 267.52,92.8 267.39,92.8 267.3,92.89 267.3,93.07 267.39,93.15 267.52,93.15 267.61,93.24 267.61,93.42 267.52,93.51 267.39,93.51 267.3,93.6 267.3,93.78 267.39,93.87 267.52,93.87 267.61,93.95 267.61,94.13 267.52,94.22 267.39,94.22 267.3,94.31 267.3,94.49 267.39,94.58 267.52,94.58 267.61,94.67 267.61,94.84 267.52,94.93 267.39,94.93 267.3,95.02 267.3,103.3 264.59,106.01 264.31,106.01 263.39,106.93 262.5,106.93 v1(262.25,106.68)
M_A_DQ10: length 58.3
  TOP w0.102: U41.BL2 262.56,104.92 262.35,104.92 261.97,104.54 261.97,104.26 262.11,104.12 262.11,103.6
  TOP w0.14: CN2063.37 269.19,60.32 v1(267.91,59.05) ; v1(263.5,102.99) 263.48,102.99 263.43,102.94 262.59,102.94 262.11,103.42 262.11,103.6
  IN1 w0.089: v1(267.91,59.05) 266.98,59.98 266.98,80.61 267.07,80.7 267.27,80.7 267.36,80.79 267.36,80.97 267.27,81.06 267.07,81.06 266.98,81.14 266.98,81.32 267.07,81.41 267.27,81.41 267.36,81.5 267.36,81.68 267.27,81.77 267.07,81.77 266.98,81.86 266.98,82.03 267.07,82.12 267.27,82.12 267.36,82.21 267.36,82.39 267.27,82.48 267.07,82.48 266.98,82.57 266.98,82.75 267.07,82.83 267.27,82.83 267.36,82.92 267.36,83.1 267.27,83.19 267.07,83.19 266.98,83.28 266.98,83.46 267.07,83.55 267.27,83.55 267.36,83.63 267.36,83.81 267.27,83.9 267.07,83.9 266.98,83.99 266.98,84.17 267.07,84.26 267.27,84.26 267.36,84.35 267.36,84.52 267.27,84.61 267.07,84.61 266.98,84.7 266.98,84.88 267.07,84.97 267.27,84.97 267.36,85.06 267.36,85.23 267.27,85.32 267.07,85.32 266.98,85.41 266.98,85.59 267.07,85.68 267.27,85.68 267.36,85.77 267.36,85.95 267.27,86.03 267.07,86.03 266.98,86.12 266.98,86.3 267.07,86.39 267.27,86.39 267.36,86.48 267.36,86.66 267.27,86.75 267.07,86.75 266.98,86.83 266.98,87.01 267.07,87.1 267.27,87.1 267.36,87.19 267.36,87.37 267.27,87.46 267.27,87.86 264.68,90.44 264.68,102.21 263.91,102.99 v1(263.5,102.99)
M_A_DQ11: length 58.5
  TOP w0.14: CN2063.42 267.93,55.75 v1(267.89,55.8) ; v1(263.88,101.74) 263.9,101.74 264.31,102.15 264.31,103.42 263.32,104.4 U41.BM1
  IN1 w0.089: v1(267.89,55.8) 267.39,56.3 266.47,56.3 266.4,56.37 266.4,75.61 266.35,75.65 266.35,77.41 266.26,77.5 266.11,77.5 266.02,77.59 266.02,77.76 266.11,77.85 266.26,77.85 266.35,77.94 266.35,78.12 266.26,78.21 266.11,78.21 266.02,78.3 266.02,78.47 266.11,78.56 266.26,78.56 266.35,78.65 266.35,78.83 266.26,78.92 266.11,78.92 266.02,79.01 266.02,79.19 266.11,79.27 266.26,79.27 266.35,79.36 266.35,79.54 266.26,79.63 266.11,79.63 266.02,79.72 266.02,79.9 266.11,79.99 266.26,79.99 266.35,80.07 266.35,80.25 266.26,80.34 266.11,80.34 266.02,80.43 266.02,80.61 266.11,80.7 266.26,80.7 266.35,80.79 266.35,80.96 266.26,81.05 266.11,81.05 266.02,81.14 266.02,81.32 266.11,81.41 266.26,81.41 266.35,81.5 266.35,81.67 266.26,81.76 266.11,81.76 266.02,81.85 266.02,82.03 266.11,82.12 266.26,82.12 266.35,82.21 266.35,82.39 266.26,82.47 266.11,82.47 266.02,82.56 266.02,82.74 266.11,82.83 266.26,82.83 266.35,82.92 266.35,83.1 266.26,83.19 266.11,83.19 266.02,83.27 266.02,83.45 266.11,83.54 266.26,83.54 266.35,83.63 266.35,83.81 266.26,83.9 266.11,83.9 266.02,83.99 266.02,84.16 266.11,84.25 266.26,84.25 266.35,84.34 266.35,84.52 266.26,84.61 266.11,84.61 266.02,84.7 266.02,88.28 264.1,90.2 264.1,101.52 v1(263.88,101.74)
M_A_DQ12: length 58.3
  TOP w0.14: v1(262.25,106.03) 261.93,106.35 U41.BK4 ; CN2063.24 272.44,54.65 271.95,55.14 271.95,56.77 v1(271.23,57.49)
  IN1 w0.089: v1(262.25,106.03) 262.27,106.01 263.14,106.01 263.55,105.6 264.58,105.6 267.01,103.18 267.01,91.23 269.93,88.3 269.93,59.74 270.53,59.15 270.53,58.19 v1(271.23,57.49)
M_A_DQ13: length 57.9
  TOP w0.14: v1(261.44,106.68) 261.77,107.01 U41.BK5 ; v1(271.12,60.4) 271.19,60.46 CN2063.29
  IN1 w0.079: 264.75,106.26 265.35,105.66
  IN1 w0.089: v1(261.44,106.68) 261.72,106.96 262.04,107.27 263.61,107.27 264.61,106.26 264.75,106.26 ; v1(271.12,60.4) 270.53,60.99 270.53,65.53 270.62,65.62 270.78,65.62 270.87,65.71 270.87,65.88 270.78,65.97 270.62,65.97 270.53,66.06 270.53,66.24 270.62,66.33 270.78,66.33 270.87,66.42 270.87,66.59 270.78,66.68 270.62,66.68 270.53,66.77 270.53,66.95 270.62,67.04 270.78,67.04 270.87,67.13 270.87,67.31 270.78,67.4 270.62,67.4 270.53,67.48 270.53,88.53 267.9,91.16 267.9,95.45 267.81,95.54 267.68,95.54 267.59,95.63 267.59,95.81 267.68,95.9 267.81,95.9 267.9,95.99 267.9,96.16 267.81,96.25 267.68,96.25 267.59,96.34 267.59,96.52 267.68,96.61 267.81,96.61 267.9,96.7 267.9,96.88 267.81,96.97 267.68,96.97 267.59,97.05 267.59,97.23 267.68,97.32 267.81,97.32 267.9,97.41 267.9,97.59 267.81,97.68 267.68,97.68 267.59,97.77 267.59,97.94 267.68,98.03 267.81,98.03 267.9,98.12 267.9,98.3 267.81,98.39 267.68,98.39 267.59,98.48 267.59,98.65 267.68,98.74 267.81,98.74 267.9,98.83 267.9,99.12 267.59,99.43 267.59,103.43 265.35,105.66
M_A_DQ14: length 58.2
  TOP w0.102: v1(263.47,103.65) 263.09,103.27 262.58,103.27 262.38,103.47 262.38,104.32 U41.BK1
  TOP w0.14: v1(267.89,60.5) 268.19,60.79 CN2063.41
  IN1 w0.089: v1(263.47,103.65) 263.64,103.47 263.84,103.47 264.98,102.33 264.98,90.56 267.68,87.85 267.68,80.41 267.59,80.32 267.36,80.32 267.27,80.23 267.27,80.05 267.36,79.96 267.59,79.96 267.68,79.87 267.68,79.7 267.59,79.61 267.36,79.61 267.27,79.52 267.27,79.34 267.36,79.25 267.59,79.25 267.68,79.16 267.68,78.99 267.59,78.9 267.36,78.9 267.27,78.81 267.27,78.63 267.36,78.54 267.59,78.54 267.68,78.45 267.68,78.27 267.59,78.19 267.36,78.19 267.27,78.1 267.27,77.92 267.36,77.83 267.59,77.83 267.68,77.74 267.68,77.56 267.59,77.47 267.36,77.47 267.27,77.39 267.27,75.73 267.36,75.65 267.59,75.65 267.68,75.56 267.68,75.38 267.59,75.29 267.36,75.29 267.27,75.2 267.27,75.02 267.36,74.93 267.59,74.93 267.68,74.85 267.68,74.67 267.59,74.58 267.36,74.58 267.27,74.49 267.27,74.31 267.36,74.22 267.59,74.22 267.68,74.13 267.68,73.96 267.59,73.87 267.36,73.87 267.27,73.78 267.27,71.51 267.36,71.42 267.55,71.42 267.63,71.33 267.63,71.15 267.55,71.06 267.36,71.06 267.27,70.97 267.27,70.8 267.36,70.71 267.55,70.71 267.63,70.62 267.63,70.44 267.55,70.35 267.36,70.35 267.27,70.26 267.27,70.08 267.36,70 267.55,70 267.63,69.91 267.63,69.73 267.55,69.64 267.36,69.64 267.27,69.55 267.27,67.55 267.36,67.46 267.59,67.46 267.68,67.37 267.68,67.19 267.59,67.11 267.36,67.11 267.27,67.02 267.27,66.84 267.36,66.75 267.59,66.75 267.68,66.66 267.68,66.48 267.59,66.39 267.36,66.39 267.27,66.31 267.27,66.13 267.36,66.04 267.59,66.04 267.68,65.95 267.68,65.77 267.59,65.68 267.36,65.68 267.27,65.59 267.27,62.66 267.36,62.57 267.59,62.57 267.68,62.48 267.68,62.3 267.59,62.21 267.36,62.21 267.27,62.12 267.27,61.95 267.36,61.86 267.59,61.86 267.68,61.77 267.68,61.59 267.59,61.5 267.36,61.5 267.27,61.41 267.27,61.12 v1(267.89,60.5)
M_A_DQ15: length 58.5
  TOP w0.102: U41.BK2 261.68,104.88 261.68,104.25 261.87,104.06 261.87,103.63
  TOP w0.14: 261.87,103.63 261.87,103.18 262.65,102.4 v1(263.8,102.4) ; v1(267.9,57.11) 268.93,56.07 CN2063.38
  IN1 w0.089: v1(263.8,102.4) 263.85,102.44 264.04,102.44 264.39,102.09 264.39,90.32 266.69,88.02 266.69,58.61 266.78,58.52 267.23,58.52 267.32,58.43 267.32,58.25 267.23,58.17 266.78,58.17 266.69,58.08 266.69,57.9 266.78,57.81 267.33,57.81 267.42,57.72 267.42,57.54 267.33,57.45 266.82,57.45 266.75,57.38 266.75,57.17 267.02,56.89 267.68,56.89 v1(267.9,57.11)
M_A_DQ16: length 56.1
  TOP w0.14: v1(265.88,58.95) 266.32,58.95 267.19,59.82 CN2063.45 ; U41.BG4 260.24,106.35 v1(260.6,106)
  IN1 w0.089: v1(265.88,58.95) 264.99,59.84 264.99,79.63 264.9,79.72 264.82,79.72 264.73,79.81 264.73,79.99 264.82,80.08 264.9,80.08 264.99,80.17 264.99,80.34 264.9,80.43 264.82,80.43 264.73,80.52 264.73,80.7 264.82,80.79 264.9,80.79 264.99,80.88 264.99,81.06 264.9,81.14 264.82,81.14 264.73,81.23 264.73,81.41 264.82,81.5 264.9,81.5 264.99,81.59 264.99,81.77 264.9,81.86 264.82,81.86 264.73,81.94 264.73,82.12 264.82,82.21 264.9,82.21 264.99,82.3 264.99,82.48 264.9,82.57 264.82,82.57 264.73,82.66 264.73,82.83 264.82,82.92 264.9,82.92 264.99,83.01 264.99,83.19 264.9,83.28 264.82,83.28 264.73,83.37 264.73,83.54 264.82,83.63 264.9,83.63 264.99,83.72 264.99,83.9 264.9,83.99 264.82,83.99 264.73,84.08 264.73,84.26 264.82,84.34 264.9,84.34 264.99,84.43 264.99,84.61 264.9,84.7 264.82,84.7 264.73,84.79 264.73,84.97 264.82,85.06 264.9,85.06 264.99,85.14 264.99,85.32 264.9,85.41 264.82,85.41 264.73,85.5 264.73,88.13 263.08,89.78 263.08,101.77 261.41,103.45 261.28,103.45 261.03,103.7 261.03,104.15 260.6,104.57 v1(260.6,106)
M_A_DQ17: length 56
  TOP w0.14: U41.BG5 260.27,107.01 v1(260.61,106.66) ; v1(265.86,60.4) 266.19,60.72 CN2063.49
  IN1 w0.089: v1(265.86,60.4) 265.3,60.96 265.3,61.25 265.39,61.34 265.58,61.34 265.67,61.43 265.67,61.61 265.58,61.7 265.39,61.7 265.3,61.79 265.3,61.97 265.39,62.05 265.58,62.05 265.67,62.14 265.67,62.32 265.58,62.41 265.39,62.41 265.3,62.5 265.3,65.6 265.39,65.69 265.58,65.69 265.67,65.78 265.67,65.96 265.58,66.05 265.39,66.05 265.3,66.14 265.3,66.32 265.39,66.4 265.58,66.4 265.67,66.49 265.67,66.67 265.58,66.76 265.39,66.76 265.3,66.85 265.3,67.03 265.39,67.12 265.58,67.12 265.67,67.2 265.67,67.38 265.58,67.47 265.39,67.47 265.3,67.56 265.3,69.6 265.39,69.69 265.58,69.69 265.67,69.78 265.67,69.95 265.58,70.04 265.39,70.04 265.3,70.13 265.3,70.31 265.39,70.4 265.58,70.4 265.67,70.49 265.67,70.66 265.58,70.75 265.39,70.75 265.3,70.84 265.3,71.02 265.39,71.11 265.58,71.11 265.67,71.2 265.67,71.38 265.58,71.46 265.39,71.46 265.3,71.55 265.3,73.77 265.39,73.86 265.58,73.86 265.67,73.95 265.67,74.13 265.58,74.22 265.39,74.22 265.3,74.31 265.3,74.48 265.39,74.57 265.58,74.57 265.67,74.66 265.67,74.84 265.58,74.93 265.39,74.93 265.3,75.02 265.3,87.98 263.38,89.9 263.38,101.89 261.92,103.35 261.92,103.95 261.03,104.84 261.03,106.23 260.87,106.4 260.87,106.4 v1(260.61,106.66)
M_A_DQ18: length 55.6
  TOP w0.14: CN2063.59 263.69,60.63 263.01,59.95 263.01,59.43 v1(262.55,58.97) ; U41.BF4 259.33,106.35 v1(258.97,106)
  IN1 w0.089: v1(258.97,106) 259.33,106 259.61,105.72 259.61,103.62 260.05,103.18 260.05,100.62 260.59,100.08 260.59,88.74 261.82,87.52 261.82,60.4 261.91,60.31 262.12,60.31 262.21,60.22 262.21,60.04 262.12,59.95 261.91,59.95 261.82,59.86 261.82,59.69 261.91,59.6 262.11,59.6 262.2,59.51 262.2,59.33 262.11,59.24 261.91,59.24 261.82,59.15 261.82,58.22 261.89,58.14 262.4,58.14 262.49,58.23 262.49,58.91 v1(262.55,58.97)
M_A_DQ19: length 55.6
  TOP w0.14: v1(262.54,60.42) 262.69,60.57 CN2063.63 ; v1(258.97,106.65) 259.33,107.01 U41.BF5
  IN1 w0.089: v1(258.97,106.65) 259.23,106.65 259.99,105.88 259.99,103.62 260.34,103.27 260.34,100.74 260.88,100.2 260.88,88.87 262.12,87.63 262.12,75.72 262.21,75.63 262.4,75.63 262.49,75.54 262.49,75.36 262.4,75.27 262.21,75.27 262.12,75.19 262.12,75.01 262.21,74.92 262.4,74.92 262.49,74.83 262.49,74.65 262.4,74.56 262.21,74.56 262.12,74.47 262.12,74.3 262.21,74.21 262.4,74.21 262.49,74.12 262.49,73.94 262.4,73.85 262.21,73.85 262.12,73.76 262.12,71.45 262.21,71.36 262.4,71.36 262.49,71.27 262.49,71.1 262.4,71.01 262.21,71.01 262.12,70.92 262.12,70.74 262.21,70.65 262.4,70.65 262.49,70.56 262.49,70.39 262.4,70.3 262.21,70.3 262.12,70.21 262.12,70.03 262.21,69.94 262.4,69.94 262.49,69.85 262.49,69.67 262.4,69.59 262.21,69.59 262.12,69.5 262.12,67.53 262.21,67.44 262.4,67.44 262.49,67.35 262.49,67.17 262.4,67.09 262.21,67.09 262.12,67 262.12,66.82 262.21,66.73 262.4,66.73 262.49,66.64 262.49,66.46 262.4,66.37 262.21,66.37 262.12,66.29 262.12,66.11 262.21,66.02 262.4,66.02 262.49,65.93 262.49,65.75 262.4,65.66 262.21,65.66 262.12,65.57 262.12,62.37 262.21,62.28 262.4,62.28 262.49,62.19 262.49,62.02 262.4,61.93 262.21,61.93 262.12,61.84 262.12,61.66 262.21,61.57 262.4,61.57 262.49,61.48 262.49,61.31 262.4,61.22 262.21,61.22 262.12,61.13 262.12,60.84 v1(262.54,60.42)
M_A_DQ20: length 56.4
  TOP w0.102: U41.BG2 260.13,104.85 260.45,104.54 260.45,103.96 v1(260.41,103.92)
  TOP w0.14: v1(266.01,57.12) 266.93,56.19 CN2063.46
  IN1 w0.089: v1(266.01,57.12) 265.67,57.45 265.67,58.61 264.69,59.6 264.69,74.65 264.44,74.9 264.44,75.19 264.53,75.28 264.61,75.28 264.7,75.37 264.7,75.54 264.61,75.63 264.53,75.63 264.44,75.72 264.44,75.9 264.53,75.99 264.61,75.99 264.7,76.08 264.7,76.25 264.61,76.34 264.53,76.34 264.44,76.43 264.44,76.61 264.53,76.7 264.61,76.7 264.7,76.79 264.7,76.97 264.61,77.05 264.53,77.05 264.44,77.14 264.44,77.32 264.53,77.41 264.61,77.41 264.7,77.5 264.7,77.68 264.61,77.77 264.53,77.77 264.44,77.86 264.44,78.03 264.53,78.12 264.61,78.12 264.7,78.21 264.7,78.39 264.61,78.48 264.53,78.48 264.44,78.57 264.44,78.74 264.53,78.83 264.61,78.83 264.7,78.92 264.7,79.1 264.61,79.19 264.53,79.19 264.44,79.28 264.44,88.01 262.79,89.66 262.79,101.65 261.3,103.14 261.16,103.14 260.75,103.55 260.75,103.8 260.63,103.92 v1(260.41,103.92)
M_A_DQ21: length 55.7
  TOP w0.102: v1(260.75,102.83) 259.89,103.7 259.89,104.16 U41.BG1
  TOP w0.14: CN2063.50 v1(265.93,55.64)
  IN1 w0.089: v1(265.93,55.64) 265.25,56.32 265.25,58.62 264.38,59.49 264.38,60.16 264.29,60.25 264.2,60.25 264.11,60.34 264.11,60.52 264.2,60.61 264.29,60.61 264.38,60.7 264.38,60.88 264.29,60.97 264.2,60.97 264.11,61.05 264.11,61.23 264.2,61.32 264.29,61.32 264.38,61.41 264.38,61.59 264.29,61.68 264.2,61.68 264.11,61.77 264.11,61.94 264.2,62.03 264.29,62.03 264.38,62.12 264.38,62.3 264.29,62.39 264.2,62.39 264.11,62.48 264.11,62.65 264.2,62.74 264.29,62.74 264.38,62.83 264.38,69.55 264.29,69.64 264.2,69.64 264.11,69.73 264.11,69.91 264.2,69.99 264.29,69.99 264.38,70.08 264.38,73.73 264.29,73.82 264.24,73.82 264.15,73.91 264.15,74.09 264.24,74.17 264.29,74.17 264.38,74.26 264.38,74.44 264.29,74.53 264.24,74.53 264.15,74.62 264.15,87.89 262.5,89.53 262.5,101.53 261.19,102.83 v1(260.75,102.83)
