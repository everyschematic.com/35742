# Allegro board DAZGLMB1ED0 dazglmb1ed0-d-ver a-165 (.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
I2C_TP_SDA_R: length 31.6
  TOP w0.14: v1(133.62,59.27) 133.62,59.4 134.55,60.33 CN2076.5 134.55,62.79 v1(134.39,62.96) ; R67258.2 122.03,66.1 Q7892.4 121.36,65.62 121.25,65.51 R21067.1 120.68,65.51 v1(120.29,65.12) ; CN2078.6 138,54.25 v1(138.45,54.7)
  IN1 w0.089: v1(134.39,62.96) 133.27,61.84 129.74,61.84 127.73,63.85 125.22,63.85 124.12,64.94 120.47,64.94 v1(120.29,65.12)
  BOTTOM w0.14: v1(133.62,59.27) 133.62,59.02 134.42,58.22 134.98,58.22 138.45,54.75 v1(138.45,54.7)
I2CB_SCL_G: length 13.4
  TOP w0.14: v2(147.69,117.48) 147.99,117.19 147.99,117.18 U13114.BG8
  BOTTOM w0.14: R21571.2 150.18,106.4 148.97,107.61 148.6,107.61 147.97,108.24 147.97,114.11 148.33,114.47 148.33,115.08 148.23,115.18 148.23,116.95 v2(147.69,117.48)
I2CB_SDA_G: length 15.7
  TOP w0.14: U13114.BF8 148.12,117.71 147.84,117.99 v2(147.84,118.11)
  BOTTOM w0.14: v2(147.84,118.11) 147.84,117.99 148.48,117.35 148.48,115.61 148.71,115.38 148.71,114.42 148.25,113.95 148.25,108.36 148.67,107.94 149.04,107.94 150.02,106.95 150.73,106.95 R21572.2 151.76,106.4 v1(152.13,106.78)
I2CC_SCL_GFX: length 20.3
  TOP w0.112: U13114.BG9 148.86,116.78 148.98,116.66 v2(149.21,116.66)
  IN1 w0.089: v2(149.21,116.66) 148.76,116.21 148.76,115.69 149,115.45 149,113.82 148.62,113.44 148.62,107.63 149.09,107.16 149.09,104.02 v1(148.81,103.75)
  BOTTOM w0.14: Q7858.4 148.82,98.86 149.12,99.15 149.12,100.27 148.61,100.78 R21569.2 148.73,101.56 149.19,102.02 149.19,103.37 v1(148.81,103.75)
I2CC_SCL_IPC: length 60.3
  IN3 w0.079: v1(148.64,99.53) 148.64,98.7 148.15,98.22 140.18,98.22 139.72,97.76 138.83,97.76 137.82,98.77 133.77,98.77 133.56,98.98 131.53,98.98 130.37,97.82 130.37,87.21 129.92,86.76 129.34,86.76 128.34,85.75 128.34,84.61 127.7,83.98 127.7,81.44 128.39,80.75 128.39,77.57 129.48,76.48 129.48,74.94 128.98,74.44 127.83,74.44 126.82,73.42 126.82,71.29 127.01,71.09 127.01,68.64 v1(124.56,66.18)
  BOTTOM w0.14: PR701.2 123.85,65.4 124.56,66.11 v1(124.56,66.18) 124.56,66.19 PU12.6 ; Q7858.3 148.48,99.69 v1(148.64,99.53)
I2CC_SDA_GFX: length 23.1
  TOP w0.112: U13114.BH9 v2(149.21,115.96)
  IN1 w0.089: v2(149.21,115.96) 149.47,115.7 149.47,113.62 149.09,113.25 149.09,107.82 149.56,107.35 149.56,104.68 149.88,104.36 150.26,104.36 150.49,104.13 150.49,102.79 151.56,101.72 151.85,101.72 v1(152.17,101.41)
  BOTTOM w0.14: R21570.2 152.02,101.56 v1(152.17,101.41) 152.17,98.59 151.75,98.18 151.25,98.18 150.89,98.54 Q7860.1
I2CC_SDA_IPC: length 66.1
  IN3 w0.079: v1(123.9,66.16) 124.31,65.75 124.77,65.75 127.47,68.45 127.47,71.35 127.3,71.52 127.3,73.26 128.02,73.98 129.17,73.98 129.94,74.75 129.94,76.67 128.85,77.76 128.85,80.94 128.16,81.63 128.16,83.79 128.8,84.42 128.8,85.56 129.47,86.24 130.11,86.24 130.83,86.96 130.83,97.63 131.72,98.52 133.37,98.52 133.58,98.31 137.62,98.31 138.64,97.3 139.91,97.3 140.37,97.76 150.01,97.76 150.9,98.64 v1(151.53,98.64)
  BOTTOM w0.14: Q7860.6 150.89,99.92 151.53,99.28 v1(151.53,98.64) ; PR706.2 PR702.2 123.47,66.59 v1(123.9,66.16) 123.9,66.42 v1(124.3,66.82) 124.32,66.84 PU12.7
ICMNT: length 150.7
  TOP w0.14: v1(189.17,57.45) 189.17,55.92 189.69,55.41 192.71,55.41 192.79,55.33 192.79,54.44 193.23,54 U49.67 ; PR67220.2 66.91,50.11 v1(66.82,50.11) 67.1,49.83 67.1,46.85 v1(66.16,45.91)
  IN3 w0.079: v1(189.17,57.45) 188.96,57.23 186.95,57.23 186.54,56.81 180.68,56.81 180.46,57.04 179.16,57.04 176.38,54.26 172.2,54.26 171.9,53.97 171.9,52.61 168.42,49.13 98.33,49.13 97.73,48.53 93.21,48.53 90.19,45.51 89.3,45.51 88.36,44.57 79.64,44.57 79,43.93 76.87,43.93 76.45,44.36 68.17,44.36 66.87,45.66 66.42,45.66 v1(66.16,45.91)
  BOTTOM w0.14: v1(189.17,57.45) 189.22,57.45 190.56,56.11 C574.2
  BOTTOM w0.203: PR32.1 67.28,50.63 67.07,50.84 66.75,50.84 PC37.2 66.67,50.56 66.82,50.41 v1(66.82,50.11)
IFPC_RSET: length 14
  TOP w0.127: 156.92,118.76 U13114.BD20
  TOP w0.14: R21531.2 152.17,108.7 154.29,110.83 154.99,110.83 155.37,111.21 155.37,111.3 156.92,112.85 156.92,118.76
IFPEF_RSET: length 21.1
  TOP w0.14: R21528.2 153.11,106.06 152.65,106.52 152.65,108.52 v1(154.45,110.32) ; v2(154.81,119.45) 154.47,119.11 U13114.BD17
  IN1 w0.089: v2(154.81,119.45) 154.81,120.46 153.97,121.3 153,121.3 152.62,120.92 152.62,112.15 v1(154.45,110.32)
ILIM_HI: length 2.4
  TOP w0.14: U13128.16 362.87,54.06 R21702.1 v1(362.61,55.15)
ILIM_LO: length 2.5
  TOP w0.14: v1(363.95,55.13) 363.61,54.8 R21703.2 363.37,54.08 U13128.15
IMVP8_TMP_FLT: length 46
  TOP w0.14: PR66925.1 229.64,149.19 229.51,149.32 v1(229.51,149.88)
  IN4 w0.203: v1(262.4,161) 261.89,161.51 259.89,161.51 259.25,162.14 257.2,162.14 255.57,163.77 244.46,163.77 240.09,159.4 238.59,159.4 229.51,150.32 v1(229.51,149.88)
  BOTTOM w0.203: PR66900.1 261.61,161.66 261.74,161.54 PR66893.1 262.4,161.16 v1(262.4,161) ; PR66900.1 PR66915.1 ; PR66900.1 PR66905.1 PR66946.1 PR66920.1
IMVP_PWRGD: length 276.5
  TOP w0.14: Q20.2 v1(213.89,141.19)
  TOP w0.203: PR66853.1 266.54,169.05 266.47,169.13 266.47,169.17 v1(266.44,169.2) 266.8,169.55 PR66851.1
  TOP w0.254: v1(316.17,44.95) 316.3,45.08 316.3,45.42 R21150.2 316.59,45.71 U13098.2 ; v1(298.72,45.61) 296.97,47.36 295.9,47.36 293.9,49.37 289.61,49.37 287.27,51.71 285.67,51.71 v1(284.25,53.13)
  IN5 w0.254: v1(266.44,169.2) 265.45,168.2 257,168.2 256.05,167.25 256.05,165.83 254.32,164.1 251.11,164.1 250.85,163.83 244.28,163.83 243.86,163.41 242.59,163.41 242.21,163.03 242.21,162.53 241.96,162.27 241.57,162.27 241.07,162.78 241.07,163.29 239.7,164.66 230.55,164.66 230.53,164.68 218.46,164.68 214.15,160.38 214.15,141.58 213.89,141.32 v1(213.89,141.19) 213.89,140.3 215.41,138.78 215.41,136.44 212.88,133.9 212.88,130.68 213.86,129.69 213.86,129.26 218.43,124.68 218.43,117.8 217.7,117.06 213.51,117.06 213.13,116.68 213.13,113.92 208.35,109.15 208.35,105.4 209.68,104.07 209.68,103.03 210.59,102.13 210.59,98.51 221.29,87.8 265.63,87.8 276.27,77.16 276.27,74.57 277.03,73.8 277.03,66.87 278.55,65.35 278.55,60.16 279.31,59.4 280.02,59.4 284.25,55.17 v1(284.25,53.13)
  BOTTOM w0.254: v1(298.72,45.61) 298.72,45.33 299.56,44.49 315.72,44.49 v1(316.17,44.95)
INA3221_THERM_ALERT: length 13
  BOTTOM w0.203: PR417.1 117.73,69.43 PR67226.1 118.01,69.35 PD102.1 119.99,69.98 120.87,69.98 122.11,71.21 125.24,71.21 126.6,69.85 v1(126.6,69.82) PU12.9
INA3221_WARN: length 13.2
  BOTTOM w0.203: PU12.8 124.79,67.49 124.58,67.69 124.58,68.44 125.55,69.41 125.55,70.39 125.08,70.87 122.84,70.87 v1(121.97,69.99) 121.52,69.99 PD101.1 119.96,68.43 PR416.1
INT_DP_AUXN: length 179.5
  TOP w0.14: v2(147.8,114.57) U13114.BL8 ; v1(250.21,162.27) 250.33,162.39 Q7903.6 250.4,162.99 C94740.2
  IN1 w0.089: v1(145.51,102.99) 145.65,103.13 145.65,103.31 145.56,103.39 144.62,103.39 144.04,103.98 144.04,107.41 144.93,108.3 144.93,109.29 147.8,112.16 147.8,113.78 148.2,114.18 148.2,114.74 148.11,114.83 148.03,114.82 148.03,114.82 v2(147.8,114.57)
  IN2 w0.089: v2(147.8,114.57) 147.96,114.74 148.24,114.74 148.69,114.29 148.69,111.98 149.22,111.45 150.7,111.45 152.42,109.72 161.72,109.72 162.05,109.39 166.05,109.39 166.76,108.68 171.14,108.68 172.64,107.18 172.64,106.01 173.35,105.3 174.31,105.3 179.55,110.53 188.97,110.53 190.2,109.31 205.63,109.31 210.46,114.14 210.46,129.71 211.3,130.55 211.3,158.62 216.81,164.13 229.16,164.13 229.65,164.62 236.66,164.62 237.88,163.4 246.42,163.4 247.44,162.37 247.9,162.37 248.91,162.37 249.32,162.78 249.7,162.78 v1(250.21,162.27)
  BOTTOM w0.14: v1(145.51,102.99) 145.18,102.66 R21530.2
INT_DP_AUXP: length 179.8
  TOP w0.14: v2(147.77,115.23) 147.84,115.23 U13114.BK8 ; v1(248.05,162.78) 247.84,162.99 Q7904.6 247.38,163.43 247.52,163.57 C94742.2
  IN1 w0.089: v2(147.77,115.23) 148.02,115 148.11,115 148.18,115 148.38,114.81 148.38,114.11 147.98,113.71 147.98,112.08 145.1,109.21 145.1,108.22 144.22,107.33 144.22,104.06 144.7,103.57 145.64,103.57 v1(146.22,102.99)
  IN2 w0.089: v1(248.05,162.78) 247.92,162.91 247.92,164.02 247.8,164.15 247.54,164.15 247.42,164.02 247.42,163.03 247.29,162.91 247.16,162.91 246.5,163.57 237.95,163.57 236.73,164.8 229.58,164.8 229.08,164.3 216.73,164.3 211.12,158.69 211.12,130.62 210.28,129.78 210.28,114.22 205.55,109.49 190.27,109.49 189.05,110.71 179.47,110.71 174.24,105.48 173.43,105.48 172.82,106.09 172.82,107.26 171.21,108.86 166.83,108.86 166.12,109.57 162.12,109.57 161.79,109.9 152.5,109.9 150.77,111.62 149.3,111.62 148.86,112.06 148.86,114.37 148.32,114.91 147.91,114.91 147.77,115.06 v2(147.77,115.23)
  BOTTOM w0.14: v1(146.22,102.99) 146.2,102.96 R21529.2
INT_EDP_AUXN: length 227.3
  TOP w0.14: v1(151.58,102.61) 151.58,102.81 151.53,102.86 151.53,103.09 150.9,103.72 R21535.2 ; U13114.BF11 149.91,117.36 v2(149.91,117.36)
  IN4 w0.089: v1(341.44,77.58) 341.17,77.31 341.17,76.86 339.12,74.81 339.12,74.71 337.13,72.71 336.57,72.71 335.37,71.52 333.51,71.52 333.14,71.14 331.31,71.14 331.09,71.37 330.12,71.37 329.91,71.16 328.81,71.16 325.09,74.88 323.63,74.88 320.82,77.7 308.54,77.7 307.49,78.75 302.14,78.75 300.89,80 298.93,80 298.32,80.61 297.79,80.61 296.54,81.86 295.22,81.86 294.26,82.82 289.64,82.82 288.48,83.99 284.23,83.99 283.41,84.8 282.11,86.1 282.11,86.71 276.76,92.06 223.47,92.06 222.79,92.74 211.87,92.74 211.48,93.13 210.06,93.13 209.57,93.62 207.01,93.62 206.52,93.13 197.07,93.13 196.64,92.7 174.03,92.7 171.24,95.48 159,95.48 153.22,101.26 153.22,101.91 152.67,102.45 152.06,102.45 151.91,102.61 v1(151.58,102.61) 151.58,102.94 151.48,103.04 151.48,106.57 151.97,107.06 151.97,107.43 151.66,107.74 151.33,107.74 150.95,108.12 150.95,111.8 151.4,112.26 151.4,113.96 151.05,114.32 151.05,114.75 150.74,115.05 150.74,117.14 150.34,117.54 150.09,117.54 v2(149.91,117.36)
  BOTTOM w0.14: v1(341.44,77.58) 341.4,77.62 C94697.1
INT_EDP_AUXP: length 226.3
  TOP w0.14: v1(152.04,103.08) 152.04,103.34 R21534.2 ; U13114.BE11 149.91,118.06 v2(149.91,118.06)
  IN4 w0.089: v1(340.76,77.56) 340.99,77.33 340.99,76.93 338.94,74.89 338.94,74.78 337.06,72.89 336.49,72.89 335.3,71.7 333.44,71.7 333.06,71.32 331.38,71.32 331.16,71.54 330.04,71.54 329.84,71.34 328.89,71.34 325.16,75.06 323.7,75.06 320.89,77.87 308.62,77.87 307.56,78.93 302.21,78.93 300.96,80.18 299,80.18 298.39,80.79 297.86,80.79 296.62,82.03 295.3,82.03 294.33,83 289.72,83 288.55,84.16 284.3,84.16 283.53,84.93 282.29,86.17 282.29,86.78 276.83,92.24 223.54,92.24 222.86,92.92 211.94,92.92 211.56,93.3 210.13,93.3 209.64,93.79 206.94,93.79 206.45,93.3 196.99,93.3 196.56,92.87 174.11,92.87 171.32,95.66 159.08,95.66 153.4,101.34 153.4,101.98 152.74,102.63 152.14,102.63 152.04,102.73 152.04,103.08 v1(152.04,103.08) 151.7,103.08 151.66,103.12 151.66,106.5 152.15,106.99 152.15,107.5 151.73,107.92 151.4,107.92 151.12,108.2 151.12,111.73 151.58,112.19 151.58,114.03 151.23,114.39 151.23,114.82 150.92,115.13 150.92,117.21 150.42,117.72 150.01,117.72 149.91,117.82 v2(149.91,118.06)
  BOTTOM w0.14: C94698.1 340.51,77.82 v1(340.76,77.56)
INT_EDP_TXN0: length 202.2
  TOP w0.14: v1(154.6,112.74) 154.55,112.79 154.55,113.42 U13114.BM17 ; v1(329.46,76.86) 329.57,76.98 329.95,76.98 C94659.1
  IN4 w0.089: v1(329.46,76.86) 329.62,77.03 329.89,77.03 330.17,77.31 330.17,77.87 329.61,78.43 328.97,78.43 326.18,81.22 314.77,81.22 314.55,81.45 313.53,81.45 313.38,81.3 312.14,81.3 310.87,82.57 307.94,82.57 307.49,83.02 303.27,83.02 302.28,84.01 301.29,84.01 300.93,84.37 298.78,84.37 297.9,85.25 296.89,85.25 296.01,86.12 294.51,86.12 294.25,86.38 291.66,86.38 291.29,86.75 286.38,86.75 277.06,96.08 226.67,96.08 226.13,95.55 215.89,95.55 214.01,97.43 210.46,97.43 209.24,98.64 203.14,98.64 202.56,98.06 196.9,98.06 194.31,95.47 175.17,95.47 172.39,98.25 163.48,98.25 158.84,102.89 157.96,102.89 157.55,103.29 157.55,108.3 156.61,109.24 156.61,112.85 156.29,113.17 155.9,113.17 155.56,113.52 155.01,113.52 154.76,113.26 154.76,112.89 v1(154.6,112.74)
INT_EDP_TXN0_R: length 2.1
  TOP w0.14: C94659.2 330.81,77.04 330.93,77.04 331.6,76.36 331.81,76.36 331.85,76.32 U13079.10
INT_EDP_TXN1: length 203.2
  TOP w0.102: 153.8,112.79 153.8,112.82 153.86,112.88 153.86,113.67 154.15,113.96 154.15,114.33 154.46,114.64 U13114.BK17
  TOP w0.14: v1(154.25,111.4) 154.43,111.57 154.43,111.81 153.8,112.44 153.8,112.79 ; C94671.1 329.9,75.37 329.67,75.37 v1(329.43,75.14)
  IN4 w0.089: v1(329.43,75.14) 329.14,75.43 328.93,75.43 328.57,75.79 328.57,76.67 328.21,77.03 328.21,77.72 325.55,80.38 315.31,80.38 315.13,80.2 313.61,80.2 313.43,80.38 311.83,80.38 311.22,81 310.58,81 309.88,81.7 308.93,81.7 308.23,81 307.86,81 307.31,81.55 307.31,81.81 307.06,82.06 302.74,82.06 301.74,83.06 298.92,83.06 297.56,84.42 296.36,84.42 295.59,85.2 291.51,85.2 290.78,85.93 286.04,85.93 277.25,94.72 215.33,94.72 213.48,96.56 209.82,96.56 209.59,96.79 197.45,96.79 195.3,94.64 174.84,94.64 172.05,97.43 163.09,97.43 158.49,102.02 157.65,102.02 156.64,103.04 155.67,103.04 154.53,104.18 154.53,109.39 154.91,109.77 154.91,110.51 154.53,110.89 154.53,111.12 v1(154.25,111.4)
INT_EDP_TXN1_R: length 1.9
  TOP w0.14: U13079.13 331.82,75.11 331.78,75.16 331.13,75.16 330.9,75.38 330.8,75.38 C94671.2
INT_EDP_TXN2: length 204.4
  TOP w0.102: 153.12,112.53 153.12,112.55 153.17,112.61 153.17,113 153.39,113.21 153.39,113.78 153.25,113.91 153.25,114.16 153.2,114.21 U13114.BL15
  TOP w0.14: C94669.1 329.87,73.75 329.64,73.75 v1(329.43,73.54) ; v1(152.57,110.71) 152.81,110.95 152.81,111.55 153.12,111.86 153.12,112.53
  IN4 w0.089: v1(329.43,73.54) 329.43,73.68 329.25,73.85 328.92,73.85 328.26,74.51 328.26,74.95 327.86,75.36 327.86,76.4 325.12,79.14 315.29,79.14 314.88,79.54 313.28,79.54 313.1,79.72 310.89,79.72 309.57,81.04 309.21,81.04 308.45,80.27 307.51,80.27 306.74,81.04 302.47,81.04 301.23,82.29 298.47,82.29 297.48,83.28 296.56,83.28 295.32,84.52 291.27,84.52 290.51,85.28 285.67,85.28 277.35,93.61 224.06,93.61 223.59,94.07 214.88,94.07 213.05,95.9 209.9,95.9 209.29,95.29 197.22,95.29 195.92,93.99 174.57,93.99 171.78,96.78 162.8,96.78 158.95,100.63 155.78,100.63 155.16,101.24 155.16,101.79 153.52,103.44 153.52,109.36 152.93,109.95 152.93,110.45 152.66,110.71 v1(152.57,110.71)
INT_EDP_TXN2_R: length 1.9
  TOP w0.14: U13079.16 331.82,73.92 331.78,73.96 331.26,73.96 331.03,73.73 330.8,73.73 C94669.2
INT_EDP_TXN3: length 204.9
  TOP w0.14: U13114.BM14 152.42,113.45 152.42,112.53 151.26,111.37 151.26,110.8 150.83,110.37 150.83,109.56 151.09,109.3 151.44,109.3 v1(151.68,109.06) ; C94657.1 329.94,72.03 329.6,72.03 v1(329.41,71.84)
  IN4 w0.089: v1(151.68,109.06) 151.86,109.24 152.17,109.24 152.72,108.68 152.72,103.32 153.87,102.17 153.87,101.53 159.27,96.13 171.51,96.13 174.3,93.34 196.34,93.34 197.63,94.63 209.67,94.63 210.25,95.22 212.49,95.22 214.32,93.39 223.06,93.39 223.61,92.83 277.13,92.83 285.33,84.63 288.91,84.63 289.68,83.86 291.69,83.86 291.91,83.65 294.52,83.65 295.58,82.59 297.25,82.59 299.16,80.69 301.73,80.69 302.16,80.26 306.61,80.26 307.24,79.63 309.36,79.63 310.64,78.35 321.3,78.35 324.12,75.53 325.36,75.53 328.94,71.95 329.29,71.95 v1(329.41,71.84)
INT_EDP_TXN3_R: length 2.1
  TOP w0.14: C94657.2 330.8,72.08 331.01,72.08 331.69,72.76 331.78,72.76 331.82,72.71 U13079.19
INT_EDP_TXP0: length 202.2
  TOP w0.14: C94655.1 329.85,77.29 329.65,77.29 329.46,77.49 v1(329.46,77.54) ; U13114.BM18 154.92,113.51 154.79,113.39 154.79,113.18 155.18,112.79 v1(155.29,112.79)
  IN4 w0.089: v1(329.46,77.54) 329.46,77.39 329.64,77.21 329.82,77.21 329.99,77.38 329.99,77.79 329.53,78.25 328.9,78.25 326.11,81.04 314.7,81.04 314.47,81.27 313.61,81.27 313.46,81.12 312.06,81.12 310.79,82.39 307.87,82.39 307.41,82.85 303.2,82.85 302.21,83.84 301.21,83.84 300.86,84.19 298.7,84.19 297.83,85.07 296.81,85.07 295.94,85.94 294.43,85.94 294.17,86.21 291.59,86.21 291.22,86.58 286.31,86.58 276.98,95.9 226.74,95.9 226.21,95.37 215.82,95.37 213.94,97.25 210.39,97.25 209.17,98.47 203.22,98.47 202.63,97.88 196.97,97.88 194.38,95.29 175.1,95.29 172.32,98.07 163.41,98.07 158.77,102.71 157.88,102.71 157.37,103.22 157.37,108.22 156.43,109.16 156.43,112.78 156.21,113 155.83,113 155.48,113.34 155.09,113.34 154.93,113.19 154.93,112.95 155.09,112.79 v1(155.29,112.79)
INT_EDP_TXP0_R: length 2.1
  TOP w0.14: C94655.2 330.78,77.35 331.06,77.35 331.74,76.67 331.81,76.67 331.85,76.71 U13079.9
INT_EDP_TXP1: length 203.2
  TOP w0.102: 154.12,112.79 154.12,112.82 154.06,112.88 154.06,113.58 154.33,113.86 154.68,113.86 154.81,113.99 154.81,114.39 154.74,114.47 154.57,114.47 154.46,114.36 U13114.BL17
  TOP w0.14: 154.12,112.79 154.12,112.57 154.74,111.94 154.74,111.59 v1(154.92,111.41) ; v1(329.43,75.94) 329.68,75.69 329.9,75.69 C94670.1
  IN4 w0.089: v1(154.92,111.41) 154.71,111.2 154.71,110.96 155.09,110.58 155.09,109.69 154.71,109.31 154.71,104.26 155.75,103.22 156.71,103.22 157.73,102.2 158.56,102.2 163.16,97.6 172.12,97.6 174.91,94.82 195.23,94.82 197.38,96.97 209.67,96.97 209.9,96.74 213.56,96.74 215.4,94.9 277.32,94.9 286.11,86.11 290.85,86.11 291.59,85.37 295.66,85.37 296.44,84.6 297.63,84.6 298.99,83.24 301.81,83.24 302.81,82.24 307.13,82.24 307.49,81.88 307.49,81.63 307.94,81.18 308.16,81.18 308.86,81.88 309.95,81.88 310.66,81.18 311.29,81.18 311.91,80.56 313.5,80.56 313.68,80.38 315.06,80.38 315.24,80.56 325.62,80.56 328.39,77.79 328.39,77.1 328.75,76.75 328.75,75.86 329,75.61 329.1,75.61 v1(329.43,75.94)
INT_EDP_TXP1_R: length 1.9
  TOP w0.14: U13079.12 331.82,75.51 331.78,75.47 331.26,75.47 331.03,75.7 330.78,75.7 C94670.2
INT_EDP_TXP2: length 204.5
  TOP w0.102: U13114.BK15 153.06,114.64 153.45,114.25 153.45,113.99 153.59,113.86 153.59,113.12 153.38,112.91 153.38,112.62 153.44,112.56 153.44,112.54
  TOP w0.14: 153.44,112.54 153.44,111.73 153.13,111.42 153.13,110.79 v1(153.23,110.68) ; v1(329.43,74.21) 329.58,74.06 329.92,74.06 C94668.1
  IN4 w0.089: v1(329.43,74.21) 329.25,74.03 329,74.03 328.44,74.59 328.44,75.02 328.04,75.43 328.04,76.47 325.19,79.32 315.36,79.32 314.95,79.72 313.35,79.72 313.17,79.9 310.97,79.9 309.65,81.22 309.14,81.22 308.37,80.45 307.58,80.45 306.81,81.22 302.54,81.22 301.3,82.46 298.55,82.46 297.55,83.46 296.64,83.46 295.4,84.7 291.34,84.7 290.59,85.46 285.75,85.46 277.42,93.79 224.13,93.79 223.67,94.25 214.95,94.25 213.12,96.08 209.82,96.08 209.21,95.47 197.15,95.47 195.85,94.17 174.64,94.17 171.86,96.96 162.87,96.96 159.02,100.8 155.85,100.8 155.34,101.31 155.34,101.87 153.7,103.51 153.7,109.43 153.11,110.02 153.11,110.56 v1(153.23,110.68)
INT_EDP_TXP2_R: length 1.9
  TOP w0.14: U13079.15 331.82,74.32 331.78,74.27 331.13,74.27 330.9,74.05 330.79,74.05 C94668.2
INT_EDP_TXP3: length 204.9
  TOP w0.14: U13114.BM15 152.81,113.51 152.74,113.44 152.74,112.4 151.58,111.24 151.58,110.67 151.15,110.24 151.15,109.77 151.3,109.62 151.48,109.62 v1(151.68,109.82) ; C94656.1 329.86,72.34 329.6,72.34 v1(329.41,72.53)
  IN4 w0.089: v1(329.41,72.53) 329.41,72.41 329.13,72.13 329.01,72.13 325.43,75.71 324.2,75.71 321.38,78.53 310.71,78.53 309.43,79.8 307.31,79.8 306.68,80.43 302.24,80.43 301.8,80.86 299.23,80.86 297.33,82.77 295.65,82.77 294.6,83.82 291.98,83.82 291.76,84.04 289.76,84.04 288.99,84.81 285.4,84.81 277.2,93.01 223.68,93.01 223.13,93.56 214.4,93.56 212.57,95.39 210.18,95.39 209.6,94.81 197.56,94.81 196.27,93.52 174.37,93.52 171.59,96.31 159.34,96.31 154.05,101.61 154.05,102.25 152.9,103.39 152.9,108.75 152.24,109.41 152.09,109.41 v1(151.68,109.82)
INT_EDP_TXP3_R: length 2.1
  TOP w0.14: C94656.2 330.79,72.39 330.88,72.39 331.56,73.07 331.78,73.07 331.82,73.11 U13079.18
INT_ULT_EDP_HPD: length 9.2
  TOP w0.14: v1(337.13,73.51) U13079.32
  BOTTOM w0.14: R20923.1 338.65,74.58 338.38,74.31 R67248.1 337.92,74.31 v1(337.13,73.51) 337.12,73.51 v1(336.42,72.81) 336.16,72.56 335.53,72.56 335.05,72.08 335.05,70.45 335.24,70.25 335.24,69.61 334.9,69.27 R20918.2
IRQ_SERIRQ: length 170.2
  TOP w0.112: v2(310.51,60.06) 310.61,60.06 311.17,60.61 U13113.BA17
  TOP w0.14: v1(180.41,63.69) 180.36,63.75 179.75,63.75 179.49,64 U49.5
  IN2 w0.089: v2(310.51,60.06) 310.51,59.68 310.79,59.4 313.71,59.4 313.91,59.61 316.25,59.61 v1(316.78,59.07)
  IN3 w0.079: v1(180.41,63.69) 180.52,63.69 182.16,62.06 183.46,62.06 184.13,61.38 185.08,61.38 187.6,63.9 190.88,63.9 191.37,64.39 195.18,64.39 195.51,64.06 195.81,64.06 196.07,64.33 196.07,65.43 197.75,67.11 198.28,67.11 198.85,66.54 202.43,66.54 204.97,69.08 204.97,71.13 210.02,76.17 210.02,76.95 214.07,81.01 275.09,81.01 279.51,76.58 279.51,75.24 281.2,73.56 281.2,69.82 279.52,68.14 279.52,66.5 282.2,63.82 291,63.82 292.88,61.94 305.33,61.94 306.34,60.93 306.85,60.93 307.69,60.09 307.69,59.83 307.83,59.69 310.14,59.69 v2(310.51,60.06)
  BOTTOM w0.14: R21088.1 317.32,59.76 316.78,59.22 v1(316.78,59.07)
JTAG_SEL: length 6.4
  TOP w0.127: 158.31,114.57 U13114.BK23
  TOP w0.14: TP13111.1 155.19,110.63 155.65,111.09 155.65,111.15 158.31,113.81 158.31,114.57
JTAG_TCK: length 9.1
  TOP w0.127: U13114.BK24 159.36,114.68 159.7,114.34 159.7,114.07 159.94,113.83 159.94,113.19
  TOP w0.14: R21586.2 156.36,107.82 157.23,108.69 157.23,110.64 158.8,112.21 158.95,112.21 159.94,113.19
JTAG_TCK_PCH: length 5.1
  TOP w0.112: U13113.AN3 307.69,53.49 307.69,53.28 307.85,53.11
  TOP w0.127: 307.85,53.11 307.85,52.56 308.18,52.23 308.18,50.58
  TOP w0.14: 308.18,50.58 309.16,49.6 R21121.1
JTAG_TDI: length 9.4
  TOP w0.14: U13114.BM23 158.41,113.51 155.93,111.03 155.93,110.97 155.72,110.77 155.72,109.31 155.49,109.08 154.27,109.08 v1(153.21,108.02) 153.13,107.94 R21584.2
JTAG_TDI_PCH: length 8
  TOP w0.127: U13113.AP2 308.64,52.73 308.64,51.27 310.2,49.71
  TOP w0.14: 310.2,49.71 310.63,49.71 310.99,49.34 R21119.1 310.84,49.21 310.53,48.91 310.53,47.23 R21110.2
JTAG_TDO: length 4.7
  TOP w0.127: U13114.BM24 159.36,113.33 158.9,112.87 158.89,112.87
  TOP w0.14: TP13110.1 156.48,110.74 158.57,112.82 158.84,112.82 158.89,112.87
JTAG_TDO_PCH: length 6.5
  TOP w0.127: 308.5,51.02 308.41,51.12 308.41,52.37 308.1,52.68 U13113.AP1
  TOP w0.14: 308.5,51.02 309.57,49.95 310.05,49.47 R21120.1 309.91,49.21 309.59,48.89 309.59,47.59 309.65,47.53 R21111.2
JTAG_TMS: length 9.5
  TOP w0.127: 159.02,113.35 159.02,113.85 U13114.BL23
  TOP w0.14: R21583.2 154.1,107.56 v1(154.58,108.04) 155.18,108.64 155.54,108.64 156,109.11 156,110.65 156.21,110.86 156.21,110.89 158.44,113.12 158.79,113.12 159.02,113.35
JTAG_TMS_PCH: length 8.5
  TOP w0.127: 310.46,49.95 308.87,51.55 308.87,52.89 308.72,53.04 U13113.AR2
  TOP w0.14: R21109.2 311.47,47.3 311.47,49.03 311.65,49.21 R21118.1 311.93,49.62 311.72,49.83 311.26,49.83 311.15,49.95 310.46,49.95
JTAG_TRST#: length 10.3
  TOP w0.127: 159.69,113.31 159.69,113.74 159.36,114.08 U13114.BL24
  TOP w0.14: 159.69,113.31 158.92,112.54 158.72,112.54 156.95,110.77 156.95,109.4 155.06,107.51 R21585.2 155.22,107.3 155.82,106.7 v1(155.82,106.52)
KB_LED_A0: length 5.7
  TOP w0.14: v1(269.82,49.6) 269.59,49.37 268.64,49.37 R21058.2 R21059.2 266.25,49.42 265.63,49.42 265.57,49.48 U13093.31
KB_LED_A1: length 7.3
  TOP w0.14: R21060.2 R21061.2 266.73,52.03 266.36,52.39 265.35,52.39 265.09,52.14 v1(265.09,51.45) 265.09,51.35 265.3,51.15 265.3,50.13 265.14,49.98 U13093.32
KB_PWR_EN: length 69.1
  TOP w0.14: v1(175.69,58.39) 175.69,59.27 176.32,59.91 R67306.1
  IN5 w0.089: v1(175.69,58.39) 175.17,58.39 171.88,55.1 170.01,55.1 168.82,53.9 155.82,53.9 155.14,54.58 141.71,54.58 140.92,55.37 126.75,55.37 126.54,55.17 125.42,55.17 125.42,55.16 123.06,55.16 122.28,55.95 119.37,55.95 v1(118.94,55.52)
  BOTTOM w0.14: U13158.3 121.97,59.33 121.86,59.22 C96273.2 121.66,59.53 121.55,59.64 120.83,59.64 119.79,58.6 119.79,57.51 118.94,56.66 v1(118.94,55.52)
L_SPK+: length 16.9
  IN2 w1.016: 20.96,12.05 22.1,13.19 22.95,13.19 24.63,14.88 24.63,17.14 25.14,17.64 25.14,19.4 27.91,22.17 27.91,22.93 29.28,24.3 29.28,24.98 ; 29.26,25.16 29.28,25.19
  vias: v1(19.89,10.71) v1(20.5,10.96) v1(20.62,11.7) v1(29.64,26.86) v1(29.64,26.2)
L_SPK-: length 15.1
  IN2 w1.016: 24.17,12.51 24.37,12.51 26.41,14.56 26.41,18.87 29.18,21.64 29.18,22.39 30.55,23.77 30.55,24.89
  vias: v1(21.27,10.74) v1(21.77,11.16) v1(30.25,25.9) v1(30.25,26.56)
LAN_DEBUGMODE: length 4
  TOP w0.14: U13143.5 350.21,68.11 350.29,68.03 350.29,67.53 349.56,66.8 R67304.2 349.56,66.24 350.13,65.67 v1(350.13,65.3)
LAN_MCT0: length 4.8
  TOP w0.61: v1(369.84,76.5) U13112.24 v1(366.59,76.5)
  BOTTOM w0.762: v1(366.59,76.5) 366.04,75.95 R21492.1
LAN_MCT1: length 5.1
  TOP w0.61: v1(366.54,73.5) U13112.21 369.46,73.5 v1(369.87,73.91)
  BOTTOM w0.762: v1(366.54,73.5) 366.04,73 R21495.1
LAN_MCT2: length 4.7
  TOP w0.61: v1(366.75,70.5) U13112.18 369.66,70.5 v1(370,70.83)
  BOTTOM w0.762: R21491.1 366.04,69.8 v1(366.75,70.5)
LAN_MCT3: length 5.1
  TOP w0.61: v1(366.64,68.29) 366.64,67.76 366.9,67.5 U13112.15 v1(369.82,67.5)
  BOTTOM w0.61: v1(366.64,68.29) 365.84,67.49 R21490.1
LAN_MX0+: length 12.7
  TOP w0.102: U13112.13 369.38,65.5 369.71,65.83 370.1,65.83 371.95,67.68 371.95,71.09 v1(372.48,71.61) 371.95,72.14 371.95,74.26 372.32,74.63 CN2061.1
LAN_MX0-: length 12.7
  TOP w0.102: U13112.14 369.38,66.5 369.77,66.11 369.98,66.11 371.67,67.79 371.67,71.08 v1(371.14,71.61) 371.67,72.14 371.67,74.37 372.03,74.73 372.03,75.49 CN2061.2
LAN_MX1+: length 13.4
  TOP w0.102: U13112.16 369.42,68.5 369.59,68.67 369.59,68.88 369.69,68.98 369.9,68.98 v1(370.23,68.65)
  IN5 w0.089: v1(370.23,68.65) 370,68.88 370,69 370.09,69.09 370.72,69.09 370.99,69.36 370.99,76.67 371.19,76.88 372.75,76.88 CN2061.3
LAN_MX1-: length 13.4
  TOP w0.102: U13112.17 369.53,69.5 369.77,69.26 369.99,69.26 v1(370.23,69.5)
  IN5 w0.089: CN2061.6 370.99,78.83 370.99,77.05 370.72,76.78 370.72,69.47 370.61,69.36 370.38,69.36 v1(370.23,69.5)
LAN_MX2+: length 11.3
  TOP w0.102: v1(370.18,71.66) 369.9,71.95 369.72,71.95 369.27,71.5 U13112.19
  IN1 w0.089: CN2061.4 371.9,78.55 371.85,78.61 371.21,78.61 370.97,78.36 370.97,72.36 370.64,72.04 370.42,72.04 370.18,71.81 v1(370.18,71.66)
LAN_MX2-: length 11.3
  TOP w0.102: v1(370.18,72.52) 369.89,72.23 369.72,72.23 369.45,72.5 U13112.20
  IN1 w0.089: CN2061.5 372.1,78.73 372.04,78.79 371.96,78.87 371.1,78.87 370.7,78.47 370.7,72.47 370.53,72.31 370.4,72.31 v1(370.18,72.52)
LAN_MX3+: length 9.8
  TOP w0.102: CN2061.7 372,80.73 371.86,80.59 371.48,80.59 370.99,80.09 370.99,75.66 370,74.67 369.51,74.67 369.35,74.5 U13112.22
LAN_MX3-: length 9.8
  TOP w0.102: U13112.23 369.49,75.5 369.64,75.35 369.64,75.05 369.74,74.95 369.88,74.95 370.71,75.77 370.71,80.2 371.37,80.86 371.74,80.86 371.87,80.99 CN2061.8
LANVCC: length 22.7
  TOP w0.203: v1(342.21,73.78) 342.32,73.89 Q7849.2
  TOP w0.508: Q7848.2 v1(345.24,74.59) ; v1(343.05,74.54) 343.05,74.27 343.18,74.13 Q7849.2
  IN2 w0.508: v1(348.08,67.89) 347.86,67.67 345.17,67.67 344.99,67.49 342.36,67.49 341.66,68.2 341.66,72.2 342.46,73.01 342.46,73.78 343.05,74.36 v1(343.05,74.54) 343.51,74.54 344.17,73.88 344.86,73.88 345.24,74.26 v1(345.24,74.59)
  BOTTOM w0.254: R21484.1 345.31,74.52 v1(345.24,74.59) ; R67190.1 348.15,67.96 v1(348.08,67.89)
  BOTTOM w0.508: C94986.2 347.25,67.06 v1(348.08,67.89) ; R21486.1 343.17,74.16 343.05,74.28 v1(343.05,74.54)
LCD_BL_PWM: length 264.8
  TOP w0.14: U13114.BD7 v2(147.11,119.46)
  IN1 w0.089: v1(341.02,89.25) 340.74,89.25 338.63,87.14 337.56,87.14 336.46,86.03 335.25,86.03 333.93,84.7 332.26,84.7 331.47,83.91 330.86,83.91 328.96,82.01 317.65,82.01 317.39,81.75 313.84,81.75 313.35,81.27 310.21,81.27 310.08,81.4 308.81,81.4 308.68,81.27 307.85,81.27 307.49,81.63 307.49,82.03 307.09,82.43 286.92,82.43 285.05,80.56 v1(281.58,80.56) ; v2(147.11,119.46) 146.5,118.85 141.78,118.85 141.32,119.31 140.44,119.31 139.72,118.59 139.72,118.12 140.36,117.48 140.98,117.48 141.45,117 141.45,114.29 141.02,113.86 141.02,112.36 142.3,111.08 142.3,108.23 142.63,107.9 142.63,103.57 142.28,103.23 142.28,102.87 142.83,102.32 143.15,102.32 143.38,102.09 143.93,102.09 145.16,100.87 146.55,100.87 146.72,100.7 149.39,100.7 149.7,101.02 152.2,101.02 157.78,95.44 201.47,95.44 202.71,94.2 202.71,93.31 200.43,91.02 200.43,85.56 v1(200.17,85.31)
  IN4 w0.089: v1(281.58,80.56) 281.09,80.56 274.68,86.96 220.11,86.96 219.3,87.77 207.71,87.77 205.08,85.14 200.34,85.14 v1(200.17,85.31)
  BOTTOM w0.127: 147.1,119.46 v2(147.11,119.46)
  BOTTOM w0.14: 147.1,119.46 146.3,118.66 144.72,118.66 144.54,118.84 143.78,118.84 143.71,118.76 141.83,118.76 140.78,117.71 138.94,117.71 138.81,117.85 137.69,117.85 137.54,117.69 137.54,117.39 137.41,117.26 R21575.1 ; v1(341.02,89.25) 341.02,87.85 340.76,87.6 340.76,86.97 340.63,86.83 Q7820.2
LCD_BLEN: length 258.5
  TOP w0.14: U13114.BB1 141.9,120.51 141.63,120.23 v1(140.36,120.23) 139.52,119.4 R21579.2
  IN1 w0.089: v1(354.51,94.64) 353.97,94.1 353.65,94.1 352.93,93.37 344.2,93.37 342.15,91.32 341.86,91.32 340.99,90.44 340.76,90.44 338.83,88.51 338.58,88.51 338.12,88.05 337.43,88.05 336.27,86.88 335.13,86.88 333.64,85.39 331.75,85.39 331.29,84.93 330.54,84.93 328.34,82.73 307.82,82.73 307.44,83.11 294.85,83.11 293.9,84.07 286.86,84.07 284.8,82 284.8,81.75 284.54,81.49 280.93,81.49 v1(280.79,81.63) ; v1(141.32,100.83) 141.57,101.08 141.57,107.33 140.9,108 140.9,110.06 139.16,111.8 139.16,114.02 139.51,114.36 140.38,114.36 141.11,115.09 141.11,116.86 140.84,117.13 140.21,117.13 139.37,117.97 139.37,118.84 140.36,119.82 v1(140.36,120.23)
  IN4 w0.089: v1(141.32,100.83) 142.44,99.71 147.25,99.71 147.81,99.15 148.97,99.15 149.69,98.43 150.28,98.43 156.98,91.73 169.36,91.73 174.61,86.48 182.99,86.48 183.25,86.75 200.1,86.75 201.35,85.49 204.94,85.49 207.6,88.14 219.66,88.14 220.47,87.34 274.79,87.34 280.5,81.63 v1(280.79,81.63)
  BOTTOM w0.14: v1(354.51,94.64) 354.51,93.99 Q7823.2
LCD_VDD: length 226
  TOP w0.127: v2(144.31,115.96) 144.66,116.31 U13114.BH3
  TOP w0.14: v1(321.08,76.17) v1(321.08,74.87) 321.08,74.64 320.85,74.42 320.85,73.51 R20960.1
  IN1 w0.089: v1(321.08,76.17) 318.92,78.32 313.61,78.32 313.02,78.91 313.02,79.57 312.82,79.77 311.78,79.77 311.61,79.61 309.11,79.61 308.56,80.16 306.58,80.16 306,80.74 297.96,80.74 297.82,80.88 289.27,80.88 287.61,79.21 v1(282.98,79.21) ; v1(135.81,112.56) 135.85,112.56 141.23,107.19 141.23,101.42 140.83,101.02 v1(140.83,100.36)
  IN4 w0.089: v1(140.83,100.36) 141.21,99.98 141.21,99.18 142.12,98.26 148.88,98.26 149.4,97.74 150,97.74 156.72,91.02 169.1,91.02 174.33,85.8 183.27,85.8 183.54,86.06 197.2,86.06 198.84,84.42 205.4,84.42 207.73,86.75 218.87,86.75 219.68,85.93 274.74,85.93 281.46,79.21 v1(282.98,79.21)
  BOTTOM w0.14: R21578.2 133.62,112.23 134.34,112.95 135.43,112.95 v1(135.81,112.56) 136.28,113.04 136.99,113.04 138.38,114.42 141.65,114.42 142.43,115.21 143.2,115.21 143.5,115.51 143.86,115.51 v2(144.31,115.96)
LCDVCC: length 8.8
  TOP w0.508: v1(336.47,85.54) 335.52,85.54 334.84,84.87 333.99,84.87 333.93,84.8 333.39,84.8 333.34,84.75 Q7821.2
  IN4 w0.508: v1(337.05,81.07) 336.47,81.65 v1(336.47,85.54)
  vias: v1(327.2,74.77) v1(327.86,74.77) v1(337.71,81.07) v1(338.4,81.07) v1(348.81,94.2)
LCDVCC_R:
  vias: v1(337.89,77.46)
LED_A_B: length 13.9
  TOP w0.254: U13093.5 261.9,51.46 261.58,51.78 v1(261.58,51.81) ; CN2075.10 252.49,48.46 253.02,47.93 v1(253.08,47.93)
  BOTTOM w0.254: v1(261.58,51.81) 261.58,50.86 258.12,47.4 v1(254.15,47.4) 253.61,47.4 v1(253.08,47.93)
LED_A_G: length 17
  TOP w0.254: CN2075.11 252.99,49.25 252.99,50.73 252.95,50.77 v1(252.95,50.92) v1(252.95,51.65) ; U13093.4 262.4,51.81 v1(262.37,51.83)
  BOTTOM w0.254: v1(252.95,51.65) 252.95,50.36 254.07,49.24 258.29,49.24 259.7,50.65 259.7,52.05 259.98,52.33 261.82,52.33 262.31,51.83 v1(262.37,51.83)
LED_A_R: length 17.2
  TOP w0.254: CN2075.12 253.49,49.25 253.49,51.53 v1(253.61,51.65) ; v1(263.04,51.83) 262.9,51.69 U13093.3
  BOTTOM w0.254: v1(263.04,51.83) 263.04,51.9 262.58,52.37 262.39,52.37 262.03,52.72 259.81,52.72 259.3,52.21 259.3,50.81 258.15,49.66 254.21,49.66 253.61,50.25 v1(253.61,51.65)
LED_B1_SYS: length 1.6
  TOP w0.254: U13152.5 375.13,11.75 374.79,12.09 R67173.2
LED_B1_SYS_R: length 18.9
  TOP w0.254: v1(375.05,13.94) 374.79,13.68 R67173.1
  TOP w0.305: v1(379.64,18.84) 379.64,18.97 379.24,19.37 378.51,19.37 376.5,21.38 376.5,23.55 376.73,23.78 LED2.3
  IN1 w0.305: v1(375.05,13.94) 375.23,13.76 376.68,13.76 377.16,14.24 377.16,14.7 376.96,14.9 376.96,17.97 378,19.02 379.46,19.02 v1(379.64,18.84)
  BOTTOM w0.305: v1(379.64,18.84) 379.64,18.97 379.07,19.54 D13048.1
LED_B2_BAT: length 1.9
  TOP w0.127: U13152.9 372.16,10.22 v1(371.99,10.04)
  BOTTOM w0.127: R67169.2 372.44,9.58 v1(371.99,10.04)
LED_B2_BAT_R: length 36.4
  TOP w0.305: LED1.3 377.22,35.38 v1(376.65,35.96)
  IN1 w0.305: v1(371.98,10.71) 373.25,11.98 373.25,18.54 374.26,19.56 374.26,21.18 373.37,22.06 v1(373.37,22.07)
  IN5 w0.305: v1(376.65,35.96) 376.75,35.86 376.75,35.14 375.71,34.1 375.71,33.19 375,32.48 372.92,32.48 372.57,32.82 372.04,32.82 370.86,31.64 370.86,29.56 371.36,29.06 371.36,24.87 372.08,24.15 372.08,23.84 373.37,22.55 v1(373.37,22.07)
  BOTTOM w0.254: v1(371.98,10.71) 372.18,10.71 372.52,10.36 R67169.1
  BOTTOM w0.305: D13051.1 373.11,21.6 373.37,21.87 v1(373.37,22.07)
LED_B4_P_BTN: length 239.3
  TOP w0.254: v1(181.45,45.81) 181.46,45.82 D13055.1 182.31,46.6 ; v1(371.98,5.93) 372.12,6.07 372.14,6.07 372.38,6.31 373.43,6.31 373.63,6.11 U13152.17 ; 182.31,46.6 182.31,47 182.65,47.35 186.82,47.35 187.24,47.77 187.24,47.8 187.35,47.9 CN2071.5 ; 182.31,46.6 v1(182.29,46.57)
  IN3 w0.254: v1(371.98,5.93) 372.02,5.93 373.14,7.05 373.14,7.09 373.15,7.1 373.15,15.71 370.59,18.27 370.29,18.27 369.21,19.35 367.2,19.35 366.92,19.63 366.92,20.41 365.99,21.35 365.99,24.6 365.02,25.57 365.02,28.18 364.35,28.86 364.35,33.72 361.76,36.31 361.42,36.31 361.23,36.49 360.86,36.49 358.85,38.5 358.85,40.28 357.48,41.66 357.48,43.86 355.76,45.58 347.1,45.58 346.71,45.18 342.01,45.18 338.23,48.97 330.36,48.97 329.56,48.17 324.85,48.17 322.52,45.84 313.82,45.84 313.13,45.15 289.13,45.15 286.45,47.83 269.12,47.83 268.12,46.83 267.1,46.83 266.75,46.47 256,46.47 255.59,46.07 246.38,46.07 245.7,45.38 195.56,45.38 195,45.94 182.93,45.94 v1(182.29,46.57)
LED_B5_GPU_FAN: length 1.6
  TOP w0.254: U13152.22 376.13,5.29 v1(376.27,5.15)
  BOTTOM w0.254: R67031.2 376.26,5.16 v1(376.27,5.15)
LED_B5_GPU_FAN_R: length 468
  TOP w0.254: CN2077.4 85.32,76.3 v1(86.02,77) 86.94,77.92 v1(86.94,78.32)
  IN3 w0.254: v1(43.91,47.24) 44.37,46.78 45.66,46.78 46.65,45.79 48.74,45.79 49.52,45 51.12,45 51.33,45.2 51.81,45.2 52.22,44.8 52.22,43.86 53.31,42.76 58.92,42.76 59.23,42.46 61.35,42.46 62.06,41.75 62.88,41.75 62.88,41.74 64.08,41.74 65.3,40.52 68.62,40.52 69.3,39.84 76.4,39.84 78.96,42.41 79.55,42.41 80.48,43.34 88.84,43.34 89.73,44.24 90.55,44.24 93.7,47.38 98.46,47.38 98.92,47.85 172.52,47.85 178.02,53.35 179.7,53.35 180.21,53.86 183.2,53.86 183.68,54.34 190.37,54.34 191.4,53.3 192.84,53.3 194.08,52.06 197.75,52.06 198.3,51.5 199.05,51.5 199.31,51.25 203.32,51.25 203.45,51.38 229,51.38 229.31,51.07 239.67,51.07 240.43,50.31 267.04,50.31 267.11,50.24 268.51,50.24 269.51,49.24 287.05,49.24 289.29,47 313.12,47 313.71,47.59 313.71,47.72 314.22,48.23 314.35,48.23 314.85,48.73 315.49,48.73 316.48,47.74 321.78,47.74 322.71,48.67 324.32,48.67 325.4,49.75 328.48,49.75 328.93,49.3 338.36,49.3 339.53,48.14 353.49,48.14 353.97,47.67 353.97,46.89 354.73,46.13 355.68,46.13 357.81,44 357.81,41.8 359.18,40.43 359.18,39.48 359.63,39.03 361.54,39.03 361.97,38.6 361.97,37.81 362.33,37.45 362.33,36.22 364.69,33.85 364.69,29 365.02,28.67 365.47,28.67 365.99,28.15 365.99,25.29 367.61,23.66 367.61,20.81 368.7,19.73 369.31,19.73 370.3,18.74 370.61,18.74 373.5,15.84 373.5,6.93 372.53,5.96 372.53,5.57 v1(372.43,5.47)
  BOTTOM w0.254: v1(372.43,5.47) 372.5,5.53 372.5,5.92 373.84,7.26 375.5,7.26 376.41,6.35 376.85,6.35 377.04,6.16 R67031.1 ; v1(43.91,47.24) 44.27,47.59 44.27,52.75 42.6,54.41 42.6,59.54 45.3,62.23 45.3,67.67 44.57,68.4 44.57,70.5 44.99,70.92 44.99,76.61 48.94,80.56 60.32,80.56 62.17,78.71 76.7,78.71 78.54,80.55 85.02,80.55 86.94,78.63 v1(86.94,78.32) 86.94,77.71 D13058.1
LED_B_B: length 12.6
  TOP w0.254: U13093.9 257.27,49.98 256.31,50.94 256.31,51.93 255.99,52.25 251.96,52.25 250.99,51.29 v1(250.99,50.92) 250.99,49.25 CN2075.7
LED_B_G: length 13.7
  TOP w0.254: CN2075.8 251.49,47.96 v1(251.45,47.92) ; U13093.8 260.4,51.37 260.22,51.55 v1(260.22,51.78)
  BOTTOM w0.254: v1(251.45,47.92) 252.52,48.99 v1(253.05,48.99) 253.19,48.85 258.45,48.85 260.22,50.61 v1(260.22,51.78)
LED_B_R: length 13.6
  TOP w0.254: U13093.6 261.4,51.2 260.9,51.69 v1(260.9,51.81) ; v1(252.27,47.91) 251.99,48.19 CN2075.9
  BOTTOM w0.254: v1(260.9,51.81) 260.9,50.74 258.62,48.45 252.81,48.45 v1(252.27,47.91)
LED_C_B: length 14.1
  TOP w0.254: CN2075.4 249.49,49.24 249.49,47.9 251.96,45.43 257.3,45.43 257.53,45.66 257.53,46.88 v1(258.08,47.44) 258.12,47.48 U13093.14
LED_C_G: length 12.2
  TOP w0.254: CN2075.5 249.99,49.24 249.99,47.96 250.96,46.99 254.08,46.99 255.92,48.83 v1(258.19,48.83) 259.03,48.83 259.18,48.98 U13093.11
LED_C_R: length 11.9
  TOP w0.254: CN2075.6 250.49,49.24 250.49,48.07 251.18,47.39 253.81,47.39 255.89,49.48 255.91,49.48 v1(256.33,49.9) 256.76,49.48 U13093.10
LED_D_B: length 17.7
  TOP w0.254: v1(247.99,50.7) CN2075.1 247.99,49.24 247.99,47.73 251.13,44.6 251.47,44.25 259.42,44.25 260.4,45.23 U13093.17
LED_D_G: length 15.1
  TOP w0.254: CN2075.2 248.49,49.24 248.49,47.79 251.09,45.19 251.09,45.19 251.64,44.64 258.54,44.64 v1(259.02,45.13) 259.67,45.78 U13093.16
LED_D_R: length 14.6
  TOP w0.254: U13093.15 258.51,46.98 258.21,46.68 v1(258.21,46.12) 258.21,45.71 257.54,45.04 251.8,45.04 251.1,45.74 248.99,47.84 248.99,49.24 CN2075.3
LED_G1_SYS: length 5
  TOP w0.127: R67168.2 375.58,14.48 v1(375,15.08)
  TOP w0.254: U13152.4 375.63,11.84 375.33,12.13 375.33,13.48 375.88,14.03 R67168.2
LED_G1_SYS_R: length 13.2
  TOP w0.254: R67168.1 375.96,15.36 375.96,15.86 v1(375.99,15.89)
  TOP w0.305: LED2.2 375.18,23.78 374.85,23.45 374.85,19.01 v1(374.75,18.91)
  IN1 w0.305: v1(375.99,15.89) 375.99,15.92 375.62,15.55 374.58,15.55 373.64,16.49 373.64,17.8 v1(374.75,18.91)
  BOTTOM w0.305: D13047.1 375.03,19.52 374.75,19.24 v1(374.75,18.91)
LED_G2_BAT: length 2.1
  TOP w0.254: R67171.2 372.76,11.64 v1(372.79,11.61) 373.27,11.61 373.63,11.24 U13152.8
LED_G2_BAT_R: length 30.1
  TOP w0.254: v1(372,13.71) 372.25,13.71 R67171.1
  TOP w0.305: LED1.2 375.25,34.18 374.7,33.63 v1(374.7,33.49)
  IN1 w0.305: v1(372.81,22.39) 372.81,21.36 373.87,20.3 373.87,19.73 372.73,18.59 372.73,14.44 v1(372,13.71)
  IN5 w0.305: v1(372.81,22.39) 372.81,22.51 371.87,23.46 371.16,23.46 370.96,23.66 370.96,28.9 370.47,29.39 370.47,31.81 371.88,33.21 372.74,33.21 373.04,32.91 374.37,32.91 374.7,33.25 v1(374.7,33.49)
  BOTTOM w0.305: D13050.1 372.29,22.39 v1(372.81,22.39)
LED_G3_M_BTN: length 13.2
  TOP w0.127: SW3.4 379.7,13.78 D13053.1 379.36,10.98 379.12,10.74 379.12,9.95 v1(378.91,9.74) ; U13152.11 372.05,9.22 v1(371.98,9.3)
  IN2 w0.127: v1(378.91,9.74) 378.84,9.82 377.92,9.82 376.98,8.88 372.4,8.88 v1(371.98,9.3)
LED_G4_P_BTN: length 239.9
  TOP w0.254: CN2071.4 186.85,47.94 186.66,47.74 182.46,47.74 182.06,47.34 v1(181.76,47.34) 181.5,47.34 181.1,47.74 D13056.1 ; v1(371.93,6.6) 372.05,6.72 U13152.16
  IN3 w0.254: v1(371.93,6.6) 371.95,6.57 372.17,6.57 372.8,7.2 372.8,15.52 370.61,17.72 370.34,17.72 369.12,18.94 365.88,18.94 365.07,19.76 365.07,23.59 364.69,23.96 364.69,28.05 364.02,28.72 364.02,32.58 361.12,35.48 360.09,35.48 359.81,35.76 359.81,37.02 358.87,37.96 357.47,37.96 356.61,38.83 356.61,41.29 356.56,41.35 356.56,44.31 355.62,45.24 347.24,45.24 346.85,44.85 341.88,44.85 338.09,48.64 330.5,48.64 329.7,47.83 324.99,47.83 322.66,45.51 313.96,45.51 313.27,44.82 288.99,44.82 286.31,47.5 271.69,47.5 269.78,45.58 263.62,45.58 263.16,46.04 256.2,46.04 255.82,45.66 246.55,45.66 245.87,44.97 182.72,44.97 181.68,46.02 181.68,47.26 v1(181.76,47.34)
LED_G5_GPU_FAN: length 2.8
  TOP w0.254: U13152.21 375.63,5.22 v1(375.53,5.12)
  BOTTOM w0.254: R67030.2 375.71,6.22 375.71,5.3 v1(375.53,5.12)
LED_G5_GPU_FAN_R: length 461.1
  TOP w0.254: CN2077.3 85.51,77.3 86.28,78.07 v1(86.28,78.32)
  IN3 w0.254: v1(46.02,47.39) 46.63,46.78 51.58,46.78 52.75,45.61 52.75,44.09 53.54,43.3 59.23,43.3 59.56,42.97 62.91,42.97 63.16,42.71 64.13,42.71 65.04,41.8 65.04,41.44 65.63,40.86 68.81,40.86 69.36,40.3 75.99,40.3 78.64,42.95 79.31,42.95 80.04,43.68 88.69,43.68 89.61,44.59 90.36,44.59 93.48,47.72 98.32,47.72 98.79,48.18 172.38,48.18 178.59,54.39 181.15,54.39 181.34,54.2 183.03,54.2 183.5,54.67 190.56,54.67 191.6,53.63 192.99,53.63 193.64,52.98 194.9,52.98 195.37,52.51 197.76,52.51 198.41,51.86 199.18,51.86 199.44,51.6 203.19,51.6 203.32,51.73 229.33,51.73 229.64,51.42 239.79,51.42 240.57,50.64 267.29,50.64 267.36,50.57 268.65,50.57 269.65,49.57 287.19,49.57 288.68,48.08 290.69,48.08 291.44,47.33 312.98,47.33 313.33,47.68 313.33,48.73 313.96,49.37 315.32,49.37 316.62,48.07 321.64,48.07 322.57,49.01 324.18,49.01 325.26,50.09 328.61,50.09 329.06,49.64 338.5,49.64 339.66,48.47 353.63,48.47 353.95,48.16 354.88,48.16 356,47.03 356,46.28 358.14,44.14 358.14,41.99 359.52,40.61 359.52,39.62 359.77,39.37 361.67,39.37 362.33,38.71 362.33,37.92 363.39,36.86 363.39,35.62 365.02,33.99 365.02,30.95 365.74,30.23 365.74,28.86 366.32,28.29 366.32,25.5 367.95,23.87 367.95,22.22 368.63,21.53 369.41,21.53 370.97,19.96 370.97,18.88 374.47,15.38 374.47,14.65 373.88,14.06 373.88,6.55 v1(373.06,5.73)
  BOTTOM w0.254: R67030.1 374.09,6.75 373.07,5.73 v1(373.06,5.73) ; D13059.1 86.28,78.22 v1(86.28,78.32) 86.28,78.71 84.84,80.14 81.13,80.14 81.12,80.13 78.73,80.13 76.91,78.3 62.02,78.3 60.28,80.04 49.15,80.04 45.38,76.27 45.38,70.76 44.97,70.34 44.97,68.56 45.69,67.84 45.69,62.07 43,59.37 43,55.7 44.66,54.04 44.66,47.93 45.36,47.24 45.87,47.24 v1(46.02,47.39)
LED_LINK: length 3.5
  TOP w0.14: U13143.39 346.98,69.94 v1(346.88,69.84)
  BOTTOM w0.14: v1(346.88,69.18) v1(346.88,69.84) 347.31,69.84 347.47,69.69 R67191.1 R67190.2
LED_R1_SYS: length 1.6
  TOP w0.254: U13152.3 376.13,11.51 376.09,11.55 376.09,11.98 375.87,12.2 R67167.2
LED_R1_SYS_R: length 11.7
  TOP w0.254: R67167.1 375.87,13.41 376.52,14.06 v1(376.52,14.42)
  TOP w0.305: LED2.1 375.77,19.94 v1(376.91,18.81)
  IN1 w0.305: v1(376.52,14.42) 376.52,18.43 v1(376.91,18.81)
  BOTTOM w0.254: v1(376.91,18.81) 376.91,18.92 377.53,19.54 D13046.1
LED_R2_BAT: length 3.9
  TOP w0.127: 373.82,12.43 374.15,12.43 374.26,12.54 374.26,13.94 v1(374.19,14.01)
  TOP w0.254: U13152.6 374.63,11.62 373.82,12.43 R67170.2
LED_R2_BAT_R: length 33.1
  TOP w0.254: R67170.1 373.78,13.59 372.26,15.1 v1(371.95,15.1)
  TOP w0.305: LED1.1 375.18,32.73 374.26,32.73 374.04,32.96 v1(374.04,33.47)
  IN1 w0.305: v1(371.95,15.1) 372.27,15.42 372.27,18.73 370.49,20.51 v1(370.49,21.9)
  IN5 w0.305: v1(370.49,21.9) 370.5,21.91 371.6,21.91 372.02,22.33 372.02,22.74 371.99,22.77 371.99,22.78 371.7,23.07 371,23.07 370.57,23.5 370.57,28.73 370.07,29.23 370.07,31.97 371.29,33.19 371.29,34.23 371.96,34.89 372.97,34.89 374.04,33.82 v1(374.04,33.47)
  BOTTOM w0.305: v1(370.49,21.9) 370.44,21.85 D13049.1
LED_R4_P_BTN: length 238.8
  TOP w0.254: CN2071.3 186.35,48.25 186.24,48.13 181.98,48.13 v1(181.78,48.33) 181.6,48.51 181.35,48.51 D13054.1 ; U13152.15 372.07,7.22 v1(372.03,7.26)
  IN3 w0.254: v1(181.78,48.33) 181.78,48.05 181.1,47.36 181.1,45.76 182.32,44.54 246.04,44.54 246.73,45.23 256.28,45.23 256.51,45.46 262.99,45.46 263.27,45.18 269.84,45.18 271.83,47.16 286.18,47.16 288.85,44.48 289.4,44.48 322.11,44.48 325.13,47.5 329.84,47.5 330.64,48.3 337.95,48.3 341.74,44.52 346.98,44.52 347.38,44.91 355.49,44.91 356.22,44.17 356.22,41.21 356.28,41.15 356.28,38.69 357.99,36.97 358.04,36.97 362.41,32.6 363.49,32.6 363.68,32.41 363.68,21.33 364.73,20.29 364.73,19.6 365.75,18.58 368.98,18.58 370.29,17.27 370.55,17.27 372.46,15.36 372.46,8.13 372.46,8.13 372.46,7.75 372.46,7.75 372.46,7.46 372.26,7.26 v1(372.03,7.26)
LED_R5_GPU_FAN: length 1.8
  TOP w0.254: U13152.20 375.13,5.48 374.8,5.15 v1(374.8,5.12)
  BOTTOM w0.254: v1(374.8,5.12) 375.19,5.51 R67029.2
LED_R5_GPU_FAN_R: length 474.5
  TOP w0.254: CN2077.2 85.59,78.3 v1(85.62,78.32)
  IN3 w0.254: v1(373.45,5.17) 373.45,5.33 374.24,6.11 374.24,13.81 374.9,14.47 374.9,15.43 371.34,19 371.34,20.07 369.55,21.86 368.8,21.86 368.37,22.29 368.37,23.91 366.65,25.63 366.65,28.43 366.11,28.97 366.11,33.7 363.77,36.04 363.77,37.33 363.32,37.79 363.32,38.93 362.81,39.44 362.11,39.44 361.33,40.22 360.52,40.22 360.46,40.28 359.81,40.93 359.81,41.74 358.79,42.76 358.79,46.42 358.54,46.67 358.54,49.16 357.32,50.38 357.32,53.39 356.11,54.61 356.11,55.91 354.42,57.6 347.98,57.6 347.8,57.77 346.93,57.77 345.08,55.92 345.08,50.26 344.47,49.65 339.98,49.65 339.65,49.97 329.2,49.97 328.15,51.02 325.73,51.02 324.04,49.34 322.43,49.34 322.15,49.06 320.89,49.06 320.63,49.32 317.3,49.32 316.59,50.03 313.69,50.03 312.03,48.38 302.82,48.38 302.1,47.66 291.58,47.66 290.83,48.41 288.82,48.41 287.33,49.9 269.79,49.9 268.79,50.9 267.5,50.9 267.43,50.97 240.71,50.97 239.31,52.37 226.82,52.37 226.54,52.09 203.19,52.09 203.07,51.96 199.59,51.96 199.33,52.21 198.53,52.21 197.9,52.84 195.51,52.84 195.04,53.31 193.78,53.31 193.13,53.97 191.74,53.97 190.7,55.01 183.32,55.01 182.87,54.56 181.45,54.56 181.29,54.73 178.45,54.73 172.24,48.51 98.65,48.51 98.18,48.05 93.34,48.05 90.24,44.95 89.48,44.95 88.54,44.01 79.9,44.01 79.17,43.28 77.44,43.28 76.32,42.15 75.92,42.15 75.56,42.51 72.66,42.51 72.11,41.95 70.25,41.95 69.69,42.51 68.73,42.51 68.17,41.95 65.79,41.95 65,42.74 65,43.69 63.96,44.73 61.66,44.73 60.83,45.56 60.83,46.6 60.52,46.91 59.96,46.91 59.61,46.55 58.82,46.55 56.07,49.3 49.67,49.3 48.71,48.33 47.09,48.33 v1(46.6,47.84)
  BOTTOM w0.254: v1(46.6,47.84) 46.46,47.98 45.35,47.98 45.05,48.28 45.05,54.2 43.39,55.87 43.39,59.21 46.08,61.9 46.08,68 45.36,68.72 45.36,70.18 45.78,70.59 45.78,76.1 49.32,79.64 60.12,79.64 61.87,77.89 77.11,77.89 78.95,79.73 84.67,79.73 85.62,78.78 v1(85.62,78.32) 85.22,78.32 D13057.1 ; v1(373.45,5.17) 373.45,5.25 373.98,5.78 R67029.1
LID#: length 324.3
  TOP w0.14: MR1.1 234.48,166.44 D8558.1 236.08,166.93 R20966.2 236.11,167.12 235.96,167.28 235.71,167.28 235.61,167.38 235.61,169.21 v1(234.72,170.1)
  IN3 w0.079: v1(348.38,88.69) 347.56,88.69 346.67,87.8 340.21,87.8 336.93,84.52 336.93,83 335.9,81.97 333.99,81.97 333.12,81.1 315.02,81.1 313.75,79.83 311.03,79.83 309.72,81.14 309.11,81.14 308.48,80.51 302.99,80.51 301.16,82.34 299.34,82.34 298.76,82.93 290.03,82.93 289.59,82.93 289.59,82.93 289.2,82.93 288.62,83.51 288.1,84.02 285.71,84.02 284.59,85.14 283.22,85.14 282,86.36 282,86.8 279.88,88.92 208.88,88.92 206.37,86.4 200.53,86.4 v1(199.49,85.36)
  IN5 w0.089: v1(183.03,65.37) 183.35,65.37 183.61,65.63 183.61,66.23 183.79,66.41 192.02,66.41 192.68,65.75 195.17,65.75 195.94,66.52 196.06,66.52 201.04,71.5 201.04,73.68 202.19,74.83 202.19,77.41 201.74,77.86 201.02,77.86 200.41,77.25 200.09,77.25 199.98,77.36 199.84,77.5 199.84,85.01 v1(199.49,85.36) 197.23,87.62 197.23,88.46 195.45,90.24 195.45,92.78 201.68,99.01 201.73,99.01 202.33,99.61 202.33,108.66 209.16,115.49 209.16,128.72 210.71,130.27 210.71,161.01 212.94,163.24 212.94,165.72 217.27,170.04 225.9,170.04 226.33,170.48 228.9,170.48 229.46,169.92 234.54,169.92 v1(234.72,170.1)
  BOTTOM w0.14: v1(348.38,88.69) 348.51,88.82 D8557.1 347.97,89.41 347.62,89.76 R20962.2 ; R20903.1 183.38,64.51 183.03,64.86 v1(183.03,65.37)
LID#_EC_L: length 4.5
  TOP w0.14: v1(184.04,65.96) 184,66 U49.118
  BOTTOM w0.14: D13087.1 183.42,67.16 C94644.2 183.81,66.18 v1(184.04,65.96) 184.04,65.89 183.66,65.5 R20903.2
LINLVP: length 83.4
  TOP w0.203: v1(29.84,38.68) 30.55,39.38 U13157.22
  TOP w0.508: CN2039.4 87.68,49.67 88.26,49.09 88.26,44.7 85.33,41.77 84.06,41.77 83.33,41.05 R67349.2 80.64,40.25 v1(80.23,39.84) 79.45,39.06 78.38,39.06 77.36,38.04 v1(77.36,37.74)
  IN1 w0.508: v1(29.84,38.68) 29.84,36.88 30.28,36.43 30.28,36.43 30.32,36.39 30.32,35.5 33.43,32.39 35.88,32.39 37.21,31.06 37.21,30.57 38.44,29.34 41.05,29.34 41.68,29.98 42.58,29.98 44.01,28.54 45.23,28.54 47.01,30.32 49.37,30.32 51.51,32.45 55.34,32.45 56.48,31.32 62.83,31.32 63.77,30.37 66.46,30.37 66.73,30.65 71.6,30.65 76.27,35.32 76.27,36.64 v1(77.36,37.74)
LIP: length 69.9
  TOP w0.203: L4237.2 29.41,39.78 v1(30.09,39.78) U13157.21
  TOP w0.508: v1(29.08,38.47) 28.94,38.61 L4237.2 ; R67349.1 v1(82.02,42.81)
  IN1 w0.508: v1(29.08,38.47) 29.08,39.06 29.46,39.44 30.5,39.44 33.1,42.03 37.53,42.03 38.35,41.22 39.01,41.22 39.62,41.83 39.62,43.12 40.15,43.65 41.4,43.65 42.01,43.04 42.01,42.38 42.54,41.85 50.41,41.85 50.79,42.23 52.45,42.23 52.92,42.71 58.11,42.71 58.69,42.13 58.69,40.57 59.95,39.31 64.54,39.31 65.05,39.82 65.53,39.82 66.01,40.3 69.41,40.3 70.15,41.04 74.32,41.04 74.98,40.38 75.89,40.38 77.57,42.05 81.27,42.05 v1(82.02,42.81)
  BOTTOM w0.508: C94632.2 30.14,39.23 30.09,39.29 29.59,39.29 29.08,38.78 v1(29.08,38.47)
LPC_LAD0: length 294.3
  TOP w0.14: U49.10 179.33,62 v1(179.52,61.81) ; U13113.AT22 309.16,63.06 v2(308.76,63.47)
  IN2 w0.089: v2(308.76,63.47) 308.5,63.21 308.5,62.2 308.27,61.96 306.27,61.96 305.96,61.66 305.96,60.9 305.36,60.3 305.36,58.07 304.56,57.27 304.56,54.69 303.81,53.93 298.37,53.93 298.22,53.79 296.53,53.79 295.38,52.64 293.35,52.64 293.05,52.94 292.82,52.94 292.09,53.67 292.09,53.86 291.24,54.7 289.91,54.7 287.88,56.73 286.6,56.73 286.3,57.04 282.45,57.04 278.71,53.3 264.03,53.3 263.7,52.97 249.78,52.97 247.52,50.71 241.75,50.71 241.05,51.41 234.09,51.41 233.62,50.94 230.14,50.94 229.67,51.41 202.97,51.41 201.58,52.8 197,52.8 194.53,55.26 194.53,60.46 193.03,61.96 191.8,61.96 191.72,61.88 190.33,61.88 189.81,62.4 185.61,62.4 185.08,62.93 183.27,62.93 180.63,62.93 v1(179.52,61.81) 179.33,61.62 179.06,61.62 178.74,61.31 177.81,61.31 177.8,61.32 175.85,61.32 175.19,60.65 172.55,60.65 170.48,58.58 170.48,58.31 167.81,55.64 157.16,55.64 156.72,56.08 148.42,56.08 147.85,56.66 147.85,57.43 147.75,57.53 143.1,57.53 142.95,57.37 133.45,57.37 130.12,54.04 128.12,54.04 127.05,52.97 118.21,52.97 116.78,54.4 115.26,54.4 114.92,54.74 111.29,54.74 110.23,53.68 101.29,53.68 100.47,52.86 96.42,52.86 93.76,50.2 84.07,50.2 83.06,49.2 78.28,49.2 77.9,48.81 73.27,48.81 72.66,48.2 69.21,48.2 68.02,49.39 66.99,49.39 66.43,49.95 66.43,50.29 65.47,51.25 65.47,51.94 58.64,58.77 56.15,58.77 v1(55.07,59.85)
  BOTTOM w0.14: R21714.1 54.79,59.57 v1(55.07,59.85) v1(55.07,60.75)
LPC_LAD0_C: length 3.3
  TOP w0.14: v1(54.12,59.83) 54.12,58.91 53.7,58.5 CN2068.64
  BOTTOM w0.14: R21714.2 54.01,59.73 v1(54.12,59.83)
