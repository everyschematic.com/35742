# Allegro board DAZGLMB1ED0 dazglmb1ed0-d-ver a-165 (.BRD) .brd (continued)
## Nets (continued)
NVVDD: C95161.1 C95162.1 C95163.1 C95164.1 C95165.1 C95166.1 C95167.1 C95168.1 C95169.1 C95170.1 C95171.1 C95172.1 C95173.1 C95174.1 C95175.1 C95176.1 C95177.1 C95178.1 C95179.1 C95180.1 C95181.1 C95182.1 C95183.1 C95184.1 C95185.1 C95186.1 C95187.1 C95188.1 C95189.1 C95190.1 C95191.1 C95192.1 C95193.1 C95194.1 C95195.1 C95196.1 C95197.1 C95198.1 C95199.1 C95200.1 C95201.1 C95202.1 C95203.1 C95204.1 C95205.1 C95206.1 C95207.1 C95208.1 C95209.1 C95210.1 C95211.1 C95212.1 C95213.1 C95214.1 C95215.1 C95216.1 C95217.1 C95218.1 C95219.1 C95220.1 C95221.1 C95222.1 C95223.1 C95224.1 C95225.1 C95226.1 C95227.1 C95228.1 C95229.1 C95230.1 C95231.1 C95232.1 C95233.1 C95234.1 C95235.1 C95236.1 C95237.1 C95238.1 C95239.1 C95240.1 C95241.1 C95242.1 C95243.1 C95244.1 C95245.1 C95246.1 C95247.1 C95248.1 C95249.1 C95250.1 C95251.1 C95252.1 C95253.1 C95254.1 C95255.1 C95256.1 C95257.1 C95258.1 C95259.1 C95260.1 C95261.1 C95915.1 C95919.1 C95922.1 C95924.1 C96209.1 C96264.1 C96265.1 C96266.1 PC9029.1 PC9477.1 PC9478.1 PC9479.1 PC9480.1 PC9481.1 PL9001.2 PL9024.2 PL9025.2 PL9026.2 PR9012.1 PR9075.1 PR66976.1 PR66978.1 PR66980.1 U13114.AA14(VDD_001) U13114.AA15(VDD_002) U13114.AA16(VDD_003) U13114.AA17(VDD_004) U13114.AA18(VDD_005) U13114.AA19(VDD_006) U13114.AA20(VDD_007) U13114.AA21(VDD_008) U13114.AA22(VDD_009) U13114.AA23(VDD_010) U13114.AA24(VDD_011) U13114.AA25(VDD_012) U13114.AA26(VDD_013) U13114.AA27(VDD_014) U13114.AA28(VDD_015) U13114.AA29(VDD_016) U13114.AA30(VDD_017) U13114.AA31(VDD_018) U13114.AA32(VDD_019) U13114.AA33(VDD_020) U13114.AA34(VDD_021) U13114.AA35(VDD_022) U13114.AA36(VDD_023) U13114.AA37(VDD_024) U13114.AA38(VDD_025) U13114.AA39(VDD_026) U13114.AB13(VDD_027) U13114.AB40(VDD_028) U13114.AC14(VDDS_001) U13114.AC15(VDDS_002) U13114.AC16(VDDS_003) U13114.AC17(VDDS_004) U13114.AC18(VDDS_005) U13114.AC19(VDD_029) U13114.AC20(VDD_030) U13114.AC21(VDD_031) U13114.AC22(VDD_032) U13114.AC23(VDD_033) U13114.AC24(VDDS_006) U13114.AC25(VDDS_007) U13114.AC26(VDDS_008) U13114.AC27(VDDS_009) U13114.AC28(VDDS_010) U13114.AC29(VDDS_011) U13114.AC30(VDD_034) U13114.AC31(VDD_035) U13114.AC32(VDD_036) U13114.AC33(VDD_037) U13114.AC34(VDD_038) U13114.AC35(VDDS_012) U13114.AC36(VDDS_013) U13114.AC37(VDDS_014) U13114.AC38(VDDS_015) U13114.AC39(VDDS_016) U13114.AE14(VDD_039) U13114.AE15(VDD_040) U13114.AE16(VDD_041) U13114.AE17(VDD_042) U13114.AE18(VDD_043) U13114.AE19(VDD_044) U13114.AE20(VDD_045) U13114.AE21(VDD_046) U13114.AE22(VDD_047) U13114.AE23(VDD_048) U13114.AE24(VDD_049) U13114.AE25(VDD_050) U13114.AE26(VDD_051) U13114.AE27(VDD_052) U13114.AE28(VDD_053) U13114.AE29(VDD_054) U13114.AE30(VDD_055) U13114.AE31(VDD_056) U13114.AE32(VDD_057) U13114.AE33(VDD_058) U13114.AE34(VDD_059) U13114.AE35(VDD_060) U13114.AE36(VDD_061) U13114.AE37(VDD_062) U13114.AE38(VDD_063) U13114.AE39(VDD_064) U13114.AF13(VDD_065) U13114.AF14(VDDS_017) U13114.AF15(VDDS_018) U13114.AF16(VDDS_019) U13114.AF17(VDDS_020) U13114.AF18(VDDS_021) U13114.AF24(VDDS_022) U13114.AF25(VDDS_023) U13114.AF26(VDDS_024) U13114.AF30(VDD_066) U13114.AF31(VDD_067) U13114.AF32(VDD_068) U13114.AF33(VDD_069) U13114.AF34(VDD_070) U13114.AF40(VDD_071) U13114.AG13(VDD_072) U13114.AG19(VDD_073) U13114.AG20(VDD_074) U13114.AG21(VDD_075) U13114.AG22(VDD_076) U13114.AG23(VDD_077) U13114.AG27(VDDS_025) U13114.AG28(VDDS_026) U13114.AG29(VDDS_027) U13114.AG35(VDDS_028) U13114.AG36(VDDS_029) U13114.AG37(VDDS_030) U13114.AG38(VDDS_031) U13114.AG39(VDDS_032) U13114.AG40(VDD_078) U13114.AH14(VDD_079) U13114.AH15(VDD_080) U13114.AH16(VDD_081) U13114.AH17(VDD_082) U13114.AH18(VDD_083) U13114.AH19(VDD_084) U13114.AH20(VDD_085) U13114.AH21(VDD_086) U13114.AH22(VDD_087) U13114.AH23(VDD_088) U13114.AH24(VDD_089) U13114.AH25(VDD_090) U13114.AH26(VDD_091) U13114.AH27(VDD_092) U13114.AH28(VDD_093) U13114.AH29(VDD_094) U13114.AH30(VDD_095) U13114.AH31(VDD_096) U13114.AH32(VDD_097) U13114.AH33(VDD_098) U13114.AH34(VDD_099) U13114.AH35(VDD_100) U13114.AH36(VDD_101) U13114.AH37(VDD_102) U13114.AH38(VDD_103) U13114.AH39(VDD_104) U13114.AK14(VDDS_033) U13114.AK15(VDDS_034) U13114.AK16(VDDS_035) U13114.AK17(VDDS_036) U13114.AK18(VDDS_037) U13114.AK19(VDD_105) U13114.AK20(VDD_106) U13114.AK21(VDD_107) U13114.AK22(VDD_108) U13114.AK23(VDD_109) U13114.AK24(VDDS_038) U13114.AK25(VDDS_039) U13114.AK26(VDDS_040) U13114.AK27(VDDS_041) U13114.AK28(VDDS_042) U13114.AK29(VDDS_043) U13114.AK30(VDD_110) U13114.AK31(VDD_111) U13114.AK32(VDD_112) U13114.AK33(VDD_113) U13114.AK34(VDD_114) U13114.AK35(VDDS_044) U13114.AK36(VDDS_045) U13114.AK37(VDDS_046) U13114.AK38(VDDS_047) U13114.AK39(VDDS_048) U13114.AL13(VDD_115) U13114.AL40(VDD_116) U13114.AM14(VDD_117) U13114.AM15(VDD_118) U13114.AM16(VDD_119) U13114.AM17(VDD_120) U13114.AM18(VDD_121) U13114.AM19(VDD_122) U13114.AM20(VDD_123) U13114.AM21(VDD_124) U13114.AM22(VDD_125) U13114.AM23(VDD_126) U13114.AM24(VDD_127) U13114.AM25(VDD_128) U13114.AM26(VDD_129) U13114.AM27(VDD_130) U13114.AM28(VDD_131) U13114.AM29(VDD_132) U13114.AM30(VDD_133) U13114.AM31(VDD_134) U13114.AM32(VDD_135) U13114.AM33(VDD_136) U13114.AM34(VDD_137) U13114.AM35(VDD_138) U13114.AM36(VDD_139) U13114.AM37(VDD_140) U13114.AM38(VDD_141) U13114.AM39(VDD_142) U13114.AP14(VDDS_049) U13114.AP15(VDDS_050) U13114.AP16(VDDS_051) U13114.AP17(VDDS_052) U13114.AP18(VDDS_053) U13114.AP19(VDD_143) U13114.AP20(VDD_144) U13114.AP21(VDD_145) U13114.AP22(VDD_146) U13114.AP23(VDD_147) U13114.AP24(VDDS_054) U13114.AP25(VDDS_055) U13114.AP26(VDDS_056) U13114.AP27(VDDS_057) U13114.AP28(VDDS_058) U13114.AP29(VDDS_059) U13114.AP30(VDD_148) U13114.AP31(VDD_149) U13114.AP32(VDD_150) U13114.AP33(VDD_151) U13114.AP34(VDD_152) U13114.AP35(VDDS_060) U13114.AP36(VDDS_061) U13114.AP37(VDDS_062) U13114.AP38(VDDS_063) U13114.AP39(VDDS_064) U13114.AR13(VDD_153) U13114.AR40(VDD_154) U13114.AT14(VDD_155) U13114.AT15(VDD_156) U13114.AT16(VDD_157) U13114.AT17(VDD_158) U13114.AT18(VDD_159) U13114.AT19(VDD_160) U13114.AT20(VDD_161) U13114.AT21(VDD_162) U13114.AT22(VDD_163) U13114.AT23(VDD_164) U13114.AT24(VDD_165) U13114.AT25(VDD_166) U13114.AT26(VDD_167) U13114.AT27(VDD_168) U13114.AT28(VDD_169) U13114.AT29(VDD_170) U13114.AT30(VDD_171) U13114.AT31(VDD_172) U13114.AT32(VDD_173) U13114.AT33(VDD_174) U13114.AT34(VDD_175) U13114.AT35(VDD_176) U13114.AT36(VDD_177) U13114.AT37(VDD_178) U13114.AT38(VDD_179) U13114.AT39(VDD_180) U13114.AT42(VDD_181) U13114.AU43(VDD_182) U13114.AV14(VDDS_065) U13114.AV15(VDDS_066) U13114.AV16(VDDS_067) U13114.AV17(VDDS_068) U13114.AV18(VDDS_069) U13114.AV19(VDD_183) U13114.AV20(VDD_184) U13114.AV21(VDD_185) U13114.AV22(VDD_186) U13114.AV23(VDD_187) U13114.AV24(VDDS_070) U13114.AV25(VDDS_071) U13114.AV26(VDDS_072) U13114.AV27(VDDS_073) U13114.AV28(VDDS_074) U13114.AV29(VDDS_075) U13114.AV30(VDD_188) U13114.AV31(VDD_189) U13114.AV32(VDD_190) U13114.AV33(VDD_191) U13114.AV34(VDD_192) U13114.AV35(VDDS_076) U13114.AV36(VDDS_077) U13114.AV37(VDDS_078) U13114.AV38(VDDS_079) U13114.AV39(VDDS_080) U13114.AV42(VDD_193) U13114.AV43(VDD_194) U13114.AV44(VDD_195) U13114.AW13(VDD_196) U13114.AW40(VDD_197) U13114.AW42(VDD_198) U13114.AW43(VDD_199) U13114.AW44(VDD_200) U13114.AW45(VDD_201) U13114.AY14(VDD_202) U13114.AY18(VDD_203) U13114.AY22(VDD_204) U13114.AY26(VDD_205) U13114.AY27(VDD_206) U13114.AY31(VDD_207) U13114.AY35(VDD_208) U13114.AY39(VDD_209) U13114.AY43(VDD_210) U13114.AY45(VDD_211) U13114.BA43(VDD_212) U13114.BA44(VDD_213) U13114.BA45(VDD_214) U13114.BA46(VDD_215) U13114.BA47(VDD_216) U13114.BB38(VDD_217) U13114.BB39(VDD_218) U13114.BB45(VDD_219) U13114.BB46(VDD_220) U13114.BB47(VDD_221) U13114.BB48(VDD_222) U13114.BC38(VDD_223) U13114.BC39(VDD_224) U13114.BC40(VDD_225) U13114.BC41(VDD_226) U13114.BC45(VDD_227) U13114.BC47(VDD_228) U13114.BC49(VDD_229) U13114.BD39(VDD_230) U13114.BD41(VDD_231) U13114.BD46(VDD_232) U13114.BD47(VDD_233) U13114.BD48(VDD_234) U13114.BD49(VDD_235) U13114.BD50(VDD_236) U13114.BD51(VDD_237) U13114.BE41(VDD_238) U13114.BE42(VDD_239) U13114.BE43(VDD_240) U13114.BE46(VDD_241) U13114.BE47(VDD_242) U13114.BE48(VDD_243) U13114.BE49(VDD_244) U13114.BE50(VDD_245) U13114.BE51(VDD_246) U13114.BE52(VDD_247) U13114.BF42(VDD_248) U13114.BF44(VDD_249) U13114.BF45(VDD_250) U13114.BF47(VDD_251) U13114.BF49(VDD_252) U13114.BF51(VDD_253) U13114.BG43(VDD_254) U13114.BG44(VDD_255) U13114.BG45(VDD_256) U13114.BG46(VDD_257) U13114.BG47(VDD_258) U13114.BG48(VDD_259) U13114.BG49(VDD_260) U13114.BG50(VDD_261) U13114.BG51(VDD_262) U13114.BG52(VDD_263) U13114.BH44(VDD_264) U13114.BH45(VDD_265) U13114.BH47(VDD_266) U13114.BH48(VDD_267) U13114.BH49(VDD_268) U13114.BH50(VDD_269) U13114.BH51(VDD_270) U13114.BH52(VDD_271) U13114.BJ44(VDD_272) U13114.BJ45(VDD_273) U13114.BJ46(VDD_274) U13114.BJ47(VDD_275) U13114.BJ48(VDD_276) U13114.BJ49(VDD_277) U13114.BJ50(VDD_278) U13114.BJ51(VDD_279) U13114.BJ52(VDD_280) U13114.BK47(VDD_281) U13114.BK48(VDD_282) U13114.BK49(VDD_283) U13114.BK50(VDD_284) U13114.BK51(VDD_285) U13114.BK52(VDD_286) U13114.BL46(VDD_287) U13114.BL47(VDD_288) U13114.BL48(VDD_289) U13114.BL49(VDD_290) U13114.BL50(VDD_291) U13114.BL51(VDD_292) U13114.BL52(VDD_293) U13114.BM47(VDD_294) U13114.BM48(VDD_295) U13114.BM49(VDD_296) U13114.BM50(VDD_297) U13114.BM51(VDD_298) U13114.N14(VDD_299) U13114.N18(VDD_300) U13114.N22(VDD_301) U13114.N26(VDD_302) U13114.N27(VDD_303) U13114.N31(VDD_304) U13114.N35(VDD_305) U13114.N39(VDD_306) U13114.P13(VDD_307) U13114.P40(VDD_308) U13114.R14(VDDS_081) U13114.R15(VDDS_082) U13114.R16(VDDS_083) U13114.R17(VDDS_084) U13114.R18(VDDS_085) U13114.R19(VDD_309) U13114.R20(VDD_310) U13114.R21(VDD_311) U13114.R22(VDD_312) U13114.R23(VDD_313) U13114.R24(VDDS_086) U13114.R25(VDDS_087) U13114.R26(VDDS_088) U13114.R27(VDDS_089) U13114.R28(VDDS_090) U13114.R29(VDDS_091) U13114.R30(VDD_314) U13114.R31(VDD_315) U13114.R32(VDD_316) U13114.R33(VDD_317) U13114.R34(VDD_318) U13114.R35(VDDS_092) U13114.R36(VDDS_093) U13114.R37(VDDS_094) U13114.R38(VDDS_095) U13114.R39(VDDS_096) U13114.U14(VDD_319) U13114.U15(VDD_320) U13114.U16(VDD_321) U13114.U17(VDD_322) U13114.U18(VDD_323) U13114.U19(VDD_324) U13114.U20(VDD_325) U13114.U21(VDD_326) U13114.U22(VDD_327) U13114.U23(VDD_328) U13114.U24(VDD_329) U13114.U25(VDD_330) U13114.U26(VDD_331) U13114.U27(VDD_332) U13114.U28(VDD_333) U13114.U29(VDD_334) U13114.U30(VDD_335) U13114.U31(VDD_336) U13114.U32(VDD_337) U13114.U33(VDD_338) U13114.U34(VDD_339) U13114.U35(VDD_340) U13114.U36(VDD_341) U13114.U37(VDD_342) U13114.U38(VDD_343) U13114.U39(VDD_344) U13114.V13(VDD_345) U13114.V40(VDD_346) U13114.W14(VDDS_097) U13114.W15(VDDS_098) U13114.W16(VDDS_099) U13114.W17(VDDS_100) U13114.W18(VDDS_101) U13114.W19(VDD_347) U13114.W20(VDD_348) U13114.W21(VDD_349) U13114.W22(VDD_350) U13114.W23(VDD_351) U13114.W24(VDDS_102) U13114.W25(VDDS_103) U13114.W26(VDDS_104) U13114.W27(VDDS_105) U13114.W28(VDDS_106) U13114.W29(VDDS_107) U13114.W30(VDD_352) U13114.W31(VDD_353) U13114.W32(VDD_354) U13114.W33(VDD_355) U13114.W34(VDD_356) U13114.W35(VDDS_108) U13114.W36(VDDS_109) U13114.W37(VDDS_110) U13114.W38(VDDS_111) U13114.W39(VDDS_112)
NVVDD_CORE1_EN: C95149.2 D8592.1(CATHODE) PR9002.2 R21611.2 R21612.1
NVVDD_PG_LOOP_OVT: Q7863.2(G) Q7864.3(D) Q7865.3(D) R21609.2
NVVDD_PSI#: R21574.1 R21591.2 U13114.BD2(GPIO6)
NVVDD_PWM_GPU: PR9022.1 U13114.BD6(GPIO0)
NVVDD_SENSE2_IN_N: PR119.2 PR67198.2
NVVDD_SENSE2_IN_P: PR67194.2 PR67197.2
NVVDDPG: D8595.1(CATHODE1) PR9018.1 PR9065.1 PU9001.32(PGOOD) Q7864.2(G) R21610.2 R21615.2 R67325.1 U13120.1(INB)
NVVDDPG_R: C95150.1 D8594.2(ANODE) R21613.2 R21614.2 R21615.1 U13120.4(OUT Y)
NVVDDPG_RRR: Q7863.1(S) R67325.2 R67326.2
NVVDDS_PSI: PR67009.2 R21582.2
NVVDDS_PSI_R: R21582.1 R21597.2 U13114.BE5(GPIO20)
NVVDDS_VID: R67331.2 U13114.BE4(GPIO3)
OVERT#: Q7861.1(S) R21601.2 R21603.1 U13114.BG5(OVERT)
OVERT#_R: D13088.1(CATHODE) PR67226.2
PA_USB2_RBIAS: R20848.2 U21.H19(PA_USB2_RBIAS)
PB_USB2_RBIAS: R22147.1 U21.F19(PB_USB2_RBIAS)
PCBEEP_EC: D13038.2(ANODE) U49.34(PWM7/RIG1#/GPA7)
PCH_2_CPU_TRIG: R21360.1 U41.H23(PROC_TRIGIN)
PCH_2_CPU_TRIG_R: R21360.2 U13113.AL2(PCH_TRIGOUT)
PCH_AZ_CODEC_BITCLK: C94807.1 R21100.1 R21454.2
PCH_AZ_CODEC_RST#: Q7847.1(S) R21102.1
PCH_AZ_CODEC_RST#_PD: D8586.1(CATHODE) Q7847.3(D)
PCH_AZ_CODEC_SDIN0: R21453.2 U13113.BE7(HDA_SDI0)
PCH_AZ_CODEC_SDOUT: R21103.1 U13108.17(SDATA_OUT)
PCH_AZ_CODEC_SYNC: R21104.1 U13108.15(SYNC)
PCH_BLON_EC: R20965.1 U49.88(PS2DAT1/RTS0#/GPF3)
PCH_BRIGHT: CN2042.33 Q7819.3(D) R20945.2 R20947.2 R22070.2
PCH_DISP_ON: R20959.1 U13113.W42(GPP_F19/EDP_VDDEN)
PCH_DPST_PWM: R20945.1 U13113.W36(GPP_F21/EDP_BKLTCTL)
PCH_LVDS_BLON: R20951.1 U13113.W35(GPP_F20/EDP_BKLTEN)
PCH_PECI: R563.1 R21192.2 U13113.AL3(PECI)
PCH_PWROK: R204.2 R205.1 R21156.2 U49.78(DAC2/TACH0B/GPJ2(3))
PCH_RSMRST#: R21129.2 R21134.2 R21141.1 U13113.BA11(RSMRST#)
PCH_SPI_CLK: R21245.1 U13113.BC31(SPI0_CLK)
PCH_SPI_CLK_EC: R21249.1 U49.105(FSCK/GPG7)
PCH_SPI_CS0#: R22065.1 U13113.BD31(SPI0_CS0#)
PCH_SPI_IO2: R21238.2 R21247.1 R22066.1 U13113.BC29(SPI0_IO2)
PCH_SPI_IO3: R21254.2 R21261.1 R22067.1 U13113.BD30(SPI0_IO3)
PCH_SPI_SI: R21246.1 R21270.2 R21277.1 U13113.BB29(SPI0_MOSI)
PCH_SPI_SI_EC: R20890.1 R21250.1 U49.102(FMOSI/GPG4)
PCH_SPI_SO: R21219.2 R21225.1 R22063.1 U13113.BE30(SPI0_MISO)
PCH_SPI_SO_EC: R20891.1 R21243.1 U49.103(FMISO/GPG5)
PCH_THRMTRIP_R#: R21189.1 U13113.AJ3(THERMTRIP#)
PCI_PLTRST#: U13102.1(INB) U13102.2(INA) U13113.BB27(GPP_B13/PLTRST#)
PCIE9_SATA_RXN: C95583.2 U13113.G31(PCIE9_RXN/SATA0A_RXN)
PCIE9_SATA_RXN_C: C95583.1 U13146.13(B1_OUTN)
PCIE9_SATA_RXN_C_RE: R21736.2 R67362.2 U13146.36(B1_INN)
PCIE9_SATA_RXN_C_RE_C: CN2069.43 R21736.1
PCIE9_SATA_RXP: C95580.2 U13113.H31(PCIE9_RXP/SATA0A_RXP)
PCIE9_SATA_RXP_C: C95580.1 U13146.12(B1_OUTP)
PCIE9_SATA_RXP_C_RE: R21735.2 R67363.2 U13146.37(B1_INP)
PCIE9_SATA_RXP_C_RE_C: CN2069.41 R21735.1
PCIE9_SATA_TXN: C95578.2 U13113.C31(PCIE9_TXN/SATA0A_TXN)
PCIE9_SATA_TXN_C: C95578.1 U13146.10(A1_INN)
PCIE9_SATA_TXN_C_RE: C95566.1 C96241.1 U13146.39(A1_OUTN)
PCIE9_SATA_TXN_C_RE_C: C95566.2 CN2069.47
PCIE9_SATA_TXP: C95581.2 U13113.B31(PCIE9_TXP/SATA0A_TXP)
PCIE9_SATA_TXP_C: C95581.1 U13146.9(A1_INP)
PCIE9_SATA_TXP_C_RE: C95567.1 C96240.1 U13146.40(A1_OUTP)
PCIE9_SATA_TXP_C_RE_C: C95567.2 CN2069.49
PCIE10_SATA_RXN: C95874.2 U13113.G29(PCIE10_RXN/SATA1A_RXN)
PCIE10_SATA_RXN_C: C95874.1 U13146.20(B2_OUTN)
PCIE10_SATA_RXN_C_RE: R21731.1 U13146.29(B2_INN)
PCIE10_SATA_RXN_C_RE_C: CN2069.29 R21731.2
PCIE10_SATA_RXP: C95875.2 U13113.E29(PCIE10_RXP/SATA1A_RXP)
PCIE10_SATA_RXP_C: C95875.1 U13146.19(B2_OUTP)
PCIE10_SATA_RXP_C_RE: R21732.1 U13146.30(B2_INP)
PCIE10_SATA_RXP_C_RE_C: CN2069.31 R21732.2
PCIE10_SATA_TXN: C95873.2 U13113.C32(PCIE10_TXN/SATA1A_TXN)
PCIE10_SATA_TXN_C: C95873.1 U13146.17(A2_INN)
PCIE10_SATA_TXN_C_RE: C95564.1 U13146.32(A2_OUTN)
PCIE10_SATA_TXN_C_RE_C: C95564.2 CN2069.35
PCIE10_SATA_TXP: C95837.2 U13113.B32(PCIE10_TXP/SATA1A_TXP)
PCIE10_SATA_TXP_C: C95837.1 U13146.16(A2_INP)
PCIE10_SATA_TXP_C_RE: C95565.1 U13146.33(A2_OUTP)
PCIE10_SATA_TXP_C_RE_C: C95565.2 CN2069.37
PCIE11_SATA_RXN: C95843.2 U13113.L31(PCIE11_RXN)
PCIE11_SATA_RXN_C: C95843.1 U13147.13(B1_OUTN)
PCIE11_SATA_RXN_C_RE: R21728.1 U13147.36(B1_INN)
PCIE11_SATA_RXN_C_RE_C: CN2069.17 R21728.2
PCIE11_SATA_RXP: C95844.2 U13113.K31(PCIE11_RXP)
PCIE11_SATA_RXP_C: C95844.1 U13147.12(B1_OUTP)
PCIE11_SATA_RXP_C_RE: R21729.1 U13147.37(B1_INP)
PCIE11_SATA_RXP_C_RE_C: CN2069.19 R21729.2
PCIE11_SATA_TXN: C95842.2 U13113.C33(PCIE11_TXN)
PCIE11_SATA_TXN_C: C95842.1 U13147.10(A1_INN)
PCIE11_SATA_TXN_C_RE: C95562.1 U13147.39(A1_OUTN)
PCIE11_SATA_TXN_C_RE_C: C95562.2 CN2069.23
PCIE11_SATA_TXP: C95845.2 U13113.B33(PCIE11_TXP)
PCIE11_SATA_TXP_C: C95845.1 U13147.9(A1_INP)
PCIE11_SATA_TXP_C_RE: C95563.1 U13147.40(A1_OUTP)
PCIE11_SATA_TXP_C_RE_C: C95563.2 CN2069.25
PCIE12_SATA_RXN: C95839.2 U13113.G33(PCIE12_RXN)
PCIE12_SATA_RXN_C: C95839.1 U13147.20(B2_OUTN)
PCIE12_SATA_RXN_C_RE: R21730.1 U13147.29(B2_INN)
PCIE12_SATA_RXN_C_RE_C: CN2069.5 R21730.2
PCIE12_SATA_RXP: C95840.2 U13113.H33(PCIE12_RXP)
PCIE12_SATA_RXP_C: C95840.1 U13147.19(B2_OUTP)
PCIE12_SATA_RXP_C_RE: R21726.1 U13147.30(B2_INP)
PCIE12_SATA_RXP_C_RE_C: CN2069.7 R21726.2
PCIE12_SATA_TXN: C95838.2 U13113.B35(PCIE12_TXN)
PCIE12_SATA_TXN_C: C95838.1 U13147.17(A2_INN)
PCIE12_SATA_TXN_C_RE: C95558.1 U13147.32(A2_OUTN)
PCIE12_SATA_TXN_C_RE_C: C95558.2 CN2069.11
PCIE12_SATA_TXP: C95841.2 U13113.A35(PCIE12_TXP)
PCIE12_SATA_TXP_C: C95841.1 U13147.16(A2_INP)
PCIE12_SATA_TXP_C_RE: C95555.1 U13147.33(A2_OUTP)
PCIE12_SATA_TXP_C_RE_C: C95555.2 CN2069.13
PCIE13_SATA_RXN: C95866.2 U13113.D43(PCIE16_RXN/SATA3_RXN)
PCIE13_SATA_RXN_C: C95866.1 U13149.13(B1_OUTN)
PCIE13_SATA_RXN_C_RE: R21799.1 U13149.36(B1_INN)
PCIE13_SATA_RXN_C_RE_C: CN2070.43 R21799.2
PCIE13_SATA_RXP: C95870.2 U13113.E42(PCIE16_RXP/SATA3_RXP)
PCIE13_SATA_RXP_C: C95870.1 U13149.12(B1_OUTP)
PCIE13_SATA_RXP_C_RE: R21798.1 U13149.37(B1_INP)
PCIE13_SATA_RXP_C_RE_C: CN2070.41 R21798.2
PCIE13_SATA_TXN: C95860.2 U13113.A41(PCIE16_TXN/SATA3_TXN)
PCIE13_SATA_TXN_C: C95860.1 U13149.10(A1_INN)
PCIE13_SATA_TXN_C_RE: C95636.1 U13149.39(A1_OUTN)
PCIE13_SATA_TXN_C_RE_C: C95636.2 CN2070.47
PCIE13_SATA_TXP: C95871.2 U13113.A40(PCIE16_TXP/SATA3_TXP)
PCIE13_SATA_TXP_C: C95871.1 U13149.9(A1_INP)
PCIE13_SATA_TXP_C_RE: C95637.1 U13149.40(A1_OUTP)
PCIE13_SATA_TXP_C_RE_C: C95637.2 CN2070.49
PCIE14_SATA_RXN: C95847.2 U13113.F41(PCIE15_RXN/SATA2_RXN)
PCIE14_SATA_RXN_C: C95847.1 U13149.20(B2_OUTN)
PCIE14_SATA_RXN_C_RE: R21794.1 U13149.29(B2_INN)
PCIE14_SATA_RXN_C_RE_C: CN2070.29 R21794.2
PCIE14_SATA_RXP: C95848.2 U13113.E41(PCIE15_RXP/SATA2_RXP)
PCIE14_SATA_RXP_C: C95848.1 U13149.19(B2_OUTP)
PCIE14_SATA_RXP_C_RE: R21795.1 U13149.30(B2_INP)
PCIE14_SATA_RXP_C_RE_C: CN2070.31 R21795.2
PCIE14_SATA_TXN: C95846.2 U13113.B39(PCIE15_TXN/SATA2_TXN)
PCIE14_SATA_TXN_C: C95846.1 U13149.17(A2_INN)
PCIE14_SATA_TXN_C_RE: C95634.1 U13149.32(A2_OUTN)
PCIE14_SATA_TXN_C_RE_C: C95634.2 CN2070.35
PCIE14_SATA_TXP: C95849.2 U13113.A39(PCIE15_TXP/SATA2_TXP)
PCIE14_SATA_TXP_C: C95849.1 U13149.16(A2_INP)
PCIE14_SATA_TXP_C_RE: C95635.1 U13149.33(A2_OUTP)
PCIE14_SATA_TXP_C_RE_C: C95635.2 CN2070.37
PCIE15_SATA_RXN: C95855.2 U13113.D39(PCIE14_RXN/SATA1B_RXN)
PCIE15_SATA_RXN_C: C95855.1 U13148.13(B1_OUTN)
PCIE15_SATA_RXN_C_RE: R21792.1 U13148.36(B1_INN)
PCIE15_SATA_RXN_C_RE_C: CN2070.17 R21792.2
PCIE15_SATA_RXP: C95856.2 U13113.E37(PCIE14_RXP/SATA1B_RXP)
PCIE15_SATA_RXP_C: C95856.1 U13148.12(B1_OUTP)
PCIE15_SATA_RXP_C_RE: R21793.1 U13148.37(B1_INP)
PCIE15_SATA_RXP_C_RE_C: CN2070.19 R21793.2
PCIE15_SATA_TXN: C95854.2 U13113.B38(PCIE14_TXN/SATA1B_TXN)
PCIE15_SATA_TXN_C: C95854.1 U13148.10(A1_INN)
PCIE15_SATA_TXN_C_RE: C95632.1 U13148.39(A1_OUTN)
PCIE15_SATA_TXN_C_RE_C: C95632.2 CN2070.23
PCIE15_SATA_TXP: C95857.2 U13113.C38(PCIE14_TXP/SATA1B_TXP)
PCIE15_SATA_TXP_C: C95857.1 U13148.9(A1_INP)
PCIE15_SATA_TXP_C_RE: C95633.1 U13148.40(A1_OUTP)
PCIE15_SATA_TXP_C_RE_C: C95633.2 CN2070.25
PCIE16_SATA_RXN: C95851.2 U13113.G35(PCIE13_RXN/SATA0B_RXN)
PCIE16_SATA_RXN_C: C95851.1 U13148.20(B2_OUTN)
PCIE16_SATA_RXN_C_RE: R21788.1 U13148.29(B2_INN)
PCIE16_SATA_RXN_C_RE_C: CN2070.5 R21788.2
PCIE16_SATA_RXP: C95852.2 U13113.E35(PCIE13_RXP/SATA0B_RXP)
PCIE16_SATA_RXP_C: C95852.1 U13148.19(B2_OUTP)
PCIE16_SATA_RXP_C_RE: R21790.1 U13148.30(B2_INP)
PCIE16_SATA_RXP_C_RE_C: CN2070.7 R21790.2
PCIE16_SATA_TXN: C95850.2 U13113.C36(PCIE13_TXN/SATA0B_TXN)
PCIE16_SATA_TXN_C: C95850.1 U13148.17(A2_INN)
PCIE16_SATA_TXN_C_RE: C95626.1 U13148.32(A2_OUTN)
PCIE16_SATA_TXN_C_RE_C: C95626.2 CN2070.11
PCIE16_SATA_TXP: C95853.2 U13113.B36(PCIE13_TXP/SATA0B_TXP)
PCIE16_SATA_TXP_C: C95853.1 U13148.16(A2_INP)
PCIE16_SATA_TXP_C_RE: C95628.1 U13148.33(A2_OUTP)
PCIE16_SATA_TXP_C_RE_C: C95628.2 CN2070.13
PCIE_CLKREQ1#: R21194.1 R21992.2 U13113.AW24(GPP_B6/SRCCLKREQ1#)
PCIE_CLKREQ2#: R21195.1 R21208.2 U13113.AT24(GPP_B7/SRCCLKREQ2#)
PCIE_CLKREQ3#: R21200.1 R21209.2 U13113.BD25(GPP_B8/SRCCLKREQ3#)
PCIE_CLKREQ4#: R21193.1 R21211.2 U13113.BB24(GPP_B9/SRCCLKREQ4#)
PCIE_CLKREQ5#: R21201.1 U13113.BE25(GPP_B10/SRCCLKREQ5#)
PCIE_CLKREQ6#: R21202.1 U13113.AT33(GPP_H0/SRCCLKREQ6#)
PCIE_CLKREQ7#: R21203.1 R21213.2 U13113.AR31(GPP_H1/SRCCLKREQ7#)
PCIE_CLKREQ8#: R21204.1 R21990.2 U13113.BD32(GPP_H2/SRCCLKREQ8#)
PCIE_CLKREQ9#: R21205.1 U13113.BC32(GPP_H3/SRCCLKREQ9#)
PCIE_CLKREQ10#: R21207.1 U13113.BB31(GPP_H4/SRCCLKREQ10#)
PCIE_CLKREQ11#: R21210.1 U13113.BC33(GPP_H5/SRCCLKREQ11#)
PCIE_CLKREQ12#: R21212.1 U13113.BA33(GPP_H6/SRCCLKREQ12#)
PCIE_CLKREQ13#: R21214.1 U13113.AW33(GPP_H7/SRCCLKREQ13#)
PCIE_CLKREQ14#: R21215.1 U13113.BB33(GPP_H8/SRCCLKREQ14#)
PCIE_CLKREQ15#: R21216.1 U13113.BD33(GPP_H9/SRCCLKREQ15#)
PCIE_CLKREQ_LAN#: Q7848.3(D) R21209.1 R22095.1
PCIE_CLKREQ_NGFF1#: CN2069.52 R21213.1 R22211.1 R22212.1
PCIE_CLKREQ_NGFF2#: CN2070.52 R21990.1 R22213.2 R22214.1
PCIE_CLKREQ_TBT#: Q7917.1(S) R21198.1 R67050.2 U13113.BC24(GPP_B5/SRCCLKREQ0#)
PCIE_CLKREQ_TBT#_C: Q7917.3(D) R67049.1 R67050.1 U21.AC5(PCIE_CLKREQ_N)
PCIE_CLKREQ_VGA#: Q7851.3(D) R21211.1
PCIE_CLKREQ_WIGIG#: Q7890.3(D) R21992.1
PCIE_CLKREQ_WLAN#: Q7888.3(D) R21208.1
PCIE_LAN_WAKE#_R: Q7849.1(S) R21486.2 R22096.2 U13143.3(WAKEN)
PCIE_REQ_LAN#_R: Q7848.1(S) R21484.2 R22095.2 U13143.4(CLKREQN)
PCIE_RXN1_TBT: C94573.2 U13113.K19(PCIE5_RXN)
PCIE_RXN1_TBT_C: C94573.1 U21.V22(PCIE_TX0_N)
PCIE_RXN2_TBT: C94575.2 U13113.G22(PCIE6_RXN)
PCIE_RXN2_TBT_C: C94575.1 U21.P22(PCIE_TX1_N)
PCIE_RXN3_TBT: C94577.2 U13113.L22(PCIE7_RXN)
PCIE_RXN3_WLAN: CN2068.43(PERN0) U13113.L17(PCIE3_RXN/USB3_9_RXN)
PCIE_RXN4_LAN: C94976.1 U13113.E20(PCIE4_RXN/USB3_10_RXN)
PCIE_RXN4_LAN_R: C94976.2 U13143.29(TX_N)
PCIE_RXN4_TBT: C94579.2 U13113.K24(PCIE8_RXN)
PCIE_RXP1_TBT: C94574.2 U13113.L19(PCIE5_RXP)
PCIE_RXP1_TBT_C: C94574.1 U21.V23(PCIE_TX0_P)
PCIE_RXP2_TBT: C94576.2 U13113.E22(PCIE6_RXP)
PCIE_RXP2_TBT_C: C94576.1 U21.P23(PCIE_TX1_P)
PCIE_RXP3_TBT: C94578.2 U13113.K22(PCIE7_RXP)
PCIE_RXP3_WLAN: CN2068.41(PERP0) U13113.K17(PCIE3_RXP/USB3_9_RXP)
PCIE_RXP4_LAN: C94975.1 U13113.G19(PCIE4_RXP/USB3_10_RXP)
PCIE_RXP4_LAN_R: C94975.2 U13143.30(TX_P)
PCIE_RXP4_TBT: C94580.2 U13113.L24(PCIE8_RXP)
PCIE_TXN1_TBT: C94800.1 U21.Y22(PCIE_RX0_N)
PCIE_TXN1_TBT_C: C94800.2 U13113.D22(PCIE5_TXN)
PCIE_TXN2_TBT: C94802.1 U21.T22(PCIE_RX1_N)
PCIE_TXN2_TBT_C: C94802.2 U13113.B22(PCIE6_TXN)
PCIE_TXN3_TBT: C95876.1 U21.M22(PCIE_RX2_N)
PCIE_TXN3_TBT_C: C95876.2 U13113.C23(PCIE7_TXN)
PCIE_TXN3_WLAN: C94796.1 CN2068.37(PETN0)
PCIE_TXN3_WLAN_C: C94796.2 U13113.B20(PCIE3_TXN/USB3_9_TXN)
PCIE_TXN4_LAN: C94798.1 U13143.36(RX_N)
PCIE_TXN4_LAN_C: C94798.2 U13113.B21(PCIE4_TXN/USB3_10_TXN)
PCIE_TXN4_TBT: C95879.1 U21.H22(PCIE_RX3_N)
PCIE_TXN4_TBT_C: C95879.2 U13113.C24(PCIE8_TXN)
PCIE_TXP1_TBT: C94801.1 U21.Y23(PCIE_RX0_P)
PCIE_TXP1_TBT_C: C94801.2 U13113.C22(PCIE5_TXP)
PCIE_TXP2_TBT: C94803.1 U21.T23(PCIE_RX1_P)
PCIE_TXP2_TBT_C: C94803.2 U13113.A23(PCIE6_TXP)
PCIE_TXP3_TBT: C95877.1 U21.M23(PCIE_RX2_P)
PCIE_TXP3_TBT_C: C95877.2 U13113.B23(PCIE7_TXP)
PCIE_TXP3_WLAN: C94797.1 CN2068.35(PETP0)
PCIE_TXP3_WLAN_C: C94797.2 U13113.C20(PCIE3_TXP/USB3_9_TXP)
PCIE_TXP4_LAN: C94799.1 U13143.35(RX_P)
PCIE_TXP4_LAN_C: C94799.2 U13113.A21(PCIE4_TXP/USB3_10_TXP)
PCIE_TXP4_TBT: C95878.1 U21.H23(PCIE_RX3_P)
PCIE_TXP4_TBT_C: C95878.2 U13113.B24(PCIE8_TXP)
PCIE_WAKE#: Q7849.3(D) Q7886.1(S) Q7889.3(D) Q7891.3(D) R21126.2 R22029.1 R22096.1 U13113.BC13(WAKE#)
PCIE_WAKE#_TBT: Q7886.3(D) R22029.2 R22031.2 U21.W1(GPIO_4)
PCIECOMP_N: R21076.2 U13113.B18(PCIE_RCOMPN)
PCIECOMP_P: R21076.1 U13113.C17(PCIE_RCOMPP)
PD#: C94966.1 D8586.2(ANODE) D8587.2(ANODE) R21475.2 R21478.1 U13108.2(PDB)
PEG_COMP: R194.2 U41.G2(PEG_RCOMP)
PEG_RXN0: C95018.2 U41.E10(PEG_RXN[15])
PEG_RXN0_C: C95018.1 U13114.BH26(PEX_TX0_N)
PEG_RXN1: C95019.2 U41.E11(PEG_RXN[14])
PEG_RXN1_C: C95019.1 U13114.BE26(PEX_TX1_N)
PEG_RXN2: C95010.2 U41.E12(PEG_RXN[13])
PEG_RXN2_C: C95010.1 U13114.BG27(PEX_TX2_N)
PEG_RXN3: C95027.1 U41.E13(PEG_RXN[12])
PEG_RXN3_C: C95027.2 U13114.BH29(PEX_TX3_N)
PEG_RXN4: C95029.1 U41.E14(PEG_RXN[11])
PEG_RXN4_C: C95029.2 U13114.BE29(PEX_TX4_N)
PEG_RXN5: C95031.1 U41.E15(PEG_RXN[10])
PEG_RXN5_C: C95031.2 U13114.BG30(PEX_TX5_N)
PEG_RXN6: C95034.1 U41.E16(PEG_RXN[9])
PEG_RXN6_C: C95034.2 U13114.BH32(PEX_TX6_N)
PEG_RXN7: C95036.1 U41.E17(PEG_RXN[8])
PEG_RXN7_C: C95036.2 U13114.BE32(PEX_TX7_N)
PEG_RXN8: C95038.1 U41.F18(PEG_RXN[7])
PEG_RXN8_C: C95038.2 U13114.BG33(PEX_TX8_N)
PEG_RXN9: C95040.1 U41.D19(PEG_RXN[6])
PEG_RXN9_C: C95040.2 U13114.BH35(PEX_TX9_N)
PEG_RXN10: C95042.1 U41.F20(PEG_RXN[5])
PEG_RXN10_C: C95042.2 U13114.BE35(PEX_TX10_N)
PEG_RXN11: C95044.1 U41.D21(PEG_RXN[4])
PEG_RXN11_C: C95044.2 U13114.BG36(PEX_TX11_N)
PEG_RXN12: C95046.1 U41.F22(PEG_RXN[3])
PEG_RXN12_C: C95046.2 U13114.BH38(PEX_TX12_N)
PEG_RXN13: C95050.1 U41.D23(PEG_RXN[2])
PEG_RXN13_C: C95050.2 U13114.BE38(PEX_TX13_N)
PEG_RXN14: C95052.1 U41.F24(PEG_RXN[1])
PEG_RXN14_C: C95052.2 U13114.BG39(PEX_TX14_N)
PEG_RXN15: C95056.1 U41.D25(PEG_RXN[0])
PEG_RXN15_C: C95056.2 U13114.BG41(PEX_TX15_N)
PEG_RXP0: C95017.2 U41.F10(PEG_RXP[15])
PEG_RXP0_C: C95017.1 U13114.BG26(PEX_TX0)
PEG_RXP1: C95006.2 U41.D11(PEG_RXP[14])
PEG_RXP1_C: C95006.1 U13114.BF26(PEX_TX1)
PEG_RXP2: C95020.2 U41.F12(PEG_RXP[13])
PEG_RXP2_C: C95020.1 U13114.BF27(PEX_TX2)
PEG_RXP3: C95026.1 U41.D13(PEG_RXP[12])
PEG_RXP3_C: C95026.2 U13114.BG29(PEX_TX3)
PEG_RXP4: C95028.1 U41.F14(PEG_RXP[11])
PEG_RXP4_C: C95028.2 U13114.BF29(PEX_TX4)
PEG_RXP5: C95030.1 U41.D15(PEG_RXP[10])
PEG_RXP5_C: C95030.2 U13114.BF30(PEX_TX5)
PEG_RXP6: C95032.1 U41.F16(PEG_RXP[9])
PEG_RXP6_C: C95032.2 U13114.BG32(PEX_TX6)
PEG_RXP7: C95035.1 U41.D17(PEG_RXP[8])
PEG_RXP7_C: C95035.2 U13114.BF32(PEX_TX7)
PEG_RXP8: C95037.1 U41.E18(PEG_RXP[7])
PEG_RXP8_C: C95037.2 U13114.BF33(PEX_TX8)
PEG_RXP9: C95039.1 U41.E19(PEG_RXP[6])
PEG_RXP9_C: C95039.2 U13114.BG35(PEX_TX9)
PEG_RXP10: C95041.1 U41.E20(PEG_RXP[5])
PEG_RXP10_C: C95041.2 U13114.BF35(PEX_TX10)
PEG_RXP11: C95043.1 U41.E21(PEG_RXP[4])
PEG_RXP11_C: C95043.2 U13114.BF36(PEX_TX11)
PEG_RXP12: C95045.1 U41.E22(PEG_RXP[3])
PEG_RXP12_C: C95045.2 U13114.BG38(PEX_TX12)
PEG_RXP13: C95049.1 U41.E23(PEG_RXP[2])
PEG_RXP13_C: C95049.2 U13114.BF38(PEX_TX13)
PEG_RXP14: C95051.1 U41.E24(PEG_RXP[1])
PEG_RXP14_C: C95051.2 U13114.BF39(PEX_TX14)
PEG_RXP15: C95055.1 U41.E25(PEG_RXP[0])
PEG_RXP15_C: C95055.2 U13114.BH41(PEX_TX15)
PEG_TXN0: C94278.1 U13114.BK27(PEX_RX0_N)
PEG_TXN1: C94276.1 U13114.BL29(PEX_RX1_N)
PEG_TXN2: C94274.1 U13114.BM30(PEX_RX2_N)
PEG_TXN3: C94272.1 U13114.BK30(PEX_RX3_N)
PEG_TXN4: C94270.1 U13114.BL32(PEX_RX4_N)
PEG_TXN5: C94268.1 U13114.BM33(PEX_RX5_N)
PEG_TXN6: C94266.1 U13114.BK33(PEX_RX6_N)
PEG_TXN7: C94264.1 U13114.BL35(PEX_RX7_N)
PEG_TXN8: C94262.1 U13114.BM36(PEX_RX8_N)
PEG_TXN9: C94260.1 U13114.BK36(PEX_RX9_N)
PEG_TXN10: C94258.1 U13114.BL38(PEX_RX10_N)
PEG_TXN11: C94256.1 U13114.BM39(PEX_RX11_N)
PEG_TXN12: C94254.1 U13114.BK39(PEX_RX12_N)
PEG_TXN13: C94252.1 U13114.BL41(PEX_RX13_N)
PEG_TXN14: C94250.1 U13114.BM42(PEX_RX14_N)
PEG_TXN15: C94248.1 U13114.BK42(PEX_RX15_N)
PEG_TXP0: C94277.1 U13114.BL27(PEX_RX0)
PEG_TXP1: C94275.1 U13114.BK29(PEX_RX1)
PEG_TXP2: C94273.1 U13114.BM29(PEX_RX2)
PEG_TXP3: C94271.1 U13114.BL30(PEX_RX3)
PEG_TXP4: C94269.1 U13114.BK32(PEX_RX4)
PEG_TXP5: C94267.1 U13114.BM32(PEX_RX5)
PEG_TXP6: C94265.1 U13114.BL33(PEX_RX6)
PEG_TXP7: C94263.1 U13114.BK35(PEX_RX7)
PEG_TXP8: C94261.1 U13114.BM35(PEX_RX8)
PEG_TXP9: C94259.1 U13114.BL36(PEX_RX9)
PEG_TXP10: C94257.1 U13114.BK38(PEX_RX10)
PEG_TXP11: C94255.1 U13114.BM38(PEX_RX11)
PEG_TXP12: C94253.1 U13114.BL39(PEX_RX12)
PEG_TXP13: C94251.1 U13114.BK41(PEX_RX13)
PEG_TXP14: C94249.1 U13114.BM41(PEX_RX14)
PEG_TXP15: C1194.1 U13114.BL42(PEX_RX15)
PEGX_RST#: Q7861.2(G) R21508.2 R21609.1 U13114.BK26(PEX_RST_N)
PEX_PLL_HVDD: C95033.1 R21505.1 U13114.BB30(PEX_PLL_HVDD)
PEX_TERMP: R21506.2 U13114.BL44(PEX_TERMP)
PGDMON: R21232.1 R21234.2 U13113.AR22(RSVD#10-AR22)
PLTRST#: R541.1 R821.1 R21222.1 R21481.1 R21713.2 R21737.2 R21800.2 R21997.2 R67340.1 U21.L4(PERST_N) U13102.4(OUT Y) U13115.2(INA)
PLTRST#_EC: R821.2 U49.22(LPCRST#/GPD2)
PM_SYNC: R21190.2 U41.BM34(PM_SYNC)
PM_SYNC_R: R21190.1 U13113.AJ4(PM_SYNC)
PM_THRMTRIP#: D13070.2(ANODE) Q23.1(EMITTER) R20751.2 R21189.2 U41.J31(THERMTRIP#)
PMON: PC18.2 PR23.1 PR25.1 PR66869.1
PP_CABLE_A: R67137.1 U13155.H10(PP_CABLE)
PROCHOT_EC: C96220.1 Q32.2(G) R815.2 U49.17(LPCPD#/GPE6)
PROCPWRGD: R560.2 R21131.1 U41.BT31(PROCPWRGD) U13113.AM3(PROCPWRGD)
PS_FBVDD_PGOOD: D8595.2(CATHODE2) PR9217.1 Q7828.2(G) U13119.1(B)
PSI: PR9011.1 PR9224.2 R21574.2
PW_VCC3_ANA_PCIE: C94044.2 U21.L16(VCC3P3_ANA_PCIE)
PW_VCC3_ANA_USB: C94599.2 U21.J16(VCC3P3_ANA_USB2)
PWM_LED#: C96254.2 C96255.2 R67385.1 U13159.3(ON1) U13159.5(ON2)
PWM_RST_PCU: Q7948.3(D) R67035.1 R67315.1 R67332.2
PWM_RST_S0: CN2074.5 CN2076.16 R21054.1 R67334.2 R67335.2
PWR_LEVEL: D13095.2(ANODE) Q7859.1(S) R21593.2 R67380.1 U13114.BE6(GPIO12)
R_SPK+: C94961.2 CN2060.4 U13108.45(SPK-OUT-R+)
R_SPK-: C94960.2 CN2060.3 U13108.44(SPK-OUT-R-)
RASTER_SYNC0: TP13112.1 U13114.BA5(GPIO21)
RBIAS: R21482.1 U13143.10(RBIAS)
REGN6V: PC9.1 PR39.1 PU1.24(REGN)
RF_EN: CN2068.56(W_DISABLE1#) R20904.1
RINRVP: CN2039.2 R67350.2 U13157.25(RISENSE-/RVSENSE+)
RIP: C94630.2 L4235.2 R67350.1 U13157.24(RISENSE+)
ROM_CS: R21549.2 U13114.BJ4(ROM_CS_N)
ROM_CS_R: R21548.2 R21549.1 TP13102.1 U13116.1(C\S\) U13117.1(C\S\)
ROM_SCLK: R21538.1 R21541.2 R21550.2 U13114.BK3(ROM_SCLK)
ROM_SCLK_R: R21550.1 TP13105.1 U13116.6(CLK) U13117.6(CLK)
ROM_SI: R21536.1 R21539.2 R21551.1 U13114.BK2(ROM_SI)
ROM_SI_R: R21551.2 TP13104.1 U13116.5(DI(IO0)) U13117.5(SI)
ROM_SO: R21537.1 R21540.2 TP13103.1 U13114.BK4(ROM_SO) U13116.2(DO(IO1)) U13117.2(DO)
RSMRST#: C94814.1 R21129.1 U49.112(RING#/PWRFAIL#/CK32KOUT/LPCRST#)
RST_LED#: R21054.2 U13093.24(R\E\S\E\T\)
RSTN: R21481.2 U13143.2(PERSTN)
RTC_N03: Q7935.2(BASE) R67269.2 R67270.1
RTC_RST#: C94810.1 JP1.2 Q7933.3(D) R21137.2 U13113.BC10(RTCRST#)
RTC_X1: C94819.2 R21217.1 U13113.BC9(RTCX1) Y1001.2
RTC_X2: C94821.2 R21217.2 U13113.BD10(RTCX2) Y1001.1
RVN: C94051.2 CN2039.1 L4234.2 U13157.26(RVSENSE-)
S5_ON: PR100.1 PR131.2 PR174.2 PR266.1 R382.1 U49.100(SSCE0#/GPG2)
S_GPIO: R21236.2 R21242.1 R21281.1 U13113.AR45(GPP_C20/UART2_RXD)
SATA_LED#: R21178.1 U13113.AD44(GPP_E8/SATALED#)
SATA_RXN0_C: CN11.5 R67362.1
SATA_RXP0_C: CN11.6 R67363.1
SATA_TXN0_C: C96241.2 CN11.3
SATA_TXP0_C: C96240.2 CN11.2
SENSEA: R21456.2 R21457.1 U13108.48(JD1)
SENSEA_EC: Q7938.3(COLLECTOR) R21456.1 R67310.1
SENSEB: R22092.1 R22093.1 U13108.47(JD2)
SIO_EXT_SCI#: R21317.2 U49.23(ECSCI#/GPD3) U13113.BA4(GPP_I3/DDPE_HPD3)
SIO_EXT_SMI#: R67213.2 R67291.1
SIO_EXT_SMI#_R: R21090.1 R67213.1 R67214.1 U13113.M45(GPP_G19/SMI#)
SIO_RCIN#: R21089.1 U49.4(KBRST#/GPB6(3)) U13113.AT17(GPP_A0/RCIN#/ESPI_ALERT1#)
SKTOCC_N: R556.2 U41.BR33(SKTOCC#)
SKTOCC_N_R: R556.1 U13113.Y44(GPP_F14)
SM_INTRUDER#: R21231.1 U13113.BE11(INTRUDER#)
SM_RCOMP_0: R195.1 U41.G1(DDR_RCOMP[0])
SM_RCOMP_1: R193.2 U41.H1(DDR_RCOMP[1])
SM_RCOMP_2: R192.1 U41.J2(DDR_RCOMP[2])
SM_VREF: C94889.1 R21406.1 U41.BN13(DDR_VREF_CA)
SMB1ALERT#: R21230.2 R21233.1 U13113.AT27(GPP_B23/SML1ALERT#/PCHHOT#)
SMB_ME0_CLK: R21139.2 U13113.AY44(GPP_C3/SML0CLK)
SMB_ME0_DAT: R21140.2 U13113.BB39(GPP_C4/SML0DATA)
SMB_ME1_CLK: Q7909.4(S) R21143.2 U13113.AW42(GPP_C6/SML1CLK)
SMB_ME1_DAT: Q7909.1(S) R21144.2 U13113.AW45(GPP_C7/SML1DATA)
SMB_ME2_CLK: R21227.1 U13113.BD34(GPP_H10/SML2CLK)
SMB_ME2_DAT: R21228.1 U13113.AW35(GPP_H11/SML2DATA)
SMB_ME3_CLK: R21224.1 U13113.BC35(GPP_H13/SML3CLK)
SMB_ME3_DAT: R21226.1 U13113.BA35(GPP_H14/SML3DATA)
SMB_ME4_CLK: R21221.1 U13113.BD39(GPP_H16/SML4CLK)
SMB_ME4_DAT: R21223.1 U13113.BE34(GPP_H17/SML4DATA)
SMB_PCH_CLK: Q7911.6(D) R21146.2 U13113.AW44(GPP_C0/SMBCLK)
SMB_PCH_DAT: Q7911.3(D) R21147.2 U13113.BB43(GPP_C1/SMBDATA)
SMB_RUN_CLK: CN2062.253(SCL) CN2063.253(SCL) Q7911.1(S) R21174.2
SMB_RUN_DAT: CN2062.254(SDA) CN2063.254(SDA) Q7911.4(S) R21172.2
SMBALERT#: R21274.2 R21276.1 U13113.BB41(GPP_C2/SMBALERT#)
SMDDR_VREF_DQ0_M3: T4.1 U41.BP13(DDR0_VREF_DQ)
SMDDR_VREF_DQ1_M3: C94919.1 R21433.1 U41.BR13(DDR1_VREF_DQ)
SML0ALERT#: R21252.2 R21259.1 U13113.BA40(GPP_C5/SML0ALERT#)
SML2ALERT#: R21220.2 R21229.1 U13113.BD35(GPP_H12/SML2ALERT#)
SPI_CLK: R21245.2 R21249.2 U13103.6(CLK)
SPI_CS0#: R22064.2 R22065.2 R67243.2 U13103.1(C\S\)
SPI_CS0#_UR_ME: R22064.1 U49.101(FSCE#/GPG3)
SPI_HOLD_IO3: R21240.1 R22067.2 U13103.7(IO3/H\O\L\D\)
SPI_SI: R21246.2 R21250.2 U13103.5(IO0/DI)
SPI_SO: R21243.2 R22063.2 U13103.2(IO1/DO)
SPI_WP_IO2: R21253.2 R22066.2 U13103.3(IO2/W\P\)
SPKLN_L: L4237.1 U13157.39(OUT_LN)
SPKLP_L: L4236.1 U13157.40(OUT_LP)
SPKRN_L: L4235.1 U13157.46(OUT_RN)
SPKRP_L: L4234.1 U13157.45(OUT_RP)
SRTC_RST#: C94812.1 Q7934.3(D) R21142.2 U13113.BB10(SRTCRST#)
STEREO_OUT_SRV_HEAD: R21581.2 U13114.BD4(GPIO19)
STRAP0: R21542.1 R21553.2 U13114.BL3(STRAP0)
STRAP1: R21543.1 R21554.2 U13114.BL4(STRAP1)
STRAP2: R21544.1 R21555.2 U13114.BM4(STRAP2)
STRAP3: R21545.1 R21556.2 U13114.BM5(STRAP3)
STRAP4: R21546.1 R21557.2 U13114.BK5(STRAP4)
STRAP5: R21547.1 R21558.2 U13114.BJ5(STRAP5)
SUSACK#: R21125.1 R21153.2 U13113.BB19(GPP_A15/SUSACK#)
SUSB#: U49.119(DSR0#/GPG6) U53.1(INB) U13113.AW15(GPD4/SLP_S3#)
SUSC#: U49.18(RI1#/GPD0(3)) U13113.BD15(GPD5/SLP_S4#)
SUSD: PC62.1 PQ9054.3(D) PQ9055.2(G) PR66972.2
SUSON: PQ8.2(BASE) PR304.2 PR2018.2 PR67224.1 Q7923.2(G) R20892.1 U49.120(TMRI0/GPC4(3))
SUSWARN#: R21125.2 R21151.2 U13113.BD19(GPP_A13/SUSWARN#/SUSPWRDNACK)
SWVGA1: PL9001.1 PR9073.2 PR9074.1 PR9235.1 PU9011.16(SW#1) PU9011.24(SW#2)
SWVGA2: PL9024.1 PR9239.1 PR66975.1 PR66981.2 PU9012.16(SW#1) PU9012.24(SW#2)
SWVGA3: PL9025.1 PR9243.1 PR66977.1 PR66982.2 PU9013.16(SW#1) PU9013.24(SW#2)
SWVGA4: PL9026.1 PR9245.1 PR66979.1 PR66983.2 PU9014.16(SW#1) PU9014.24(SW#2)
SYS_HWPG: D17.1(CATHODE) PR180.1 U49.124(TMRI1/GPC6(3))
SYS_PEX_RST_MON#: R21508.1 R21509.2 R21580.2 U13115.4(OUT Y)
SYS_PEX_RST_MON#_R: R21580.1 R21594.2 U13114.BE2(GPIO16)
SYS_PWROK: R21127.2 R21150.1 R21152.1 R67172.1 U13098.4(OUT Y)
SYS_PWROK_R: R21127.1 R21136.2 R21159.1 U13113.AY1(SYS_PWROK)
SYS_RESET#: R21099.1 U13113.AW1(SYS_RESET#)
SYS_SHDN#: PR179.1 PR186.2 PR3022.2 PU9.6(EN2) Q23.3(COLLECTOR) U49.85(PS2CLK0/CEC/TMB0/GPF0)
SYSTEM_AGND: PR182.2 PR185.2 PR189.2 PR190.2 PR192.2
TBT1_PCIE_RBIAS: R379.1 U21.N16(PCIE_RBIAS)
TBT_BATLOW#: R20862.1 R67157.1 U21.F2(POC_GPIO_4)
TBT_CIO_PLUG_EVENT#: D73.1(CATHODE) R20693.1 R67053.1 R67192.1 R67220.2 U21.W2(GPIO_5)
TBT_DP_HPD: C95834.2 R20830.2 R20865.1 R21883.2 R67072.1 U21.AA2(DPSNK0_HPD)
TBT_DP_HPD_Q: Q7880.2(G) R21882.1 R21883.1
TBT_DPSNK0_DDC_CLK: R67046.1 R67149.1 U21.Y5(DPSNK0_DDC_CLK)
TBT_DPSNK0_DDC_DATA: R67047.1 R67150.1 U21.R4(DPSNK0_DDC_DATA)
TBT_DPSNK1_DDC_CLK: R397.1 U21.Y8(DPSNK1_DDC_CLK)
TBT_DPSNK1_DDC_DATA: R20844.1 U21.N4(DPSNK1_DDC_DATA)
TBT_DPSNK1_HPD: R67048.1 U21.Y6(DPSNK1_HPD)
TBT_DPSRC_HPD: R20689.1 U21.G1(DPSRC_HPD)
TBT_EE_CLK: R67117.1 U21.AB4(EE_CLK) U13076.6(CLK)
TBT_EE_CLK_R: R67117.2 U13155.A3(SPI_CLK)
TBT_EE_CS_N: R20855.1 U21.AC3(EE_CS_N) U13076.1(C\S\) U13155.B3(SPI_SSZ)
TBT_EE_DI: U21.AB3(EE_DI) U13076.5(DI(IO0)) U13155.B4(SPI_MOSI)
TBT_EE_DO: R20854.1 U21.AC4(EE_DO) U13076.2(DO(IO1)) U13155.A4(SPI_MISO)
TBT_EE_WP_N: R20852.2 U21.V1(GPIO_2) U13076.3(W\P\(IO2))
TBT_FORCE_PWR: R20863.1 R67055.1 R67156.2 R67215.2 U21.H4(POC_GPIO_3)
TBT_FORCE_PWR_NL5: R67215.1 R67239.1 U13113.AE45(GPP_E6/DEVSLP2)
TBT_FORCE_PWR_WS1: R67156.1 U13113.AL44(GPP_D9)
TBT_HPD: R20829.1 R20830.1 U13025.32(HPDIN/DCI_CLK)
TBT_HTPLG_NL5: D73.2(ANODE) R17808.1 R67220.1 U13113.AN44(GPP_C22/UART2_RTS#)
TBT_HTPLG_WS1: R67192.2 R67217.2
TBT_I2C_SCL: R20860.2 U21.U2(GPIO_1) U13155.D2(I2C_SCL1)
TBT_I2C_SDA: R20859.2 U21.U1(GPIO_0) U13155.D1(I2C_SDA1)
TBT_JTAG_TCK: R20846.2 U21.T4(TCK)
TBT_JTAG_TDI: R454.2 U21.Y4(TDI)
TBT_JTAG_TDO: R20847.2 U21.W4(TDO)
TBT_JTAG_TMS: R20845.2 U21.V4(TMS)
TBT_MAINON: R20849.1 R67056.1 R67193.1 U21.D2(POC_GPIO_5)
TBT_RBIAS: R402.1 U21.J6(RSENSE)
TBT_RESET_N: R67051.1 R67141.2 U21.F4(RESET_N)
TBT_RSENSE: R402.2 U21.H6(RBIAS)
TBT_SPI_HOLD#: R20853.2 U13076.7(H\O\L\D\(IO3))
TBT_SRC0_CFG1: R20868.1 U21.AA1(GPIO_8)
TBT_SRC0_DDC_CLK: R20858.2 R67152.2 U21.Y2(GPIO_7)
TBT_SRC0_DDC_DATA: R20857.2 R67151.2 U21.Y1(GPIO_6)
TBT_TEST_EN: R396.2 U21.E1(TEST_EN)
TBT_TEST_PWRGD: R20850.2 U21.AB5(TEST_PWR_GOOD)
TBT_XTL25_IN: C13512.2 U21.D22(XTAL_25_IN) Y3.1
TBT_XTL25_OUT: C94581.2 U21.D23(XTAL_25_OUT) Y3.3
TBTA_ACE_GPIO0: R67133.1 R67154.2 R67180.1 U13155.B2(GPIO_0)
TBTA_ACE_GPIO1: R67116.2 U13155.C2(GPIO_1)
TBTA_ACE_GPIO2: R67185.2 U13155.D10(GPIO_2)
TBTA_ACE_GPIO3: T91.1 U13155.G11(GPIO_3)
TBTA_ACE_GPIO6: R67144.1 R67145.1 U13155.G10(GPIO_6)
TBTA_ACE_GPIO7: R67132.1 U13155.D7(GPIO_7)
TBTA_ACE_GPIO8: R67115.2 U13155.H6(GPIO_8)
TBTA_AUX_N: C94569.1 U21.W15(PA_DPSRC_AUX_N)
TBTA_AUX_P: C94568.1 U21.Y15(PA_DPSRC_AUX_P)
TBTA_CA2HD_0_N: CN18.B10(SSRXN1) D13031.2 U21.A21(PA_RX0_N)
TBTA_CA2HD_0_P: CN18.B11(SSRXP1) D13026.2 U21.B21(PA_RX0_P)
TBTA_CA2HD_1_N: CN18.A10(SSRXN2) D13030.2 U21.B15(PA_RX1_N)
TBTA_CA2HD_1_P: CN18.A11(SSRXP2) D13027.2 U21.A15(PA_RX1_P)
TBTA_CC1: C96019.1 CN18.A5(CC1) D13034.2 U13155.K9(RPD_G1) U13155.L9(C_CC1)
TBTA_CC2: C96018.1 CN18.B5(CC2) D13035.2 U13155.K10(RPD_G2) U13155.L10(C_CC2)
TBTA_DBG_CTL1: R67140.1 U13155.E4(DEBUG_CTL1)
TBTA_DBG_CTL2: R67139.1 U13155.D5(DEBUG_CTL2)
TBTA_DEBUG1: R67124.1 U13155.L2(DEBUG1)
TBTA_DEBUG2: R67125.1 U13155.K2(DEBUG2)
TBTA_DIG_AUD_N: R67123.1 U13155.K3(DEBUG4)
TBTA_DIG_AUD_P: R67122.1 U13155.L3(DEBUG3)
TBTA_DPSRC_AUX_N: C94569.2 R67127.1 U13155.J2(AUX_N)
TBTA_DPSRC_AUX_P: C94568.2 R67126.1 U13155.J1(AUX_P)
TBTA_HD2CA_0_N: C94571.1 CN18.A3(SSTXN1) D13029.2
TBTA_HD2CA_0_P: C94572.1 CN18.A2(SSTXP1) D8599.2
TBTA_HD2CA_1_N: C94570.1 CN18.B3(SSTXN2) D13028.2
TBTA_HD2CA_1_P: C13391.1 CN18.B2(SSTXP2) D13025.2
TBTA_HPD: R20864.1 U21.M4(PA_DPSRC_HPD) U13155.C10(GPIO_4)
TBTA_I2C_INT: R20861.2 U21.J4(POC_GPIO_0) U13155.C1(I2C_IRQ1Z)
TBTA_I2C_IRQ2Z: Q7927.1(S) R67131.1 R67176.1 U13155.B6(I2C_IRQ2Z)
TBTA_I2C_IRQ2Z_EC: Q7927.3(D) R67175.1 R67176.2 U49.29(PWM3/GPA3)
TBTA_LDO_BMC: C96010.2 U13155.E1(LDO_BMC)
TBTA_LSRX: R20867.1 U21.A4(PA_LSRX) U13155.K4(LSX_P2R)
TBTA_LSTX: R403.1 U21.A5(PA_LSTX) U13155.L4(LSX_R2P)
TBTA_MRESET: Q7923.3(D) Q7923.6(D) R67121.1 R67174.2 U13155.E11(MRESET)
TBTA_ROSC: R67128.1 U13155.G2(R_OSC)
TBTA_SBU1: CN18.A8(SBU1) D13032.2 U13155.K8(C_SBU1)
TBTA_SBU2: CN18.B8(SBU2) D13033.2 U13155.L8(C_SBU2)
TBTA_SS: C96009.1 U13155.H7(SS)
TBTA_TX0_N: C94571.2 U21.B19(PA_TX0_N)
TBTA_TX0_P: C94572.2 U21.A19(PA_TX0_P)
TBTA_TX1_N: C94570.2 U21.B17(PA_TX1_N)
TBTA_TX1_P: C13391.2 U21.A17(PA_TX1_P)
TBTA_USB2_D_N: U21.D20(PA_USB2_D_N) U13155.K5(USB_RP_N)
TBTA_USB2_D_N_B: CN18.B7(DN2) D13060.2 R67162.2
TBTA_USB2_D_N_T: CN18.A7(DN1) D13036.2 R67160.2
TBTA_USB2_D_P: U21.E20(PA_USB2_D_P) U13155.L5(USB_RP_P)
TBTA_USB2_D_P_B: CN18.B6(DP2) D13061.2 R67161.2
TBTA_USB2_D_P_T: CN18.A6(DP1) D13037.2 R67159.2
TBTA_USB2_N_B: R67162.1 U13155.L7(C_USB_BN)
TBTA_USB2_N_T: R67160.1 U13155.L6(C_USB_TN)
TBTA_USB2_P_B: R67161.1 U13155.K7(C_USB_BP)
TBTA_USB2_P_T: R67159.1 U13155.K6(C_USB_TP)
TBTB_HPD: R67045.1 U21.G2(PB_DPSRC_HPD)
TBTB_I2C_INT: R67153.2 U21.E2(POC_GPIO_1)
TBTB_LSRX: R67044.1 U21.B5(PB_LSRX)
TBTB_LSTX: R67043.1 U21.B4(PB_LSTX)
TEMP_MBAT#: PR8.2 PR14.2 PR18.1 U49.73(ADC7/CTS1#/GPI7(3))
TEMP_MBAT#_CONN: PJ1.5 PJ9028.6 PR14.1
TERM9: C95000.1 R21490.2 R21491.2 R21492.2 R21495.2
THER_ALERT#: R21592.2 R67327.1 U13114.BJ3(GPIO9)
THERMDN: TP13108.1 U13114.BJ1(THERMDN)
THERMDP: TP13109.1 U13114.BJ2(THERMDP)
TMU_CLK_OUT: R20866.1 U21.V2(GPIO_3)
TOBII_WAKE#_EC: CN2079.6 R67166.2
TP_LED_ON: CN2078.1 U49.113(CRX0/GPC0)
TP_ON_OFF: CN2076.9 CN2078.3 R67281.1
TP_PWR_EN: C94788.1 Q7838.2(G) R21065.2
TPCLK: C94790.2 CN2078.9 R21063.2 U49.89(PS2CLK2/GPF4)
TPD_INT#: R20905.1 R67271.1 R67273.2
TPD_INT#_PCH: R21283.2 R67272.1 U13113.AV43(GPP_C10/UART0_RTS#)
TPD_INT#_R: CN2076.7 CN2078.4 Q7843.1(S) R67255.2 R67257.1
TPD_RST: R20902.1 R67339.1
TPDATA: C94789.2 CN2078.8 R21064.2 U49.90(PS2DAT2/GPF5)
TS_DETECT: CN2042.31 R21303.1 U13113.BD22(GPP_A20/ISH_GP2)
TS_EN: C887.1 CN2042.30 R807.2
TS_EN_R: R807.1 R67313.2 U49.81(DAC5/RIG0#/GPJ5(3))
TS_PWR: CN2042.35 R22007.2
TS_VREF: TP13107.1 U13114.BF12(TS_VREF)
TST: R21685.1 R21695.1 U13124.22(TEST)
TX0_HDMI+: CN2044.7(D0+) D13075.2 R21016.2 R22122.2
TX0_HDMI-: CN2044.9(D0-) D13076.2 R21016.1 R22123.2
TX1_HDMI+: CN2044.4(D1+) D13073.2 R21013.2 R22120.2
TX1_HDMI-: CN2044.6(D1-) D13074.2 R21013.1 R22121.2
TX2_HDMI+: CN2044.1(D2+) D13071.2 R21012.2 R22118.2
TX2_HDMI-: CN2044.3(D2-) D13072.2 R21012.1 R22119.2
TXC_HDMI+: CN2044.10(CLK+) D13077.2 R21018.2 R22124.2
TXC_HDMI-: CN2044.12(CLK-) D13078.2 R21018.1 R22125.2
TYPEC_VBUS: C961.1 C963.1 C94624.1 C94625.1 C94626.1 C96028.1 C96030.1 CN18.A4(VBUS#1) CN18.A9(VBUS#2) CN18.B4(VBUS#3) CN18.B9(VBUS#4) D51.1 Q7923.5(G) U13155.A10(SENSEN) U13155.B10(SENSEP) U13155.H11(VBUS#1) U13155.J10(VBUS#2) U13155.J11(VBUS#3) U13155.K11(VBUS#4)
U3_CE: R22048.1 U13124.12(CE)
U3_OS: R21679.1 U13124.30(OS)
UART2_CTS#: R21326.1 U13113.AN43(GPP_C23/UART2_CTS#)
UART2_TXD: R21324.1 U13113.AR39(GPP_C21/UART2_TXD)
UART_MISO: R67119.1 U13155.F2(UART_RX)
UART_MOSI: R67118.1 U13155.E2(UART_TX)
UIF_RST#_R: Q7948.1(S) R67035.2 R67386.2 U13152.24(R\E\S\E\T\)
USB2_COMP: R21085.1 U13113.AG3(USB2_COMP)
USB3_RXN1: L4256.2 R21700.1 U13113.C8(USB3_2_RXN/SSIC_1_RXN)
USB3_RXN1_R: CN2067.5(STDA_SSRX-) L4256.1 R21700.2 TP61.1 U13127.5(I/O-3)
USB3_RXN2: C95511.1 U13113.A9(USB3_3_RXP/SSIC_2_RXP)
USB3_RXN2_C: C95511.2 U13124.2(A1_OUT+)
USB3_RXN2_C_RE: L4248.2 R21675.1 U13124.26(A1IN+)
USB3_RXN2_C_RE_R: CN2064.5(STDA_SSRX-) L4248.1 R21675.2 TP13163.1 U13122.5(I/O-3)
USB3_RXN3: C95515.1 U13113.G11(USB3_4_RXP)
USB3_RXN3_C: C95515.2 U13124.8(A2_OUT+)
USB3_RXN3_C_RE: L4252.2 R21682.1 U13124.20(A2IN+)
USB3_RXN3_C_RE_R: CN2065.5(STDA_SSRX-) L4252.1 R21682.2 TP13175.1 U13123.5(I/O-3)
USB3_RXP1: L4256.3 R21701.1 U13113.B8(USB3_2_RXP/SSIC_1_RXP)
USB3_RXP1_R: CN2067.6(STDA_SSRX+) L4256.4 R21701.2 TP66.1 U13127.6(I/O-4)
USB3_RXP2: C95512.1 U13113.B10(USB3_3_RXN/SSIC_2_RXN)
USB3_RXP2_C: C95512.2 U13124.1(A1_OUT-)
USB3_RXP2_C_RE: L4248.3 R21676.1 U13124.27(A1IN-)
USB3_RXP2_C_RE_R: CN2064.6(STDA_SSRX+) L4248.4 R21676.2 TP13160.1 U13122.6(I/O-4)
USB3_RXP3: C95517.1 U13113.E11(USB3_4_RXN)
USB3_RXP3_C: C95517.2 U13124.7(A2_OUT-)
USB3_RXP3_C_RE: L4252.3 R21683.1 U13124.21(A2IN-)
USB3_RXP3_C_RE_R: CN2065.6(STDA_SSRX+) L4252.4 R21683.2 TP13172.1 U13123.6(I/O-4)
USB3_TXN1: C95538.1 U13113.B12(USB3_2_TXN/SSIC_1_TXN)
USB3_TXN1_C: C95538.2 L4257.2 R21704.1
USB3_TXN1_R: CN2067.8(STDA_SSTX-) L4257.1 R21704.2 TP69.1 U13127.1(I/O-1)
USB3_TXN2: C95513.1 U13113.D13(USB3_3_TXP/SSIC_2_TXP)
USB3_TXN2_C: C95513.2 U13124.5(B1_IN+)
USB3_TXN2_C_RE: C95506.1 U13124.23(B1OUT+)
USB3_TXN2_C_RE_C: C95506.2 L4249.2 R21677.1
USB3_TXN2_C_RE_C_R: CN2064.8(STDA_SSTX-) L4249.1 R21677.2 TP13162.1 U13122.1(I/O-1)
USB3_TXN3: C95518.1 U13113.B13(USB3_4_TXP)
USB3_TXN3_C: C95518.2 U13124.11(B2_IN+)
USB3_TXN3_C_RE: C95520.1 U13124.17(B2OUT+)
USB3_TXN3_C_RE_C: C95520.2 L4253.2 R21684.1
USB3_TXN3_C_RE_C_R: CN2065.8(STDA_SSTX-) L4253.1 R21684.2 TP13174.1 U13123.1(I/O-1)
USB3_TXP1: C95539.1 U13113.A12(USB3_2_TXP/SSIC_1_TXP)
USB3_TXP1_C: C95539.2 L4257.3 R21706.1
USB3_TXP1_R: CN2067.9(STDA_SSTX+) L4257.4 R21706.2 TP71.1 U13127.10(I/O-6)
USB3_TXP2: C95514.1 U13113.C13(USB3_3_TXN/SSIC_2_TXN)
USB3_TXP2_C: C95514.2 U13124.4(B1_IN-)
USB3_TXP2_C_RE: C95507.1 U13124.24(B1OUT-)
USB3_TXP2_C_RE_C: C95507.2 L4249.3 R21678.1
USB3_TXP2_C_RE_C_R: CN2064.9(STDA_SSTX+) L4249.4 R21678.2 TP13167.1 U13122.10(I/O-6)
USB3_TXP3: C95519.1 U13113.A14(USB3_4_TXN)
USB3_TXP3_C: C95519.2 U13124.10(B2_IN-)
USB3_TXP3_C_RE: C95521.1 U13124.18(B2OUT-)
USB3_TXP3_C_RE_C: C95521.2 L4253.3 R21688.1
USB3_TXP3_C_RE_C_R: CN2065.9(STDA_SSTX+) L4253.4 R21688.2 TP13179.1 U13123.10(I/O-6)
USB_BC_ON: U49.97(ID4/GPH4) U13128.4(ILIM_SEL)
USB_CHARGE_ON: R21705.1 U49.96(ID3/GPH3) U13128.5(EN)
USB_CLT1: U49.79(DAC3/TACH1B/GPJ3(3)) U13128.6(CTL1)
USB_OC0#: C96247.1 R21077.1 U13113.AD43(GPP_E9/USB2_OC0#) U13128.13(F\A\U\L\T\)
USB_OC1#: C96248.1 R21078.1 R67212.2 U13113.AD42(GPP_E10/USB2_OC1#) U13121.3(OCB)
USB_OC2#: C96033.1 R21079.1 U13113.AD39(GPP_E11/USB2_OC2#) U13125.3(OCB)
USB_OC3#: R21080.1 R67212.1 U13113.AC44(GPP_E12/USB2_OC3#)
USB_OC4#: R21081.1 U13113.Y43(GPP_F15/USB2_OCB_4)
USB_OC5#: R21082.1 U13113.Y41(GPP_F16/USB2_OCB_5)
USB_OC6#: R21083.1 U13113.W44(GPP_F17/USB2_OCB_6)
USB_OC7#: R21084.1 U13113.W43(GPP_F18/USB2_OCB_7)
USBON#: U49.99(ID6/GPH6) U13121.4(EN) U13125.4(EN)
USBP1+: U13113.AD7(USB2P_2) U13128.3(DP_OUT)
USBP1+_C: L4255.3 R21697.1 U13128.10(DP_IN)
USBP1+_C_R: CN2067.3(D+) L4255.4 R21697.2 TP64.1 U13127.7(I/O-5)
USBP1-: U13113.AD5(USB2N_2) U13128.2(DM_OUT)
USBP1-_C: L4255.2 R21699.1 U13128.11(DM_IN)
USBP1-_C_R: CN2067.2(D-) L4255.1 R21699.2 TP67.1 U13127.4(I/O-2)
USBP2+: L4247.3 R21673.1 U13113.AG10(USB2P_3)
USBP2+_R: CN2064.3(D+) L4247.4 R21673.2 TP13164.1 U13122.7(I/O-5)
USBP2-: L4247.2 R21674.1 U13113.AG8(USB2N_3)
USBP2-_R: CN2064.2(D-) L4247.1 R21674.2 TP13161.1 U13122.4(I/O-2)
USBP3+: L4251.3 R21680.1 U13113.AE2(USB2P_4)
USBP3+_R: CN2065.3(D+) L4251.4 R21680.2 TP13176.1 U13123.7(I/O-5)
USBP3-: L4251.2 R21681.1 U13113.AE1(USB2N_4)
USBP3-_R: CN2065.2(D-) L4251.1 R21681.2 TP13173.1 U13123.4(I/O-2)
USBP4+: L4254.3 R21698.1 U13113.AC3(USB2P_5)
USBP4+_R: CN2066.3(D+) D8596.1 L4254.4 R21698.2 TP13152.1
USBP4-: L4254.2 R21696.1 U13113.AC2(USB2N_5)
USBP4-_R: CN2066.2(D-) D8597.1 L4254.1 R21696.2 TP13153.1
USBP5+: R67147.1 U13113.AF3(USB2P_6)
USBP5+_C: C96021.1 CN2079.4 D13065.1 R67147.2
USBP5-: R67146.1 U13113.AF2(USB2N_6)
USBP5-_C: C96020.1 CN2079.3 D13064.1 R67146.2
USBP6+: CN2068.3(USB_D+) U13113.AB2(USB2P_7)
USBP6-: CN2068.5(NC) U13113.AB3(USB2N_7)
USBP7+: R22008.1 U13113.AL7(USB2P_8)
USBP7+_C: CN2042.21 D13041.1 R22008.2
USBP7-: R22009.1 U13113.AL8(USB2N_8)
USBP7-_C: CN2042.22 D13040.1 R22009.2
USBP8+: R20953.1 U13113.AA2(USB2P_9)
USBP8+_C: CN2042.27 D8553.1 R20953.2
USBP8-: R20954.1 U13113.AA1(USB2N_9)
USBP8-_C: CN2042.28 D8554.1 R20954.2
USBP9+: R21051.1 U13113.AJ7(USB2P_10)
USBP9+_R: CN2049.3 D8567.1 R21051.2
USBP9-: R21050.1 U13113.AJ8(USB2N_10)
USBP9-_R: CN2049.2 D8566.1 R21050.2
USBPWR0: C95524.2 C95525.2 C95526.1 C95527.2 C95532.2 CN2066.1(VBUS) D13094.1 U13125.1(OUT)
USBPWR2: C95528.1 C95529.2 C95530.1 C95531.1 C95533.2 C96263.1 CN2067.1(VBUS) U13127.2(VDD) U13128.12(OUT)
USBPWR3: C95498.2 C95499.2 C95500.1 C95501.2 C95502.2 C95503.2 C95504.1 C95505.2 C95516.2 CN2064.1(VBUS) CN2065.1(VBUS) U13121.1(OUT) U13122.2(VDD) U13123.2(VDD)
VA: PC13.1 PC14.1 PD1.1 PD1.2 PD2.1 PD9007.1 PD9007.2 PJ2.5(V+#1) PJ2.6(V+#2) PR31.1
VA1: PC1.1 PC5.1 PD1.3 PD9007.3 PQ1.5(D) PR16.2
VA2: PC2.1 PQ1.1(S1) PQ1.2(S2) PQ1.3(S3) PR1.1 PR3.1 PR28.1
VCORE_CS1: PR66841.2 PR66941.1
VCORE_CS2: PR66843.2 PR66944.1
VCORE_CS3: PR66844.2 PR66948.1
VCORE_CSUMA: PR66855.2 PR66857.1 PR66858.2 PR66877.1
VCORE_PWM1: PR66825.2 PR66939.1
VCORE_PWM2: PR66826.2 PR66942.1
VCORE_PWM3: PR66827.2 PR66945.1
VGA_XTALIN: C95159.1 U13114.BL6(XTAL_IN) Y1004.1
VGA_XTALOUT: C95160.1 U13114.BM6(XTAL_OUT) Y1004.3
VGPU_CORE_SENSE: PR9009.2 U13114.BK45(VDD_SENSE) U13114.BM45(VDDS_SENSE)
VGT_VCCSENSE: PR66882.1 PR66883.2 R20761.2 U41.AH38(VCCGT_SENSE)
VGT_VSSSENSE: PR66886.2 PR66888.1 R549.1 U41.AH37(VSSGT_SENSE)
VL: PC141.1 PU9.13(VREG5)
VMA_CLK0: U13114.AG45(FBA_CLK0) U13135.K11(CLK_T)
VMA_CLK0#: U13114.AG46(FBA_CLK0_N) U13135.K10(CLK_C)
VMA_CLK1: U13114.AK46(FBA_CLK1) U13136.K11(CLK_T)
VMA_CLK1#: U13114.AK45(FBA_CLK1_N) U13136.K10(CLK_C)
VMA_DQ0: U13114.U51(FBA_D0) U13135.V4(DQ0)
VMA_DQ1: U13114.U48(FBA_D1) U13135.V3(DQ1)
VMA_DQ2: U13114.U50(FBA_D2) U13135.U4(DQ2)
VMA_DQ3: U13114.U49(FBA_D3) U13135.U3(DQ3)
VMA_DQ4: U13114.R51(FBA_D4) U13135.P4(DQ4)
VMA_DQ5: U13114.R50(FBA_D5) U13135.P3(DQ5)
VMA_DQ6: U13114.R47(FBA_D6) U13135.N4(DQ6)
VMA_DQ7: U13114.U46(FBA_D7) U13135.N3(DQ7)
VMA_DQ8: U13114.V46(FBA_D8) U13135.V11(DQ8)
VMA_DQ9: U13114.Y45(FBA_D9) U13135.V12(DQ9)
VMA_DQ10: U13114.Y47(FBA_D10) U13135.U11(DQ10)
VMA_DQ11: U13114.Y46(FBA_D11) U13135.U12(DQ11)
VMA_DQ12: U13114.V50(FBA_D12) U13135.P11(DQ12)
VMA_DQ13: U13114.V47(FBA_D13) U13135.P12(DQ13)
VMA_DQ14: U13114.U52(FBA_D14) U13135.N11(DQ14)
VMA_DQ15: U13114.V51(FBA_D15) U13135.N12(DQ15)
VMA_DQ16: U13114.AJ44(FBA_D16) U13135.B11(DQ16)
VMA_DQ17: U13114.AG48(FBA_D17) U13135.B12(DQ17)
VMA_DQ18: U13114.AJ45(FBA_D18) U13135.C11(DQ18)
VMA_DQ19: U13114.AG49(FBA_D19) U13135.C12(DQ19)
VMA_DQ20: U13114.AF46(FBA_D20) U13135.F11(DQ20)
VMA_DQ21: U13114.AF47(FBA_D21) U13135.F12(DQ21)
VMA_DQ22: U13114.AF48(FBA_D22) U13135.G11(DQ22)
VMA_DQ23: U13114.AD47(FBA_D23) U13135.G12(DQ23)
VMA_DQ24: U13114.AD49(FBA_D24) U13135.B4(DQ24)
VMA_DQ25: U13114.AD48(FBA_D25) U13135.B3(DQ25)
VMA_DQ26: U13114.AC46(FBA_D26) U13135.C4(DQ26)
VMA_DQ27: U13114.AC47(FBA_D27) U13135.C3(DQ27)
VMA_DQ28: U13114.AA47(FBA_D28) U13135.F4(DQ28)
VMA_DQ29: U13114.AA46(FBA_D29) U13135.F3(DQ29)
VMA_DQ30: U13114.AA45(FBA_D30) U13135.G4(DQ30)
VMA_DQ31: U13114.Y44(FBA_D31) U13135.G3(DQ31)
VMA_DQ32: U13114.AW51(FBA_D32) U13136.B4(DQ0)
VMA_DQ33: U13114.BA52(FBA_D33) U13136.B3(DQ1)
VMA_DQ34: U13114.AW50(FBA_D34) U13136.C4(DQ2)
VMA_DQ35: U13114.BA51(FBA_D35) U13136.C3(DQ3)
VMA_DQ36: U13114.BA50(FBA_D36) U13136.F4(DQ4)
VMA_DQ37: U13114.BB50(FBA_D37) U13136.F3(DQ5)
VMA_DQ38: U13114.BA49(FBA_D38) U13136.G4(DQ6)
VMA_DQ39: U13114.AW49(FBA_D39) U13136.G3(DQ7)
VMA_DQ40: U13114.AV48(FBA_D40) U13136.B11(DQ8)
VMA_DQ41: U13114.AT49(FBA_D41) U13136.B12(DQ9)
VMA_DQ42: U13114.AT47(FBA_D42) U13136.C11(DQ10)
VMA_DQ43: U13114.AT48(FBA_D43) U13136.C12(DQ11)
VMA_DQ44: U13114.AT46(FBA_D44) U13136.F11(DQ12)
VMA_DQ45: U13114.AV51(FBA_D45) U13136.F12(DQ13)
VMA_DQ46: U13114.AV52(FBA_D46) U13136.G11(DQ14)
VMA_DQ47: U13114.AV49(FBA_D47) U13136.G12(DQ15)
VMA_DQ48: U13114.AJ48(FBA_D48) U13136.V11(DQ16)
VMA_DQ49: U13114.AJ46(FBA_D49) U13136.V12(DQ17)
VMA_DQ50: U13114.AJ47(FBA_D50) U13136.U11(DQ18)
VMA_DQ51: U13114.AK49(FBA_D51) U13136.U12(DQ19)
VMA_DQ52: U13114.AM47(FBA_D52) U13136.P11(DQ20)
VMA_DQ53: U13114.AM46(FBA_D53) U13136.P12(DQ21)
VMA_DQ54: U13114.AN48(FBA_D54) U13136.N11(DQ22)
VMA_DQ55: U13114.AN49(FBA_D55) U13136.N12(DQ23)
VMA_DQ56: U13114.AM44(FBA_D56) U13136.V4(DQ24)
VMA_DQ57: U13114.AM45(FBA_D57) U13136.V3(DQ25)
VMA_DQ58: U13114.AN45(FBA_D58) U13136.U4(DQ26)
