# Allegro board DAZGLMB1ED0 dazglmb1ed0-d-ver a-165 (.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
C_PEG_TX15: length 9.2
  TOP w0.079: 224.21,122.69 224.23,122.67 224.23,122.67 224.3,122.6 225.56,122.6 225.79,122.36 225.79,122.22 U41.B25
  TOP w0.14: 224.21,122.69 224.04,122.86 223.86,122.86 222.02,124.7 222.02,125.62 221.51,126.13 221.51,126.71 220.61,127.61 220.33,127.61 C1194.2
C_PEG_TX#0: length 13.1
  TOP w0.079: U41.B10 226.18,110.3 226.28,110.19 226.28,110.11 226.15,109.98 225.04,109.98 224.89,110.13 224.49,110.13 224.43,110.2 224.29,110.2 224.23,110.26 224.21,110.26
  TOP w0.14: 224.21,110.26 223.98,110.26 223.89,110.34 222.13,110.34 221.74,110.74 216.07,110.74 215.21,109.87 214.77,109.87 C94278.2
C_PEG_TX#1: length 12
  TOP w0.079: U41.B11 225.91,111.15 225.48,111.58 225,111.58 224.59,111.16 224.22,111.16 224.17,111.22 224.15,111.22
  TOP w0.14: C94276.2 214.75,111.45 223.31,111.45 223.54,111.22 224.15,111.22
C_PEG_TX#2: length 11.3
  TOP w0.079: U41.B12 225.76,111.87 225.71,111.92 225.71,112.11 225.84,112.23 225.84,112.34 225.78,112.4 225.69,112.4 225.56,112.27 225.5,112.27 225.42,112.35 224.52,112.35 224.37,112.2 224.28,112.2 224.17,112.31 224.15,112.31
  TOP w0.14: 224.15,112.31 223.81,112.31 223.66,112.16 216.05,112.16 215.76,112.44 C94274.2
C_PEG_TX#3: length 11.2
  TOP w0.079: U41.B13 225.77,112.8 225.77,112.95 225.57,113.15 225,113.15 224.66,112.81 224.22,112.81 224.17,112.87 224.15,112.87
  TOP w0.14: 224.15,112.87 217.06,112.87 216.56,113.38 216.56,113.48 216.14,113.9 215.91,113.9 215.76,114.04 C94272.2
C_PEG_TX#4: length 12.1
  TOP w0.079: 224.15,113.9 224.17,113.9 224.22,113.84 224.41,113.84 224.49,113.92 225.42,113.92 225.5,113.85 225.56,113.85 225.69,113.98 225.78,113.98 225.84,113.92 225.84,113.81 225.71,113.68 225.71,113.49 225.76,113.45 U41.B14
  TOP w0.14: C94270.2 216.1,115.33 216.1,114.95 217.46,113.59 223.63,113.59 223.94,113.9 224.15,113.9
C_PEG_TX#5: length 9.8
  TOP w0.079: U41.B15 225.73,114.23 225.52,114.44 225.52,114.51 225.31,114.73 225,114.73 224.65,114.37 224.22,114.37 224.17,114.43 224.15,114.43
  TOP w0.14: C94268.2 217.2,114.94 217.2,114.87 217.77,114.3 223.45,114.3 223.58,114.43 224.15,114.43
C_PEG_TX#6: length 13
  TOP w0.079: U41.B16 225.76,115.02 225.71,115.07 225.71,115.23 225.84,115.36 225.84,115.49 225.78,115.55 225.69,115.55 225.56,115.42 225.5,115.42 225.42,115.5 224.52,115.5 224.37,115.35 224.28,115.35 224.17,115.46 224.15,115.46
  TOP w0.14: 224.15,115.46 223.5,115.46 223.07,115.03 218.46,115.03 218.16,115.33 218.16,116.6 217.7,117.06 217.44,117.06 217.3,117.2 216.21,117.2 215.89,117.52 C94266.2
C_PEG_TX#7: length 11.4
  TOP w0.079: U41.B17 225.78,115.94 225.78,116.15 225.62,116.3 225,116.3 224.63,115.93 224.22,115.93 224.17,115.99 224.15,115.99
  TOP w0.14: C94264.2 218.93,117.7 219.43,117.7 219.75,117.38 219.75,116.72 219.45,116.42 218.98,116.42 218.87,116.31 218.87,115.85 218.98,115.74 221.71,115.74 222.19,116.22 223.67,116.22 223.9,115.99 224.15,115.99
C_PEG_TX#8: length 11.4
  TOP w0.079: U41.C18 226.43,116.72 226.43,116.89 226.24,117.09 224.43,117.09 224.3,116.96 224.22,116.96 224.17,117.02 224.15,117.02
  TOP w0.14: C94262.2 218.96,119.23 219.11,119.23 219.28,119.4 219.76,119.4 220.24,118.91 220.24,118.46 220.12,118.35 220.12,118.01 220.62,117.51 220.62,117.01 220.46,116.85 220.46,116.69 220.7,116.45 221.38,116.45 222.09,117.16 222.68,117.16 222.91,116.93 223.67,116.93 223.75,117.02 224.15,117.02
C_PEG_TX#9: length 11.2
  TOP w0.079: 224.21,117.31 224.23,117.31 224.29,117.36 224.71,117.36 225.04,117.69 225.57,117.69 225.64,117.63 225.64,117.48 225.54,117.38 U41.A19
  TOP w0.14: 224.21,117.31 223.16,117.31 222.53,117.94 222.24,117.94 221.74,117.44 221.32,117.44 220.89,117.88 220.89,118.31 221.27,118.69 221.27,118.97 221.13,119.1 220.78,119.1 220.53,119.36 220.53,119.71 220.43,119.8 219.98,119.8 219.72,120.06 219.72,120.51 219.62,120.6 219.31,120.6 219.18,120.48 218.95,120.48 C94260.2
C_PEG_TX#10: length 11.2
  TOP w0.079: U41.C20 226.4,118.32 226.4,118.49 226.24,118.66 224.37,118.66 224.26,118.55 224.21,118.55
  TOP w0.14: C94258.2 217.67,121.63 217.77,121.63 218.15,122.01 219.61,122.01 222.71,118.91 223.01,118.91 223.37,118.55 224.21,118.55
C_PEG_TX#11: length 10.7
  TOP w0.079: U41.A21 225.54,118.96 225.6,119.02 225.6,119.16 225.49,119.27 225.04,119.27 224.72,118.94 224.29,118.94 224.23,118.89 224.21,118.89
  TOP w0.14: C94256.2 217.42,122.75 217.51,122.84 217.66,122.84 217.8,122.7 219.55,122.7 222.89,119.36 223.37,119.36 223.84,118.89 224.21,118.89
C_PEG_TX#12: length 9.8
  TOP w0.079: U41.C22 226.44,119.86 226.44,120.03 226.24,120.24 225.04,120.24 224.91,120.36 224.24,120.36 224.14,120.26 224.04,120.26 223.98,120.32 223.98,120.33 223.97,120.34 223.96,120.34
  TOP w0.14: C94254.2 219.07,123.92 219.71,123.92 223.29,120.34 223.96,120.34
C_PEG_TX#13: length 9.8
  TOP w0.079: U41.A23 225.53,120.53 225.61,120.61 225.61,120.76 225.53,120.84 225.06,120.84 224.94,120.71 224.36,120.71 224.28,120.8 223.92,120.8 223.86,120.74 223.84,120.74
  TOP w0.14: C94252.2 218.67,125.18 218.84,125.18 219.44,124.58 219.68,124.58 223.52,120.74 223.84,120.74
C_PEG_TX#14: length 9
  TOP w0.079: U41.C24 226.43,121.45 226.43,121.62 226.24,121.81 224.91,121.81 224.77,121.96 223.92,121.96 223.86,122.01 223.84,122.01
  TOP w0.14: 223.84,122.01 223.69,122.01 221.25,124.45 221.25,125.37 220.66,125.96 220.46,125.96 C94250.2
C_PEG_TX#15: length 9.2
  TOP w0.079: 224.21,122.42 224.23,122.42 224.26,122.44 225.49,122.44 225.64,122.3 225.64,122.2 225.54,122.11 U41.A25
  TOP w0.14: C94248.2 220.33,127.34 220.5,127.34 221.24,126.6 221.24,126.02 221.75,125.51 221.75,124.59 223.75,122.6 223.92,122.6 224.1,122.42 224.21,122.42
CAD_SNK: length 22.9
  TOP w0.14: Q7832.2 242.22,165.86 242.72,166.36 v1(242.72,166.41) ; v1(252.88,165.78) 252.61,166.05 ESD8.5
  IN3 w0.079: v1(252.88,165.78) 252.55,165.78 251.99,166.34 251.1,166.34 250.46,165.7 248.43,165.7 248.42,165.71 243.42,165.71 v1(242.72,166.41)
  BOTTOM w0.14: R20970.2 v1(252.88,165.78) 252.37,165.27 251.4,165.27 250.59,166.08 v1(250.59,168.72) 250.59,170.18 CN2043.13
CAD_SNK_R_EDP: length 3.6
  TOP w0.14: v1(337.41,72.33) 337.39,72.32 U13079.29
  BOTTOM w0.14: v1(337.41,72.33) 337.41,72.96 337.68,73.23 R67396.1 338.41,73.56 R67381.1
CAP+: length 4.5
  TOP w0.203: U13108.23 27.94,35.12 27.77,35.28 27.44,35.28 27.38,35.34 26.63,35.34 C94929.2 25.87,36.25 v1(26.69,37.08)
CAP-: length 2.2
  TOP w0.178: U13108.24 27.54,34.79 27.47,34.86 26.31,34.86 26.12,35.05 C94929.1
CATERR#: length 8.1
  TOP w0.14: v1(263.61,125.42) 263.28,125.75 U41.BM30 ; R571.1 270.18,125.67 v1(269.9,125.95)
  BOTTOM w0.14: v1(269.9,125.95) 269.64,125.95 268.88,125.19 266.09,125.19 265.83,124.93 v1(265.4,124.93) 264.07,124.93 263.61,125.4 v1(263.61,125.42)
CCD_PWR: length 5.9
  TOP w0.203: v1(357.4,79.14) 357.22,78.96 C94682.2
  TOP w0.254: CN2042.36 356.85,80.17 357.04,79.98 357.04,79.75 356.86,79.57 C94682.2
  BOTTOM w0.203: v1(357.55,78.48) 357.4,78.63 v1(357.4,79.14)
  BOTTOM w0.508: v1(357.4,79.14) 357.14,79.4 C94683.2 357.14,81.08 R20955.2
CFG2: length 19.4
  TOP w0.14: R20767.1 273.58,111.23 273.58,111.62 274.19,112.23 v1(274.19,112.28) ; v1(263.61,123.06) 263.93,122.74 U41.BN26
  BOTTOM w0.14: v1(263.61,123.06) 263.61,122.89 v1(264.07,122.43) 264.28,122.22 264.94,122.22 265.43,121.73 265.43,118.55 270.86,113.13 271.9,113.13 272.74,112.28 v1(274.19,112.28)
CFG3: length 13.5
  TOP w0.127: v1(264.26,123.85) 264.26,123.92 U41.BN28
  TOP w0.14: v1(273.17,126.64) 273.55,127.02 R124.1
  BOTTOM w0.14: v1(264.26,123.85) 264.72,123.85 264.94,124.07 268.07,124.07 268.17,123.97 270.07,123.97 270.42,124.32 273.22,124.32 273.83,124.93 273.83,126.33 273.53,126.64 v1(273.17,126.64)
CFG4: length 10.4
  TOP w0.14: R20768.1 272.97,114.24 272.11,113.38 271.45,113.38 269.09,115.74 v1(268.96,115.74) 268.88,115.74 266.25,118.37 265.66,118.37 U41.BR20
CFG5: length 12.2
  TOP w0.14: U41.BM20 263.61,117.62 v1(263.61,117.55) ; v1(271.29,112.36) 271.47,112.18 271.47,111.6 272.03,111.04 R20765.1
  BOTTOM w0.14: v1(263.61,117.55) 263.61,117.54 264.12,117.03 266.16,117.03 270.83,112.36 v1(271.29,112.36)
CFG6: length 9.4
  TOP w0.14: R20766.1 272.56,113.1 271.33,113.1 269.48,114.96 268.36,114.96 267.13,116.2 267.13,116.98 266.17,117.94 U41.BT20
CFG7: length 11.7
  TOP w0.14: v1(271.95,111.85) 272.45,111.35 R67188.1 ; v1(264.91,117.55) 264.58,117.87 U41.BP20
  BOTTOM w0.14: v1(271.95,111.85) 271.95,112.67 271.77,112.85 270.74,112.85 266.04,117.55 v1(265.65,117.55) v1(264.91,117.55)
CFG10: length 9.7
  TOP w0.14: R20764.1 v1(272.16,115.21) 270.71,115.21 268.55,117.36 268.55,117.95 266.88,119.62 266.69,119.62 266.01,120.3 U41.BT23
CFG12: length 12
  TOP w0.127: v1(262.96,117.55) 262.96,117.48 U41.BM19
  TOP w0.14: R20763.1 271.06,111.38 270.99,111.45 v1(270.99,111.73)
  BOTTOM w0.14: v1(262.96,117.55) 262.96,117.44 263.72,116.68 266.12,116.68 270.99,111.81 v1(270.99,111.73)
CFG13: length 10.3
  TOP w0.14: R20762.1 272.06,112.31 271.54,112.82 271.22,112.82 269.36,114.68 268.19,114.68 266.85,116.02 266.85,116.81 266.13,117.52 265.6,117.52 U41.BR19
CFG_RCOMP: length 8.5
  TOP w0.14: R129.1 272.82,123.31 272.8,123.33 270.42,123.33 v1(270.3,123.21) 270.12,123.21 268.04,121.12 267.53,121.12 266.78,121.88 U41.BT25
CHA_SA0: length 8.4
  TOP w0.254: v1(211.73,57.09) 212.16,56.66 212.16,54.86 212.43,54.58 CN2063.256
  BOTTOM w0.254: R21389.1 213.58,54.35 R21392.2 213.05,54.88 213.05,55.34
  BOTTOM w0.305: 213.05,55.34 213.05,56.18 212.14,57.09 v1(211.73,57.09)
CHA_SA1: length 6.5
  TOP w0.254: v1(211.63,56.43) 211.04,55.85 211.04,54.83 211.43,54.44 CN2063.260
  BOTTOM w0.254: R21390.1 211.86,54.45 211.95,54.55 R21393.2 212.36,54.98
  BOTTOM w0.305: v1(211.63,56.43) 211.96,56.43 212.36,56.02 v1(212.36,55.85) 212.36,54.98
CHA_SA2: length 8.4
  TOP w0.14: CN2063.166 234.94,54.81 234.84,54.91 234.84,55.77 v1(235.33,56.26)
  BOTTOM w0.14: v1(235.33,56.26) 235.24,56.18 234.54,56.18 233.9,55.54 233.9,54.75 v1(233.73,54.58) 233.49,54.34 233.49,53.58 R21394.2 232.91,53.28 232.46,52.83 R21391.1
CHB_SA0: length 4.3
  TOP w0.254: CN2062.256 212.43,68.04 v1(211.86,68.62)
  BOTTOM w0.254: 211.25,69.05 211.68,68.62 v1(211.86,68.62)
  BOTTOM w0.305: R21416.1 R21419.2 211.25,69.05
CHB_SA1: length 4.2
  TOP w0.254: v1(211.83,67.91) 211.43,67.52 CN2062.260
  BOTTOM w0.305: v1(211.83,67.91) 211.83,67.1 v1(211.81,67.07) 211.01,67.07 R21420.2 R21417.1
CHB_SA2: length 7
  TOP w0.14: v1(235.12,69.16) 234.69,68.72 234.69,68.14 234.94,67.9 CN2062.166
  BOTTOM w0.14: v1(235.12,69.16) 234.08,68.11 R21421.2 R21418.1
CLK_CPU_BCLKN: length 146.7
  TOP w0.079: 224.18,127.33 224.18,127.33 224.24,127.28 224.37,127.28 224.64,127.01 225.23,127.01 225.34,127.12 225.34,127.19 U41.A32
  TOP w0.14: 224.18,127.33 224.13,127.33 224.07,127.39 224.07,127.54 224.16,127.63 v1(224.59,127.63) ; v1(295.11,51.57) 295.22,51.68 295.22,52.96 295.12,53.06 U13113.H2
  IN5 w0.089: v1(295.11,51.57) 294.88,51.81 294.79,51.81 294.62,51.97 294.62,52.33 294.41,52.54 293.52,52.54 293.26,52.8 292.76,52.8 292.12,53.43 292.12,53.94 290.95,55.11 289.92,55.11 289.42,55.61 289.42,56.27 288.34,57.35 287.2,57.35 285.66,58.88 284.82,58.88 282.47,61.24 282.47,66.72 282.02,67.16 282.02,72.41 280.22,74.21 280.22,77.88 266.03,92.07 225.66,92.07 213.18,104.55 213.18,109.77 216.32,112.91 218.72,112.91 222.13,116.32 222.13,125.03 223.97,126.87 223.97,127.47 224.01,127.51 224.13,127.63 v1(224.59,127.63)
CLK_CPU_BCLKP: length 146.8
  TOP w0.079: U41.B31 225.89,126.85 224.58,126.85 224.31,127.12 224.23,127.12 224.18,127.07
  TOP w0.102: U13113.G2 294.57,53.24 294.98,52.82
  TOP w0.14: v1(294.45,51.57) 294.98,52.1 294.98,52.82 ; v1(223.62,127.63) 223.81,127.44 223.81,127.28 224.02,127.07 224.18,127.07
  IN5 w0.089: v1(294.45,51.57) 294.45,52.26 294.34,52.38 293.45,52.38 293.19,52.63 292.69,52.63 291.95,53.36 291.95,53.87 290.88,54.94 289.85,54.94 289.25,55.54 289.25,56.2 288.27,57.18 287.13,57.18 285.59,58.72 284.75,58.72 282.3,61.17 282.3,66.65 281.85,67.09 281.85,72.34 280.05,74.14 280.05,77.81 265.96,91.9 225.59,91.9 213.01,104.48 213.01,109.83 216.25,113.07 218.65,113.07 221.97,116.39 221.97,125.1 223.8,126.94 223.8,127.44 v1(223.62,127.63)
CLK_DPLL_NSCCLKN: length 150.9
  TOP w0.079: 224.09,126.5 224.11,126.52 224.18,126.52 224.36,126.69 225.53,126.69 225.71,126.51 227.45,126.51 227.57,126.63 227.57,126.95 227.71,127.09 227.71,127.2 227.64,127.27 227.48,127.27 227.21,127 U41.D31
  TOP w0.14: 224.09,126.5 223.69,126.1 222.83,126.1 222.56,126.37 222.56,126.6 222.65,126.69 v1(222.84,126.69) ; v1(291.13,53.41) 291.08,53.41 290.74,53.06 290.74,52.66 291.03,52.37 291.03,52.08 291.51,51.6 293.21,51.6 294.15,52.54 294.15,52.65 U13113.F1
  IN5 w0.089: v1(291.13,53.41) 291.03,53.41 290.7,53.74 290.7,54.25 290.47,54.47 289.63,54.47 288.78,55.32 288.78,55.93 288.01,56.71 286.94,56.71 285.46,58.18 284.51,58.18 281.8,60.89 281.8,66.47 281.38,66.89 281.38,72.14 279.58,73.95 279.58,77.55 265.73,91.41 223.85,91.41 212.88,102.38 212.88,103.82 212.54,104.16 212.54,110.09 216,113.54 218.45,113.54 221.47,116.56 221.47,125.32 v1(222.84,126.69)
CLK_DPLL_NSCCLKP: length 150.9
  TOP w0.079: 224.28,126.32 224.3,126.33 224.3,126.41 224.42,126.54 225.46,126.54 225.65,126.35 227.51,126.35 227.73,126.57 227.73,126.7 U41.E31
  TOP w0.14: v1(222.11,126.69) 222.3,126.5 222.3,126.26 222.72,125.84 223.8,125.84 224.28,126.32 ; U13113.G1 294.62,52.63 294.32,52.33 293.32,51.34 291.4,51.34 290.74,52 290.74,52.29 290.47,52.56 v1(290.47,53.41)
  IN5 w0.089: v1(290.47,53.41) 290.53,53.47 290.53,54.18 290.4,54.3 289.57,54.3 288.62,55.25 288.62,55.86 287.94,56.54 286.87,56.54 285.39,58.02 284.44,58.02 281.63,60.82 281.63,66.4 281.21,66.82 281.21,72.07 279.41,73.88 279.41,77.48 265.66,91.24 223.78,91.24 212.72,102.31 212.72,103.75 212.37,104.09 212.37,110.16 215.93,113.71 218.38,113.71 221.3,116.63 221.3,125.39 222.35,126.43 222.35,126.64 222.29,126.69 v1(222.11,126.69)
CLK_PCI_EC: length 198.4
  TOP w0.14: R21095.2 C94804.1 319.67,59.42 320.25,60 321.55,60 v1(321.84,60.29) ; v1(180.35,59.22) 180.69,59.56 180.69,60.21 180.1,60.8 U49.13
  IN1 w0.089: v1(186.53,46.65) 186.53,47.62 188.44,49.52 189.69,49.52 189.76,49.45 189.97,49.24 194.11,49.24 195.66,47.68 202.79,47.68 203.63,46.84 232.27,46.84 233.1,47.68 236.76,47.68 237.56,46.88 256.17,46.88 256.84,47.55 263.92,47.55 264.28,47.18 265.93,47.18 267.22,48.48 268.1,48.48 268.6,48.98 288.34,48.98 289.02,48.3 291.37,48.3 293.03,46.64 310.62,46.64 311.06,47.08 317.48,47.08 318.36,46.21 321.21,46.21 321.48,46.47 321.48,47.01 322.09,47.62 322.09,48.97 323.84,50.72 323.84,54.82 322.98,55.68 322.98,56.23 323.62,56.86 323.62,59.15 322.47,60.29 v1(321.84,60.29)
  BOTTOM w0.14: v1(186.53,46.65) 185.07,48.11 182.84,48.11 182.1,48.85 181.13,48.85 180.48,49.5 180.48,49.58 180.23,49.82 180.23,50.72 180.87,51.35 183.54,51.35 184.7,52.52 184.7,54.25 186.08,55.62 186.08,57.44 185.31,58.21 185.31,62.43 184.88,62.86 182.21,62.86 181.31,61.95 181.31,61.62 180.61,60.92 R817.2 180.68,60.6 180.68,59.72 180.35,59.39 v1(180.35,59.22)
CLK_PCI_EC_R: length 7.7
  TOP w0.102: R21095.1 317.7,59.21 317.7,59.63 317.24,60.09 316.3,60.09 316.22,60.16 316.22,60.37 316.3,60.44 316.3,60.62 315.62,61.31 315.49,61.31 315.13,60.95 314.92,60.95 314.56,60.59 313.23,60.59 313.04,60.46 312.63,60.46 U13113.BC17
CLK_PCI_LPC: length 295.5
  IN5 w0.089: v1(63.09,44.03) 63.09,42.97 63.37,42.69 64.21,42.69 64.87,42.03 68.07,42.03 68.85,41.24 72.03,41.24 73.17,42.38 75.61,42.38 75.76,42.23 83.36,42.23 83.77,42.65 85.64,42.65 88.1,45.11 91.39,45.11 92.8,46.52 93.93,46.52 95.33,47.91 97.63,47.91 98.04,48.33 177.03,48.33 177.46,48.76 177.46,49.32 177.72,49.57 179.85,49.57 180.66,48.76 182.2,48.76 182.47,48.49 189.84,48.49 190.07,48.72 198.52,48.72 198.88,48.36 203.57,48.36 204.44,47.49 233.17,47.49 233.57,47.88 250.22,47.88 250.62,47.49 256.18,47.49 256.57,47.88 258.26,47.88 259.63,49.26 264.07,49.26 264.99,50.18 268.64,50.18 269.09,49.73 287.52,49.73 289.07,48.18 301.95,48.18 302.69,48.92 312.83,48.92 313.3,49.39 315.31,49.39 316.38,48.33 322.13,48.33 323.28,49.47 325.25,49.47 327.05,51.26 327.05,52.9 v1(327.07,52.92)
  BOTTOM w0.14: v1(63.09,44.03) 63.09,44.54 63.32,44.78 63.32,45.53 63.06,45.79 63.06,46.42 63.32,46.68 63.32,48.42 62.68,49.06 62.68,49.19 62.28,49.6 62.28,53.53 61.45,54.36 R21718.2 ; R21096.2 C94805.1 326.42,56.87 326.16,56.61 326.16,55.4 326.48,55.08 326.48,53.52 v1(327.07,52.92)
CLK_PCI_LPC_R: length 18.4
  TOP w0.14: U13113.AV19 309.87,61.8 309.44,61.36 v2(309.44,61.27)
  IN1 w0.089: v1(322.9,58.79) 322.68,59.02 321.53,59.02 320.42,60.13 313.36,60.13 312.69,60.8 311.63,60.8 311.6,60.77 309.94,60.77 v2(309.44,61.27)
  BOTTOM w0.14: R21096.1 325.51,58.77 324.76,58.77 324.38,58.39 v1(323.87,58.39) 323.31,58.39 v1(322.9,58.79)
CLK_PCIE_LANN: length 76.9
  TOP w0.14: U13113.E5 293.79,54.53 294.08,54.53 v2(294.23,54.37) ; U13143.32 346.86,72.74 346.54,73.05 341.64,73.05 341.15,72.57 341.15,67.98 341,67.83 341,67.09 v1(340.84,66.92)
  IN5 w0.089: v1(340.84,66.92) 341.05,66.71 341.05,66.32 340.86,66.13 339.15,66.13 337.9,64.88 337.9,63.63 337.69,63.43 336.45,63.43 334.37,61.35 332.02,61.35 330.85,60.18 330.2,60.18 329.32,59.29 327.84,59.29 326.37,57.82 326.37,56.87 325.54,56.04 323.43,56.04 323.33,55.94 318.64,55.94 317.73,55.02 315.7,55.02 314.06,53.38 306.05,53.38 305.63,53.8 304.84,53.8 304.44,54.21 304.44,58 303.04,59.4 302.71,59.4 302.51,59.6 302.12,59.6 301.35,58.83 299.77,58.83 299.2,58.26 298.85,58.26 298.44,58.67 297.46,58.67 297.4,58.6 296.17,58.6 295.18,57.62 294.8,57.62 294.37,57.19 294.37,56.17 293.63,55.43 293.63,55.02 294.23,54.42 v2(294.23,54.37)
CLK_PCIE_LANP: length 76.9
  TOP w0.14: v1(341.56,66.92) 341.27,67.21 341.27,67.72 341.42,67.87 341.42,72.46 341.75,72.79 346.43,72.79 346.75,72.47 346.98,72.47 347.11,72.34 U13143.33 ; U13113.G4 294.69,54.54 v2(294.25,54.98)
  IN5 w0.089: v2(294.25,54.98) 294.25,54.83 294.2,54.78 294.11,54.78 293.8,55.09 293.8,55.36 294.53,56.1 294.53,57.12 294.87,57.46 295.25,57.46 296.23,58.44 297.47,58.44 297.53,58.5 298.38,58.5 298.78,58.09 299.27,58.09 299.84,58.67 301.42,58.67 302.18,59.43 302.44,59.43 302.64,59.23 302.97,59.23 304.27,57.94 304.27,54.14 304.77,53.64 305.56,53.64 305.98,53.21 314.13,53.21 315.77,54.86 317.8,54.86 318.71,55.77 323.4,55.77 323.5,55.87 325.61,55.87 326.54,56.8 326.54,57.75 327.91,59.13 329.39,59.13 330.27,60.01 330.92,60.01 332.09,61.18 334.44,61.18 336.52,63.26 337.76,63.26 338.06,63.56 338.06,64.81 339.22,65.96 340.93,65.96 341.22,66.25 341.22,66.84 341.37,67 341.48,67 v1(341.56,66.92)
CLK_PCIE_NGFF1_N: length 283.3
  TOP w0.14: R22209.2 33.41,60.04 v1(33.04,60.04) 32.67,60.04 R22206.1 ; U13113.U5 299.25,54.63 v2(298.95,54.93)
  IN5 w0.089: v1(33.04,60.04) 33.27,60.27 45.6,60.27 46.6,59.27 51.19,59.27 54.1,56.36 56.11,56.36 57.67,54.8 58.1,54.8 58.78,54.13 58.78,53.36 60.64,51.5 61.81,51.5 64.66,48.64 66.12,48.64 67.57,47.19 72.18,47.19 72.72,46.65 75,46.65 75.38,46.28 85.08,46.28 86.6,47.8 90.28,47.8 91.69,49.2 92.82,49.2 94.63,51.02 127.23,51.02 127.71,51.5 154.25,51.5 154.73,51.02 174.54,51.02 176.78,53.26 179.89,53.26 180.4,53.77 183.42,53.77 184.01,54.37 191.09,54.37 191.18,54.27 196.98,54.27 197.35,54.64 197.81,54.64 198.18,54.27 202.73,54.27 204.02,52.98 256.18,52.98 256.25,53.06 263.74,53.06 264.34,53.65 270.17,53.65 270.49,53.33 280.11,53.33 280.94,52.5 289.1,52.5 290.13,51.48 293.53,51.48 294.01,51 296.24,51 296.81,51.57 296.81,51.92 298.47,53.58 298.47,54.99 298.62,55.13 298.75,55.13 v2(298.95,54.93)
CLK_PCIE_NGFF1_N_Q: length 74.6
  TOP w0.14: R22206.2 31.08,59.78 v1(30.91,59.96)
  IN2 w0.089: v1(65.2,28.67) 65.2,28.85 65.07,28.97 64.88,28.97 64.65,29.21 64.65,30.25 63.7,31.19 54.97,31.19 54.68,30.9 50.96,30.9 49.53,32.34 48.69,32.34 46.94,34.09 41.25,34.09 40.64,34.7 39.49,34.7 39.06,34.26 37.65,34.26 36.49,33.1 36.49,31.61 35.28,30.4 32.89,30.4 32.24,31.04 32.24,33 31.23,34.01 31.23,37.08 31.91,37.75 31.91,39.3 33.25,40.65 33.25,43.25 32.93,43.58 31.9,43.58 31.34,44.14 31.34,45.76 32.14,46.56 32.14,59.61 31.57,60.17 31.12,60.17 v1(30.91,59.96)
  BOTTOM w0.14: R22204.1 66.05,28.47 65.93,28.59 65.55,28.59 65.48,28.67 v1(65.2,28.67)
CLK_PCIE_NGFF1_N_R: length 14
  TOP w0.14: v1(69.9,21.15) 69.74,20.99 CN2069.53
  IN4 w0.089: v1(67.48,28.41) 67.74,28.67 67.74,28.75 67.9,28.91 69.12,28.91 71.27,26.76 71.27,22.78 70.15,21.66 70.15,21.41 v1(69.9,21.15)
  BOTTOM w0.14: R22202.1 67.81,28.08 v1(67.48,28.41) 67.15,28.41 R22204.2
CLK_PCIE_NGFF1_N_RE: length 55.7
  TOP w0.14: R22187.1 47.22,56.3 v1(46.3,56.3) 46.1,56.1 R22170.1
  IN4 w0.089: v1(71.14,30.01) 70.94,30.22 70.94,30.62 70.21,31.35 59.47,31.35 58.26,32.55 58.26,37 58.86,37.6 58.86,39.02 58.43,39.45 58.43,41.19 58.67,41.42 58.67,42.24 58.08,42.83 53.79,42.83 52.94,43.67 52.94,48.51 53.43,48.99 53.43,50 52.9,50.53 51.42,50.53 49.53,52.42 46.74,52.42 45.95,53.21 45.95,55.28 45.76,55.47 45.76,56.39 45.91,56.54 46.06,56.54 v1(46.3,56.3)
  BOTTOM w0.14: R22202.2 69.32,28.49 70.37,28.49 70.91,29.03 70.91,29.79 v1(71.14,30.01)
CLK_PCIE_NGFF1_P: length 283.2
  TOP w0.14: R22207.1 32.66,60.68 v1(33.04,60.68) 33.42,60.68 R22208.2 ; v2(299,55.54) 299.15,55.39 U13113.U7
  IN5 w0.089: v2(299,55.54) 298.76,55.3 298.55,55.3 298.3,55.06 298.3,53.65 296.64,51.99 296.64,51.64 296.17,51.17 294.08,51.17 293.6,51.65 290.19,51.65 289.17,52.67 281.01,52.67 280.18,53.5 270.56,53.5 270.24,53.82 264.27,53.82 263.67,53.22 256.18,53.22 256.11,53.15 204.09,53.15 202.8,54.44 198.25,54.44 197.88,54.8 197.28,54.8 196.91,54.44 191.25,54.44 191.16,54.53 183.94,54.53 183.35,53.94 180.33,53.94 179.82,53.43 176.71,53.43 174.47,51.18 154.8,51.18 154.32,51.66 127.64,51.66 127.16,51.18 94.56,51.18 92.75,49.37 91.62,49.37 90.21,47.96 86.54,47.96 85.02,46.44 75.45,46.44 75.07,46.82 72.79,46.82 72.25,47.36 67.63,47.36 66.19,48.81 64.73,48.81 61.88,51.67 60.71,51.67 58.95,53.43 58.95,54.19 58.17,54.97 57.74,54.97 56.18,56.53 54.17,56.53 51.26,59.44 46.66,59.44 45.67,60.43 33.29,60.43 v1(33.04,60.68)
CLK_PCIE_NGFF1_P_Q: length 74.5
  TOP w0.14: v1(30.88,60.67) 31.14,60.93 R22207.2
  IN2 w0.089: v1(30.88,60.67) 31.21,60.34 31.64,60.34 32.3,59.68 32.3,46.49 31.51,45.69 31.51,44.21 31.97,43.75 33,43.75 33.42,43.32 33.42,40.58 32.07,39.23 32.07,37.68 31.4,37.01 31.4,34.08 32.41,33.07 32.41,31.11 32.96,30.56 35.21,30.56 36.32,31.68 36.32,33.17 37.58,34.43 38.99,34.43 39.42,34.87 40.71,34.87 41.32,34.26 47.01,34.26 48.76,32.5 49.6,32.5 51.03,31.07 54.61,31.07 54.9,31.36 63.77,31.36 64.82,30.32 64.82,29.28 64.95,29.14 65.08,29.14 v1(65.27,29.33)
  BOTTOM w0.14: v1(65.27,29.33) 65.27,29.25 65.66,28.86 65.87,28.86 66.05,29.04 R22205.1
CLK_PCIE_NGFF1_P_R: length 13.9
  TOP w0.14: v1(70.58,21.15) 70.24,20.81 CN2069.55
  IN4 w0.089: v1(67.48,29.07) 69.19,29.07 71.43,26.83 71.43,22.71 70.32,21.59 70.32,21.41 v1(70.58,21.15)
  BOTTOM w0.14: R22203.1 67.61,29.2 v1(67.48,29.07) 66.96,29.07 R22205.2
CLK_PCIE_NGFF1_P_RE: length 55.7
  TOP w0.14: R22169.1 46.25,56.99 v1(46.27,56.96) 47.27,56.96 R22188.1
  IN4 w0.089: v1(46.27,56.96) 46.02,56.71 45.84,56.71 45.6,56.46 45.6,55.4 45.78,55.22 45.78,53.14 46.67,52.25 49.46,52.25 51.35,50.36 52.83,50.36 53.26,49.93 53.26,49.06 52.78,48.57 52.78,43.6 53.72,42.66 58.01,42.66 58.5,42.17 58.5,41.49 58.26,41.25 58.26,39.38 58.69,38.95 58.69,37.67 58.09,37.07 58.09,32.48 59.4,31.18 70.14,31.18 70.77,30.55 70.77,30.15 70.61,29.99 v1(70.38,29.99)
  BOTTOM w0.14: R22203.2 69.36,28.76 70.26,28.76 70.64,29.14 70.64,29.72 v1(70.38,29.99)
CLK_PCIE_NGFF2_N: length 310.2
  TOP w0.14: v1(44.45,24.88) 44.65,24.88 44.93,24.6 44.93,23.58 44.82,23.47 R22200.1 ; U13113.W10 300.91,56.92 v2(301.21,56.61)
  IN5 w0.089: v2(301.21,56.61) 300.98,56.84 300.82,56.84 300.76,56.78 300.76,54.32 299.87,53.43 299.87,51.93 300.68,51.12 300.68,49.93 299.57,48.82 289.28,48.82 287.77,50.33 269.33,50.33 268.88,50.78 264.73,50.78 264.34,50.38 259.91,50.38 258.01,48.48 233.32,48.48 232.92,48.09 230.66,48.09 229.79,48.96 199.13,48.96 198.76,49.32 195.49,49.32 194.69,50.12 190.2,50.12 189.71,49.62 189.17,49.62 189.01,49.46 186.21,49.46 185.64,50.03 185.64,50.41 185.41,50.64 179.02,50.64 178.6,50.21 176.72,50.21 175.43,48.93 97.79,48.93 97.38,48.51 95.08,48.51 93.68,47.11 92.55,47.11 91.15,45.71 87.83,45.71 85.76,43.64 80.8,43.64 80.33,43.17 74.09,43.17 73.96,43.04 67.79,43.04 67.36,43.48 66.67,43.48 66.22,43.03 65.61,43.03 64.02,44.62 62.74,44.62 62.45,44.32 61.79,44.32 59.9,42.43 52.37,42.43 52.2,42.27 51.16,42.27 49.35,40.45 41.7,40.45 41.48,40.24 41.14,40.24 40.76,39.86 40.76,38.55 39.42,37.2 37.49,37.2 36.34,36.06 36.34,33.18 37.71,31.8 37.71,26.05 37.41,25.75 37.41,24.71 39.44,22.67 43.78,22.67 44.88,23.77 44.88,24.81 44.8,24.88 v1(44.45,24.88)
CLK_PCIE_NGFF2_N_R: length 4.6
  TOP w0.14: R22200.2 44.69,22.46 v1(44.69,21.89) 44.84,21.74 44.84,21.56 44.63,21.34 44.13,21.34 43.86,21.07 43.86,20.92 43.74,20.8 CN2070.53
  BOTTOM w0.14: v1(44.69,21.89) 44.69,22.55 R22198.1
CLK_PCIE_NGFF2_N_RE: length 49.1
  TOP w0.14: R22194.1 33.01,54.96 v1(33.07,54.91) 33.12,54.96 R22193.1
  BOTTOM w0.14: R22198.2 44.81,23.47 45,23.66 45,24.12 45.22,24.34 45.63,24.34 45.77,24.47 45.77,26.21 44.87,27.1 v1(44.1,27.1) 44.1,27.87 41.03,30.94 38.13,30.94 35.99,33.08 35.99,39.23 35.75,39.48 35.75,43.51 38.57,46.33 39.76,46.33 40.86,47.43 40.86,51.58 37.83,54.61 34.9,54.61 34.19,55.33 33.48,55.33 v1(33.07,54.91)
CLK_PCIE_NGFF2_P: length 310.3
  TOP w0.14: v1(45.3,24.88) 45.19,24.78 45.19,23.73 R22201.1 ; v2(301.24,57.37) 300.93,57.68 U13113.W11
  IN5 w0.089: v1(45.3,24.88) 45.04,24.63 45.04,23.7 43.85,22.51 39.37,22.51 37.24,24.64 37.24,25.82 37.55,26.12 37.55,31.73 36.17,33.11 36.17,36.13 37.42,37.37 39.35,37.37 40.59,38.62 40.59,39.93 41.07,40.4 41.41,40.4 41.63,40.62 49.28,40.62 51.09,42.43 52.13,42.43 52.3,42.6 59.83,42.6 61.72,44.49 62.38,44.49 62.67,44.79 64.09,44.79 65.68,43.2 66.15,43.2 66.6,43.64 67.43,43.64 67.86,43.21 73.89,43.21 74.02,43.34 80.27,43.34 80.73,43.8 85.69,43.8 87.76,45.87 91.08,45.87 92.48,47.28 93.62,47.28 95.01,48.68 97.31,48.68 97.73,49.09 175.36,49.09 176.65,50.38 178.53,50.38 178.95,50.81 185.48,50.81 185.81,50.48 185.81,50.1 186.28,49.63 188.94,49.63 189.1,49.79 189.64,49.79 190.13,50.28 194.76,50.28 195.56,49.49 198.83,49.49 199.19,49.13 229.86,49.13 230.73,48.25 232.85,48.25 233.25,48.65 257.94,48.65 259.84,50.55 264.27,50.55 264.67,50.95 268.95,50.95 269.4,50.5 287.84,50.5 289.35,48.99 299.5,48.99 300.51,50 300.51,51.05 299.7,51.86 299.7,53.5 300.59,54.39 300.59,56.85 300.75,57 300.87,57 v2(301.24,57.37)
CLK_PCIE_NGFF2_P_R: length 4.5
  TOP w0.14: CN2070.55 44.24,20.7 44.12,20.82 44.12,20.96 44.24,21.07 44.74,21.07 45.45,21.79 v1(45.45,21.89) 45.42,21.92 45.42,22.66 R22201.2
  BOTTOM w0.14: R22199.1 45.45,22.61 v1(45.45,21.89)
CLK_PCIE_NGFF2_P_RE: length 49.2
  TOP w0.14: R22192.1 33.58,55.59 v1(33.07,55.59) 32.94,55.72 R22195.1
  BOTTOM w0.14: v1(33.07,55.59) 34.3,55.59 35.02,54.88 37.94,54.88 41.13,51.69 41.13,47.32 39.87,46.07 38.68,46.07 36.01,43.4 36.01,39.59 36.26,39.34 36.26,33.19 38.24,31.21 41.14,31.21 44.34,28.01 v1(45.01,28.01) 45.01,27.34 46.03,26.32 46.03,24.36 45.74,24.07 45.33,24.07 45.27,24.01 45.27,23.74 R22199.2
CLK_PCIE_TBTN: length 66.6
  TOP w0.14: v2(296.89,55.76) 296.92,55.79 297.21,55.79 U13113.N7 ; U21.T19 v4(347.77,50.24)
  IN4 w0.089: v2(296.89,55.76) 296.34,55.76 296.14,55.96 296.14,57.44 296.62,57.92 298.84,57.92 299.07,57.69 300.51,57.69 300.73,57.92 301.61,57.92 302.03,57.5 302.03,56.35 302.23,56.15 302.64,56.15 303,56.52 303,58 303.51,58.51 304.71,58.51 305,58.81 306.49,58.81 307.66,57.63 307.66,54.94 307.87,54.73 308.42,54.73 309.22,53.93 309.73,53.93 310.26,53.4 314.87,53.4 315.77,52.5 317.11,52.5 318.63,50.98 322.66,50.98 323.61,51.93 327.82,51.93 328.08,51.67 333.18,51.67 333.92,52.42 336.32,52.42 337.53,51.21 338.79,51.21 339.15,50.86 342.94,50.86 343.9,49.89 344.88,49.89 346.01,51.02 347.52,51.02 347.77,50.77 v4(347.77,50.24)
CLK_PCIE_TBTP: length 66.6
  TOP w0.14: U21.V19 v4(347.12,50.24) ; v2(296.89,56.58) 297.13,56.34 U13113.N8
  IN4 w0.089: v4(347.12,50.24) 347.3,50.24 347.6,50.55 347.6,50.7 347.45,50.85 346.08,50.85 344.95,49.72 343.83,49.72 342.87,50.69 339.08,50.69 338.72,51.05 337.46,51.05 336.26,52.25 333.99,52.25 333.25,51.51 328.01,51.51 327.75,51.77 323.68,51.77 322.73,50.82 318.56,50.82 317.04,52.33 315.7,52.33 314.81,53.23 310.19,53.23 309.98,53.44 309.66,53.76 309.16,53.76 308.35,54.56 307.8,54.56 307.5,54.87 307.5,57.56 306.42,58.64 305.07,58.64 304.78,58.35 303.58,58.35 303.17,57.94 303.17,56.45 302.71,55.98 302.16,55.98 301.86,56.28 301.86,57.43 301.54,57.75 300.8,57.75 300.58,57.52 299,57.52 298.77,57.75 296.69,57.75 296.31,57.37 296.31,56.03 296.41,55.93 296.55,55.93 296.78,56.16 296.86,56.16 296.95,56.25 296.95,56.52 v2(296.89,56.58)
CLK_PCIE_WIGIGN: length 255.6
  TOP w0.14: v2(295.93,55.16) 296.18,55.41 U13113.L7
  BOTTOM w0.14: v2(295.93,55.16) 296.03,55.16 296.43,54.77 296.43,54.37 295.86,53.8 295.86,53.28 294.94,52.37 294.05,52.37 293.02,51.34 290.28,51.34 289.57,52.05 288.4,52.05 287.4,51.05 286.08,51.05 285.39,50.36 v1(284.75,50.36) 284.73,50.33 284.73,49.62 282.99,47.88 268.82,47.88 268.34,47.4 267.42,47.4 265.69,45.67 260.54,45.67 259.73,44.87 181.91,44.87 179.07,47.71 165.13,47.71 162.5,50.33 132.1,50.33 129.47,47.71 94.66,47.71 93.74,46.79 75.88,46.79 75.35,46.26 73.65,46.26 72.13,44.74 72.13,44.62 71.57,44.05 70.52,44.05 69.95,44.62 69.95,45.66 69.41,46.19 69.41,47 68.05,48.37 67.69,48.37 67.24,48.82 65.41,48.82 65.25,48.99 64.41,48.99 63.19,50.21 63.19,52.72 63.51,53.04 63.51,55.27 63.02,55.76 62.68,55.76 R21994.2
CLK_PCIE_WIGIGN_C: length 6.1
  TOP w0.14: CN2068.73 v1(59.2,56.25)
  BOTTOM w0.14: R21994.1 61.43,55.84 61.27,55.68 60.91,55.68 R21719.1 60.13,56.22 59.99,56.07 59.99,55.52 59.88,55.41 59.1,55.41 58.78,55.73 58.78,55.83 v1(59.2,56.25)
CLK_PCIE_WIGIGP: length 255.6
  TOP w0.14: U13113.L5 296.46,54.65 v2(296.83,55.02)
  BOTTOM w0.14: R21993.2 62.49,55.49 62.91,55.49 63.24,55.16 63.24,53.15 62.92,52.83 62.92,50.1 64.3,48.72 65.14,48.72 65.3,48.56 67.13,48.56 67.58,48.1 67.94,48.1 69.15,46.89 69.15,46.08 69.68,45.55 69.68,44.51 70.41,43.78 71.68,43.78 72.4,44.51 72.4,44.63 73.76,45.99 75.46,45.99 75.99,46.52 93.85,46.52 94.77,47.44 129.58,47.44 132.21,50.07 162.39,50.07 165.02,47.44 178.96,47.44 181.8,44.6 259.84,44.6 260.65,45.41 265.8,45.41 267.53,47.13 268.45,47.13 268.93,47.62 283.1,47.62 284.9,49.42 v1(285.62,49.42) 285.62,50.21 286.19,50.78 287.51,50.78 288.51,51.78 289.46,51.78 290.17,51.07 293.13,51.07 294.16,52.1 295.05,52.1 296.13,53.17 296.13,53.69 296.69,54.26 296.69,54.78 296.83,54.92 v2(296.83,55.02)
CLK_PCIE_WIGIGP_C: length 6.1
  TOP w0.14: v1(58.52,56.23) 59.04,56.75 CN2068.71
  BOTTOM w0.14: R21993.1 61.23,55.41 60.67,55.41 R21718.1 58.99,55.14 58.52,55.62 v1(58.52,56.23)
CLK_PCIE_WLANN: length 261.3
  TOP w0.14: v1(59.15,62.25) 59.15,62.38 59.26,62.48 59.47,62.48 59.71,62.25 CN2068.49 ; v2(293.33,54.19) 293.29,54.15 292.81,54.15 292.76,54.09 292.76,53.71 292.93,53.53 293.11,53.53 293.22,53.64 U13113.D3
  BOTTOM w0.14: v2(293.33,54.19) 293.36,54.19 293.44,54.11 293.44,53.98 293.24,53.78 292.92,53.78 291.55,55.15 290.61,55.15 290.44,54.98 289.33,54.98 v1(288.82,55.49) 288.3,54.97 288.21,54.97 288.02,54.97 287.68,54.63 287.68,52.7 287.08,52.1 284.84,52.1 283.12,50.37 282.33,49.59 281.55,48.81 268.65,48.81 268.46,48.62 267.07,48.62 264.91,46.46 259.61,46.46 258.81,45.65 202.99,45.65 202,46.64 194.51,46.64 194.07,46.21 193.05,46.21 192.5,45.66 182.49,45.66 179.51,48.65 165.64,48.65 162.25,52.04 132.67,52.04 129.28,48.65 76.06,48.65 74.84,47.43 70.79,47.43 70.3,47.92 69.61,47.92 68.29,49.24 67.96,49.24 67.57,49.64 65.9,49.64 65.66,49.88 64.63,49.88 63.98,50.53 63.98,52.4 64.29,52.71 64.29,55.82 63.02,57.09 63.02,58.92 61.05,60.9 59.18,60.9 58.68,61.4 58.68,61.83 58.9,62.05 58.9,62.17 58.98,62.25 v1(59.15,62.25)
CLK_PCIE_WLANP: length 261.4
  TOP w0.14: v1(58.41,62.22) 58.94,62.75 CN2068.47 ; v2(293.87,53.89) 293.81,53.83 U13113.F2
  BOTTOM w0.14: v1(58.41,62.22) 58.41,61.29 59.07,60.63 60.94,60.63 62.76,58.81 62.76,56.98 64.03,55.71 64.03,52.82 63.71,52.51 63.71,50.42 64.52,49.61 65.55,49.61 65.79,49.37 67.46,49.37 67.85,48.98 68.18,48.98 69.5,47.65 70.19,47.65 70.68,47.17 74.95,47.17 76.17,48.38 129.39,48.38 132.78,51.77 162.14,51.77 165.53,48.38 179.39,48.38 182.38,45.39 192.61,45.39 193.16,45.94 194.18,45.94 194.62,46.38 201.89,46.38 202.88,45.39 258.92,45.39 259.73,46.19 265.02,46.19 267.18,48.35 268.57,48.35 268.76,48.54 281.66,48.54 284.95,51.83 287.19,51.83 287.95,52.59 287.95,54.52 288.13,54.7 288.32,54.7 v1(288.82,54.21) 289.33,54.72 290.55,54.72 290.72,54.88 291.44,54.88 292.81,53.51 293.35,53.51 293.73,53.89 v2(293.87,53.89)
CLK_VDD: length 11
  TOP w0.203: C95991.1 v1(33.68,57.78) ; v1(45.13,55.41) 44.88,55.16 C95987.1 44.57,54.83 43.93,55.48 U3.12 ; U3.5 36.03,58.08 35.5,57.55 35.28,57.55 34.99,57.26 C95992.2 v1(34.56,57.78)
  TOP w0.254: v1(41.37,57.5) 41.95,58.08 U3.16
  TOP w0.305: v1(38.03,55.48) U3.9
  TOP w0.508: R22191.2 32.66,57.5 32.94,57.22 v1(32.94,56.4)
CLK_VGA_N: length 200.1
  TOP w0.104: U13114.BM27 161.22,113.51 161.14,113.43 161.14,113.11 161.25,112.99 161.25,112.92 161.27,112.9 161.27,112.89
  TOP w0.14: U13113.D5 292.73,54.62 v2(292.73,54.98) ; 161.27,112.89 161.27,112.71 159.67,111.11 159.67,109.07 159.33,108.73 158.97,108.73 v1(158.8,108.55)
  IN2 w0.089: v2(292.73,54.98) 292.73,55.01 293.32,55.6 293.32,56.03 292.59,56.77 292.59,59.82 291.87,60.54 290.87,60.54 290.65,60.76 290.17,60.76 289.2,59.78 287.65,59.78 287.02,59.16 282.65,59.16 279.79,56.29 278.81,56.29 277.17,54.66 263.47,54.66 263.14,54.33 249.21,54.33 247.65,52.77 209.93,52.77 207.96,54.74 207.96,70.08 210.18,72.31 210.18,93.76 206.3,97.64 204.72,97.64 204.29,98.07 203.26,98.07 200.56,100.76 176.61,100.76 171.86,105.51 171.86,106.76 170.77,107.85 166.51,107.85 165.81,108.55 159.79,108.55 159.53,108.8 159.05,108.8 v1(158.8,108.55)
CLK_VGA_P: length 200
  TOP w0.104: U13114.BM26 160.93,113.34 160.93,112.97 161.01,112.89
  TOP w0.14: v1(158.8,109.21) 158.94,109.07 159.01,109 159.22,109 159.41,109.18 159.41,111.22 161.01,112.82 161.01,112.89 ; U13113.E6 293.59,55.13 293.42,55.13 293.31,55.03 v2(293.31,54.83)
  IN2 w0.089: v2(293.31,54.83) 293.19,54.83 293.11,54.91 293.11,55.13 293.49,55.51 293.49,56.1 292.76,56.84 292.76,59.89 291.94,60.71 290.94,60.71 290.72,60.93 290.1,60.93 289.13,59.95 287.58,59.95 286.96,59.33 282.58,59.33 279.72,56.46 278.74,56.46 277.1,54.82 263.4,54.82 263.07,54.49 249.14,54.49 247.59,52.94 210,52.94 208.12,54.81 208.12,70.01 210.35,72.24 210.35,93.83 206.37,97.8 204.79,97.8 204.36,98.23 203.33,98.23 200.63,100.93 176.68,100.93 172.03,105.58 172.03,106.83 170.84,108.02 166.58,108.02 165.88,108.72 159.86,108.72 159.6,108.97 159.03,108.97 v1(158.8,109.21)
CLKRUN#: length 154.7
  TOP w0.102: v2(309.87,62.32) 310.45,62.9 U13113.AW22
  TOP w0.14: v1(195.7,64.48) 195.62,64.4 U49.93
  IN1 w0.089: v2(309.87,62.32) 310.51,61.69 313.58,61.69 313.97,62.08 317.01,62.08 317.39,61.69 319.04,61.69 319.93,60.8 320.7,60.8 321.86,59.63 v1(321.86,59.5)
  IN3 w0.079: v2(309.87,62.32) 309.37,61.81 307.61,61.81 306.6,62.83 300.38,62.83 298.85,64.35 293.52,64.35 292.5,65.37 292.5,66.62 289.61,69.51 285.59,69.51 283.56,71.54 279.67,75.43 279.67,76.69 275.19,81.17 213.97,81.17 209.86,77.05 209.86,76.24 204.82,71.19 204.82,69.14 202.37,66.7 198.91,66.7 198.33,67.28 197.71,67.28 195.7,65.28 v1(195.7,64.48)
  BOTTOM w0.14: R21130.2 323.16,59.5 v1(321.86,59.5) 321.86,59 322.28,58.58 322.28,57.95 322.63,57.6 R21132.2
CLR_CMOS: length 159.2
  TOP w0.14: Q7934.2 324.17,47.34 322.97,47.34 R67245.2 322.46,48.23 322.35,48.34 Q7933.2 322.35,49.19 v1(321.57,49.98) ; U49.19 179.2,58.4 179.28,58.48 181.56,58.48 182.04,58 182.04,56.4 182.95,55.49 v1(182.95,55.29)
  IN3 w0.079: v1(321.57,49.98) 321.29,50.26 317.36,50.26 316.88,50.74 313.4,50.74 312.25,49.6 307.36,49.6 306.39,50.56 305.24,50.56 304.97,50.83 304.67,50.83 304.11,50.28 302.86,50.28 301.54,48.96 293.09,48.96 291.36,50.68 289.97,50.68 289.18,51.47 286.88,51.47 286.61,51.2 271.62,51.2 269.72,53.1 226.33,53.1 226.13,52.9 209.29,52.9 207.44,54.75 207.44,54.86 207.21,55.08 206.85,55.08 206.51,54.75 206.51,53.09 205.89,52.47 203.17,52.47 202.94,52.24 199.67,52.24 199.44,52.47 198.62,52.47 198,53.09 195.61,53.09 195.11,53.59 194,53.59 193.34,54.24 191.81,54.24 190.8,55.25 182.99,55.25 v1(182.95,55.29)
CORE_PLLVDD: length 77.9
  TOP w0.254: v2(153.41,119.46) 153.06,119.11 U13114.BD15
  TOP w0.3: U13114.AF11 150.29,131.71 v4(150.61,132.03)
  TOP w0.305: U13114.BC12 149.91,118.76 v2(149.91,118.76) ; v2(151.31,118.76) U13114.BD12 ; v2(155.51,118.76) U13114.BD18 ; U13114.U42 171.92,138.01 v4(171.61,138.33)
  IN1 w0.35: v4(150.61,132.03) 151.21,131.43 151.21,123.58 152.72,122.06 155.17,122.06 155.74,121.49 159.08,121.49 v2(159.71,120.86)
  IN5 w0.35: v4(171.61,138.33) 171.09,138.85 171.09,139.88 170.86,140.11 170.86,140.66 170.28,141.24 152.55,141.24 151.21,139.89 151.21,132.63 v4(150.61,132.03)
  BOTTOM w0.203: 153.59,113.2 C95154.1 ; C95155.1 171.16,137.58 171.61,138.03 v4(171.61,138.33)
  BOTTOM w0.381: 159.38,121.19 v2(159.71,120.86)
  BOTTOM w0.508: v2(153.41,119.46) 152.99,119.46 152.29,118.76 ; 152.29,118.76 v2(151.31,118.76) v2(149.91,118.76) ; 152.29,118.76 152.75,118.3 152.75,112.67 ; 155.6,110.96 155.65,110.96 157.53,112.84 157.53,114.11 158.69,115.28 ; 153.59,113.2 154.83,114.44 154.83,118.41 155.19,118.76 v2(155.51,118.76)
  vias: v1(153.16,109.44) v2(159.71,120.16)
CPU_2_PCH_TRIG: length 164.3
  TOP w0.102: 305.71,50.74 305.87,50.9 305.87,51.65 305.97,51.76 305.97,52.58 305.83,52.73 U13113.AK1
  TOP w0.14: v1(303.91,49.32) 303.91,49.6 304.31,50 304.97,50 305.71,50.74
  IN1 w0.089: v1(303.91,49.32) 303.07,48.48 293.15,48.48 292.01,49.62 289.21,49.62 288.19,50.64 285.39,50.64 283.87,52.16 283.87,52.8 v1(283.59,53.08)
  IN5 w0.089: v1(212.77,126.84) 212.55,126.62 212.55,114.03 206.19,107.66 206.19,103.25 206.75,102.68 206.75,101.67 222.85,85.56 264.03,85.56 270.66,78.93 273.67,78.93 275.52,77.09 275.52,67.51 278.07,64.95 278.07,59.96 279.12,58.92 279.83,58.92 283.77,54.98 283.77,53.74 283.59,53.55 v1(283.59,53.08)
  BOTTOM w0.14: R20811.2 211.89,125.96 v1(212.77,126.84)
CPU_2_PCH_TRIG_R: length 27.8
  TOP w0.14: U41.J23 v1(231.2,120.53)
  IN3 w0.079: v1(231.2,120.53) 230.35,120.53 230.02,120.87 230.02,125.16 228.98,126.2 222.14,126.2 220.11,124.17 216.3,124.17 215.79,124.68 v1(215.79,125.75)
  BOTTOM w0.14: R20811.1 212.86,125.18 213.61,125.92 215.62,125.92 v1(215.79,125.75)
CPU_EDP_AUXN: length 173.8
  TOP w0.079: 224.06,123.4 224.89,123.4 225.08,123.21 226.05,123.21 226.15,123.1 226.15,122.96 226.08,122.9 U41.B26
  TOP w0.14: 224.06,123.4 224.03,123.37 223.94,123.37 223.5,123.81 223.5,123.97 v1(223.32,124.15)
  IN5 w0.089: v1(223.32,124.15) 223.57,124.39 223.57,125.62 225.05,127.1 225.05,128.76 225.35,129.07 225.35,130.13 225.79,130.57 225.79,132.27 229.11,135.6 264.67,135.6 267.1,133.16 267.1,131.85 268.51,130.44 268.51,129.39 269.13,128.77 269.13,123.26 268.45,122.57 268.45,119.71 268.42,119.68 268.42,117.08 271.21,114.28 272.44,114.28 273.77,112.95 273.77,111.35 274.08,111.05 274.08,108.83 275.53,107.38 275.53,104.36 278.35,101.54 278.35,99.81 280.52,97.64 280.52,92.94 286.91,86.55 290.88,86.55 294.01,83.42 297.62,83.42 299.21,81.83 299.21,81.38 299.94,80.65 300.83,80.65 301.5,79.98 310.28,79.98 310.41,79.85 315.97,79.85 316.65,80.53 323.13,80.53 323.42,80.82 330.73,80.82 333.61,83.7 335.23,83.7 336.08,84.55 340.43,84.55 341.23,83.75 341.23,83.57 341.32,83.48 v1(341.55,83.48)
  BOTTOM w0.14: v1(341.55,83.48) 341.6,83.43 C94699.1
CPU_EDP_AUXP: length 173.8
  TOP w0.079: U41.C26 226.41,122.9 226.31,122.99 226.31,123.17 226.11,123.37 225.15,123.37 224.96,123.56 224.18,123.56 224.1,123.64
  TOP w0.14: 224.1,123.64 224.05,123.64 223.79,123.89 223.79,124.03 223.91,124.15 v1(224.04,124.15)
  IN5 w0.089: v1(340.15,83.43) 340.96,83.43 341.07,83.53 341.07,83.68 340.36,84.38 336.15,84.38 335.3,83.53 333.68,83.53 330.8,80.65 323.49,80.65 323.2,80.36 316.72,80.36 316.04,79.68 310.34,79.68 310.21,79.81 301.43,79.81 300.76,80.48 299.87,80.48 299.04,81.31 299.04,81.76 297.55,83.25 293.94,83.25 290.81,86.39 286.84,86.39 280.36,92.87 280.36,97.57 278.19,99.74 278.19,101.47 275.37,104.29 275.37,107.31 273.91,108.77 273.91,110.98 273.61,111.28 273.61,112.88 272.37,114.12 271.14,114.12 268.25,117.01 268.25,119.75 268.28,119.78 268.28,122.64 268.97,123.33 268.97,128.7 268.35,129.32 268.35,130.37 266.93,131.78 266.93,133.09 264.6,135.43 229.18,135.43 225.95,132.2 225.95,130.5 225.52,130.06 225.52,129 225.22,128.69 225.22,127.03 223.74,125.55 223.74,124.45 v1(224.04,124.15)
  BOTTOM w0.14: C94700.1 340.05,83.33 v1(340.15,83.43)
CPU_EDP_TXN0: length 165.8
  TOP w0.14: v1(227.53,124.87) 227.53,124.93 U41.E29
  IN5 w0.089: v1(343.17,81.88) 342.89,81.6 342.89,81.47 342.52,81.1 340.7,81.1 339.42,79.82 334.11,79.82 332.64,78.36 330.57,78.36 330.15,77.94 327.76,77.94 327.22,77.41 321.54,77.41 320.76,76.63 307.27,76.63 306.5,77.41 298.5,77.41 296.82,79.09 296.82,79.72 296.22,80.32 292.92,80.32 290.49,82.74 289.41,82.74 287.88,84.27 286.19,84.27 278.61,91.86 278.61,96.81 276.1,99.31 276.1,100.79 273.68,103.21 273.68,106.61 271.41,108.88 271.41,109.67 270.43,110.64 270.43,112.44 265.87,117.01 265.87,128.42 264.22,130.07 264.22,131.83 262.3,133.74 230.04,133.74 228.14,131.84 228.14,129.94 227.8,129.6 227.8,126.88 227.6,126.69 227.6,125.57 227.26,125.23 227.26,125.14 v1(227.53,124.87)
  BOTTOM w0.14: v1(343.17,81.88) 342.92,81.63 C94679.1
CPU_EDP_TXN1: length 176.3
  TOP w0.14: U41.E28 227.53,124.14 v1(227.53,124.08)
  IN5 w0.089: v1(344.62,81.86) 344.51,81.86 344.12,82.24 343.8,82.24 343.57,82.01 343.57,81.57 342.61,80.61 340.91,80.61 339.18,78.88 337.84,78.88 337.67,78.71 336.62,78.71 336.35,78.98 335.33,78.98 332.84,76.48 330.79,76.48 329.97,75.66 329.97,71.58 329.77,71.38 329.16,71.38 324.85,75.7 320.94,75.7 320.43,76.21 318.31,76.21 318.02,75.91 313.22,75.91 312.49,75.18 310.87,75.18 309.88,76.17 305.98,76.17 305.51,75.7 304.92,75.7 304.51,76.11 300.7,76.11 300,76.8 298.33,76.8 296.22,78.9 296.22,79.55 295.89,79.89 292.7,79.89 290.34,82.25 289.34,82.25 287.89,83.71 286.18,83.71 284.59,85.3 283.52,85.3 282.77,86.05 282.77,86.73 278.2,91.3 278.2,96.38 275.46,99.13 275.46,100.78 273.19,103.05 273.19,106.36 271.02,108.53 271.02,109.5 270.04,110.48 270.04,112.28 265.47,116.85 265.47,128.09 263.56,130 263.56,131.7 261.91,133.35 232.72,133.35 231.29,131.92 231.29,126.71 230.79,126.22 228.56,126.22 228.12,125.78 228.12,124.83 227.74,124.44 227.74,124.29 v1(227.53,124.08)
  BOTTOM w0.14: C94686.1 344.29,81.37 344.29,81.53 v1(344.62,81.86)
CPU_EDP_TXN2: length 174.5
  TOP w0.14: v1(225.55,125.67) 225.91,125.32 U41.B29
  IN5 w0.089: v1(225.55,125.67) 225.55,125.67 225.23,125.98 225.23,126.09 225.84,126.7 225.84,127.62 226.56,128.34 226.56,132.01 229.42,134.87 263.77,134.87 266.21,132.43 266.21,131.41 267.71,129.91 267.71,119.95 267.69,119.93 267.69,116.78 270.91,113.55 272.14,113.55 273.05,112.65 273.05,110.66 272.54,110.15 272.54,109.35 274.8,107.08 274.8,104.06 277.62,101.24 277.62,99.51 279.8,97.34 279.8,92.47 286.54,85.73 290.25,85.73 293.31,82.67 297.24,82.67 298.48,81.43 298.48,80.98 299.65,79.81 300.54,79.81 301.65,78.71 307.25,78.71 307.88,78.07 310.79,78.07 311.17,78.45 314.85,78.45 315.19,78.79 322.71,78.79 324,80.08 331.05,80.08 332.05,81.08 333.16,81.08 333.94,81.86 336.61,81.86 337.63,82.87 337.63,83.72 337.72,83.81 338.97,83.81 339.9,82.87 342.98,82.87 v1(344,83.89)
  BOTTOM w0.14: C94692.1 345.55,81.64 345.55,82.11 344.99,82.67 344.42,82.67 343.68,83.4 343.68,83.79 343.78,83.89 v1(344,83.89)
CPU_EDP_TXN3: length 174.2
  TOP w0.14: v1(225.58,124.86) 225.91,124.54 U41.B28
  IN5 w0.089: v1(347.49,81.91) 347.49,82.49 347.3,82.68 344.53,82.68 344.27,82.94 343.64,82.94 343.16,82.46 339.59,82.46 339.2,82.07 339.2,81.19 338.62,80.61 332.29,80.61 331.34,79.66 330.43,79.66 329.7,78.93 327.54,78.93 326.88,78.27 315.67,78.27 315.34,77.94 311.82,77.94 311.44,77.56 307.49,77.56 306.78,78.27 300.13,78.27 298.43,79.97 298.43,80.08 296.43,82.08 292.92,82.08 290.95,84.06 289.41,84.06 288.23,85.23 286.43,85.23 279.4,92.26 279.4,97.16 277.08,99.47 277.08,101.01 274.41,103.68 274.41,106.92 272.14,109.18 272.14,110.43 272.64,110.93 272.64,112.5 272,113.14 270.77,113.14 267.28,116.63 267.28,120.01 267.3,120.03 267.3,128.27 265.58,130 265.58,132.33 263.43,134.47 229.64,134.47 227.39,132.22 227.39,130.49 227.05,130.15 227.05,128.22 226.28,127.46 226.28,126.54 226.04,126.3 226.04,125.48 225.81,125.26 225.81,125.1 v1(225.58,124.86)
  BOTTOM w0.14: v1(347.49,81.91) 347.25,81.67 347.25,81.46 C94696.1
CPU_EDP_TXP0: length 165.8
  TOP w0.14: v1(226.88,124.87) 226.88,124.93 U41.D29
  IN5 w0.089: v1(226.88,124.87) 227.1,125.08 227.1,125.3 227.44,125.64 227.44,126.76 227.63,126.95 227.63,129.67 227.97,130.01 227.97,131.91 229.97,133.91 262.37,133.91 264.39,131.9 264.39,130.14 266.03,128.49 266.03,117.08 270.6,112.51 270.6,110.71 271.58,109.73 271.58,108.95 273.85,106.68 273.85,103.28 276.27,100.85 276.27,99.38 278.77,96.88 278.77,91.93 286.26,84.44 287.95,84.44 289.48,82.91 290.56,82.91 292.99,80.48 296.29,80.48 296.99,79.79 296.99,79.16 298.57,77.58 306.57,77.58 307.34,76.8 320.7,76.8 321.47,77.58 327.15,77.58 327.69,78.11 330.08,78.11 330.5,78.53 332.57,78.53 334.04,79.99 339.36,79.99 340.63,81.27 342.45,81.27 342.73,81.54 342.73,81.67 v1(342.51,81.88)
  BOTTOM w0.14: C94678.1 342.16,81.53 v1(342.51,81.88)
CPU_EDP_TXP1: length 176.3
  TOP w0.14: U41.F28 228.18,124.14 v1(228.18,124.08)
  IN5 w0.089: v1(343.96,81.86) 344.07,81.86 344.42,81.51 344.42,81.35 344.29,81.22 344.09,81.22 343.83,81.47 343.71,81.47 342.68,80.44 340.98,80.44 339.25,78.71 337.91,78.71 337.74,78.54 336.55,78.54 336.28,78.81 335.4,78.81 332.91,76.32 330.86,76.32 330.13,75.59 330.13,71.51 329.84,71.21 329.09,71.21 324.78,75.53 320.87,75.53 320.36,76.04 318.38,76.04 318.09,75.74 313.29,75.74 312.56,75.02 310.8,75.02 309.81,76 306.05,76 305.58,75.53 304.85,75.53 304.44,75.94 300.63,75.94 299.93,76.63 298.26,76.63 296.06,78.83 296.06,79.48 295.82,79.72 292.63,79.72 290.27,82.08 289.28,82.08 287.82,83.54 286.11,83.54 284.52,85.13 283.45,85.13 282.61,85.98 282.61,86.66 278.04,91.23 278.04,96.31 275.29,99.06 275.29,100.71 273.02,102.98 273.02,106.29 270.85,108.46 270.85,109.43 269.87,110.41 269.87,112.21 265.31,116.78 265.31,128.02 263.39,129.93 263.39,131.63 261.84,133.18 232.79,133.18 231.45,131.85 231.45,126.64 230.86,126.05 228.63,126.05 228.29,125.71 228.29,124.76 227.91,124.38 227.91,124.17 228,124.08 v1(228.18,124.08)
  BOTTOM w0.14: C94685.1 343.91,81.22 344.02,81.33 344.02,81.79 v1(343.96,81.86)
CPU_EDP_TXP2: length 174.5
  TOP w0.14: U41.A29 225.1,125.26 v1(224.81,125.55)
  IN5 w0.089: v1(343.15,83.89) 343.45,83.89 343.53,83.81 343.53,83.66 342.91,83.04 339.97,83.04 339.04,83.97 337.65,83.97 337.46,83.79 337.46,82.94 336.54,82.02 333.87,82.02 333.09,81.25 331.98,81.25 330.98,80.25 323.93,80.25 322.64,78.96 315.12,78.96 314.78,78.62 311.1,78.62 310.72,78.24 307.95,78.24 307.32,78.87 301.71,78.87 300.61,79.98 299.72,79.98 298.65,81.05 298.65,81.5 298.6,81.55 297.31,82.84 293.37,82.84 290.32,85.89 286.61,85.89 279.96,92.54 279.96,97.41 277.79,99.58 277.79,101.31 274.97,104.13 274.97,107.15 272.7,109.42 272.7,110.08 273.21,110.59 273.21,112.72 272.21,113.72 270.98,113.72 267.85,116.85 267.85,119.86 267.88,119.88 267.88,129.98 266.38,131.48 266.38,132.5 263.84,135.03 229.35,135.03 226.4,132.08 226.4,128.41 225.67,127.69 225.67,126.77 225.06,126.16 225.06,125.8 v1(224.81,125.55)
  BOTTOM w0.14: C94691.1 345.28,81.29 345.28,82 344.88,82.4 344.31,82.4 343.42,83.29 343.42,83.62 v1(343.15,83.89)
CPU_EDP_TXP3: length 174.2
  TOP w0.14: v1(226.23,124.86) 226.56,124.54 U41.C28
  IN5 w0.089: v1(226.23,124.86) 226.05,124.86 225.98,124.93 225.98,125.19 226.21,125.41 226.21,126.23 226.45,126.47 226.45,127.39 227.21,128.15 227.21,130.08 227.55,130.42 227.55,132.15 229.71,134.31 263.36,134.31 265.41,132.26 265.41,129.93 267.14,128.2 267.14,120.1 267.11,120.08 267.11,116.56 270.7,112.97 271.93,112.97 272.47,112.43 272.47,111 271.98,110.5 271.98,109.11 274.24,106.85 274.24,103.61 276.92,100.94 276.92,99.4 279.23,97.09 279.23,92.19 286.36,85.07 288.16,85.07 289.34,83.89 290.88,83.89 292.85,81.92 296.36,81.92 298.27,80.01 298.27,79.9 300.06,78.11 306.71,78.11 307.42,77.4 311.51,77.4 311.89,77.78 315.41,77.78 315.74,78.11 326.95,78.11 327.61,78.77 329.77,78.77 330.5,79.5 331.41,79.5 332.36,80.44 338.69,80.44 339.37,81.12 339.37,82 339.66,82.29 343.23,82.29 343.71,82.78 344.2,82.78 344.46,82.52 347.23,82.52 347.32,82.42 347.32,82.29 346.92,81.88 v1(346.73,81.88)
  BOTTOM w0.14: C94695.1 346.98,81.47 346.98,81.75 346.86,81.88 v1(346.73,81.88)
CPU_OPC_COMP: length 3.3
  TOP w0.127: R20813.2 268.6,125.65 268.43,125.47 267.38,125.47 266.94,125.03 U41.BT29
CPU_OPCE_COMP: length 10.9
  TOP w0.127: U41.BR25 265.61,121.5 266.77,121.5 267.69,120.59 268.27,120.59 270.35,122.67 270.93,122.67 271.08,122.81 273.19,122.81 273.48,122.52 v1(273.91,122.52) 273.96,122.57 R20814.2
CPU_OPCE_COMP2: length 5.3
  TOP w0.127: U41.BP25 264.97,122.27 266.14,122.27 266.19,122.32 266.8,122.32 267.46,121.66 267.81,121.66 268.91,122.75 R20815.2
CPU_PCI_BCLKN: length 158.1
  TOP w0.081: U41.C36 226.75,129.66 227.02,129.66 227.12,129.56 227.12,129.48 226.86,129.22 226.65,129.22 226.35,128.92 226.35,128.85 226.05,128.55 224.88,128.55 224.68,128.74 224.05,128.74 223.9,128.9 223.9,129.02 v1(224.15,129.28)
  TOP w0.102: U13113.J1 295.73,52.7 295.73,52.21 296.31,51.62 296.31,51.02 296.16,50.87 296.11,50.87 296.1,50.85
  TOP w0.14: v1(290,52.76) 289.91,52.85 289.78,52.85 289.64,52.71 289.64,51.87 290.22,51.3 290.88,51.3 291.43,50.74 295.99,50.74 296.1,50.85
  IN5 w0.089: v1(290,52.76) 289.95,52.76 289.76,52.94 289.76,53.22 289.54,53.44 289.54,53.65 288.13,55.06 288.13,55.54 287.62,56.05 286.69,56.05 285.21,57.54 284.26,57.54 281.16,60.63 281.16,66.2 280.66,66.7 280.66,71.63 278.91,73.38 278.91,77.32 265.5,90.73 222.73,90.73 212.25,101.21 212.25,102.95 211.4,103.8 211.4,105.25 211.9,105.75 211.9,110.35 215.73,114.18 218.19,114.18 220.78,116.77 220.78,126.24 222.6,128.06 223.29,128.06 223.61,128.37 223.61,128.87 223.83,129.09 223.83,129.26 223.92,129.35 224.07,129.35 v1(224.15,129.28)
