# Allegro board DAZGLMB1ED0 dazglmb1ed0-d-ver a-165 (.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PEG_TXP3: length 76
  TOP w0.14: v1(164.08,105.4) 163.84,105.64 163.66,105.64 163.33,105.97 163.33,109.58 163.66,109.91 163.66,112.93 163.88,113.15 163.88,113.72 163.56,114.05 U13114.BL30 ; C94271.1 215.31,113.6 215.2,113.72 213.09,113.72 210.98,111.61 210.98,107.91 211.22,107.66 v1(211.35,107.66)
  IN4 w0.089: v1(164.08,105.4) 164.34,105.67 164.43,105.67 164.57,105.53 164.57,102.81 165.98,101.4 170.77,101.4 171.76,100.41 173.29,100.41 176.06,97.63 192.83,97.63 196.29,101.08 200.05,101.08 204.93,105.96 208.77,105.96 209.43,106.62 210.68,106.62 211.01,106.94 211.01,107.47 211.2,107.66 v1(211.35,107.66)
PEG_TXP4: length 79.1
  TOP w0.14: v1(214.7,116.3) 214.7,115.61 215.31,115 C94269.1 ; v1(165.4,104.33) 165.26,104.47 164.89,104.47 164.57,104.79 164.57,108.59 164.37,108.8 164.37,113.79 164.61,114.03 164.61,114.57 U13114.BK32
  IN4 w0.089: v1(214.7,116.3) 214.88,116.48 214.88,116.7 214.82,116.76 213.84,116.76 213.63,116.55 213.63,112.53 208.19,107.08 204.29,107.08 199.5,102.29 195.81,102.29 192.28,98.75 176.52,98.75 173.75,101.53 172.41,101.53 171.27,102.67 169.75,102.67 168.13,104.29 168.13,106.31 167.63,106.8 166.91,106.8 166.19,106.08 166.19,104.92 165.78,104.51 165.58,104.51 v1(165.4,104.33)
PEG_TXP5: length 74.1
  TOP w0.14: U13114.BM32 165.02,113.45 165.02,109.92 166.38,108.57 166.38,105.62 166.76,105.24 167.22,105.24 v1(167.4,105.06) ; v1(216.73,116.3) 216.77,116.3 217.05,116.02 217.05,115.83 216.86,115.63 C94267.1
  IN4 w0.089: v1(167.4,105.06) 167.4,105.27 167.31,105.36 167.1,105.36 166.77,105.03 166.77,103.34 167.91,102.2 171.01,102.2 172.08,101.13 173.59,101.13 176.36,98.36 192.45,98.36 195.9,101.82 199.66,101.82 204.53,106.69 208.44,106.69 217.12,115.36 217.12,116.06 216.87,116.3 v1(216.73,116.3)
PEG_TXP6: length 75.6
  TOP w0.14: C94265.1 215.23,116.93 215.13,117.04 215.13,118.23 v1(215.06,118.3) ; U13114.BL33 165.74,114.13 165.74,113.89 165.99,113.65 165.99,113.34 165.71,113.06 165.71,112.49 165.63,112.41 165.63,110.46 168.3,107.79 168.3,105.86 168.67,105.49 169.23,105.49 v1(169.44,105.28)
  IN4 w0.089: v1(215.06,118.3) 215.17,118.3 215.39,118.09 215.39,117.65 215.22,117.48 213.85,117.48 213.76,117.57 213.76,118.22 213.58,118.41 213.17,118.41 212.98,118.22 212.98,117.57 212.91,117.5 212.91,112.83 207.88,107.81 203.88,107.81 201.23,105.16 197.66,105.16 191.98,99.48 176.85,99.48 174.08,102.26 172.79,102.26 171.57,103.49 169.99,103.49 168.92,104.56 168.92,105.38 169.12,105.58 169.33,105.58 169.44,105.46 v1(169.44,105.28)
PEG_TXP7: length 75.8
  TOP w0.14: C94263.1 218.23,117.19 217.91,117.5 217.71,117.5 217.27,117.94 217.27,118.14 v1(217.09,118.32) ; U13114.BK35 167.38,114.59 167.38,114.08 167.16,113.86 166.95,113.86 166.74,113.65 166.74,113 166.66,112.92 166.66,111.2 167.1,110.75 v1(167.1,110.72)
  IN4 w0.089: v1(167.1,110.72) 166.88,110.5 166.69,110.5 166.35,110.16 166.35,109.24 168.06,107.53 169.07,107.53 170.03,106.58 170.03,104.27 170.42,103.89 171.83,103.89 172.26,103.46 173.44,103.46 176.4,100.49 180.79,100.49 181.41,99.88 191.82,99.88 200.3,108.36 207.73,108.36 212.24,112.87 212.24,118.2 213,118.96 213.82,118.96 213.99,118.8 216.6,118.8 217.07,118.32 v1(217.09,118.32)
PEG_TXP8: length 71.9
  TOP w0.14: U13114.BM35 167.27,113.3 167.27,112.86 v1(167.1,112.69) ; v1(217.04,119.56) 217.04,119.55 217.74,118.84 218.13,118.84 C94261.1
  IN4 w0.089: v1(167.1,112.69) 167.35,112.45 168.46,112.45 169.18,111.73 169.18,109.44 171.72,106.9 171.72,106.11 172.96,104.88 174.95,104.88 176.23,106.15 177.27,106.15 181.28,110.17 197.27,110.17 197.66,109.77 207.03,109.77 210.82,113.56 210.82,119.06 212.63,120.87 217.44,120.87 218.46,119.85 218.46,119.28 218.15,118.96 217.7,118.96 217.1,119.56 v1(217.04,119.56)
PEG_TXP9: length 73
  TOP w0.14: U13114.BL36 167.84,114.13 167.84,113.94 168.08,113.7 168.08,110.16 169.92,108.32 169.92,105.56 170.15,105.33 170.5,105.33 v1(170.71,105.12) ; C94259.1 218.26,120.82 218.01,120.58 217.48,120.58 217.19,120.29 215.27,120.29 215.03,120.06 215.03,119.8 v1(214.78,119.55)
  IN4 w0.089: v1(170.71,105.12) 170.96,105.38 171.23,105.38 172.59,104.02 174.02,104.02 176.98,101.06 181.12,101.06 181.5,100.68 189.48,100.68 197.74,108.94 207.42,108.94 211.6,113.12 211.6,118.46 213.25,120.11 214.79,120.11 215.04,119.86 215.04,119.73 214.86,119.55 v1(214.78,119.55)
PEG_TXP10: length 67.3
  TOP w0.14: C94257.1 216.42,121.12 216.04,120.74 213.34,120.74 213.13,120.95 213.13,121.38 v1(213,121.51) ; U13114.BK38 168.82,114.57 168.82,114.02 168.56,113.77 168.56,112.17 168.89,111.84 168.89,110.36 169.21,110.04 169.73,110.04 v1(169.88,109.89)
  IN4 w0.089: v1(169.88,109.89) 170.19,109.89 170.49,109.59 170.49,109.04 172.16,107.37 172.16,106.26 173.14,105.27 174.67,105.27 176,106.61 177.04,106.61 181.02,110.58 197.66,110.58 198.07,110.17 206.87,110.17 210.43,113.73 210.43,119.57 212.37,121.51 v1(213,121.51)
PEG_TXP11: length 66.9
  TOP w0.14: C94255.1 216.86,123.31 216.24,123.31 215.17,122.24 215.17,121.64 v1(215.03,121.51) ; U13114.BM38 169.3,113.37 169.3,112.39 v1(169.82,111.87)
  IN4 w0.089: v1(215.03,121.51) 215.13,121.61 215.13,122.36 214.9,122.6 212.57,122.6 209.87,119.9 209.87,113.96 206.64,110.73 198.47,110.73 198,111.19 179.99,111.19 177.08,108.28 176.37,108.28 175,106.9 175,106.41 174.42,105.83 173.39,105.83 172.74,106.48 172.74,107.81 171.12,109.42 171.12,109.82 170.49,110.46 170.49,111.84 170.26,112.07 170.02,112.07 v1(169.82,111.87)
PEG_TXP12: length 66.6
  TOP w0.14: v1(171.04,110.69) 171.04,110.69 170.56,111.17 170.56,111.46 170.29,111.73 170.29,112.78 170.18,112.89 170.18,113.67 169.94,113.92 169.94,114.06 169.86,114.14 U13114.BL39 ; v1(214.78,123.54) 214.9,123.66 214.91,123.66 215.11,123.85 217.65,123.85 217.81,123.69 218.08,123.69 C94253.1
  IN4 w0.089: v1(171.04,110.69) 171.24,110.89 171.56,110.89 171.76,110.69 171.76,109.68 173.31,108.13 173.31,106.73 173.64,106.4 174.19,106.4 174.44,106.64 174.44,107.13 176.14,108.84 176.85,108.84 179.79,111.79 198.23,111.79 198.73,111.29 206.4,111.29 209.31,114.19 209.31,120.19 212.96,123.83 214.48,123.83 v1(214.78,123.54)
PEG_TXP13: length 65
  TOP w0.14: v1(173.9,108.31) 173.73,108.14 172.59,108.14 171.83,108.91 171.83,112.37 170.94,113.26 170.94,113.74 171.09,113.88 171.4,113.88 171.6,114.09 171.6,114.57 U13114.BK41 ; C94251.1 217.85,125.57 216.71,125.57 v1(216.54,125.74)
  IN4 w0.089: v1(173.9,108.31) 174.17,108.03 174.3,108.03 175.84,109.57 176.54,109.57 179.51,112.54 198.52,112.54 199.04,112.02 206.1,112.02 208.52,114.43 208.52,120.43 213.42,125.33 216.13,125.33 v1(216.54,125.74)
PEG_TXP14: length 64.4
  TOP w0.14: v1(173.83,109.24) 173.71,109.37 172.94,109.37 172.35,109.96 172.35,110.85 172.27,110.93 172.27,112.35 171.58,113.04 171.58,113.19 U13114.BM41 ; v1(215.54,126.46) 215.34,126.66 215.34,126.89 215.4,126.95 218.07,126.95 219.33,125.7 219.51,125.7 C94249.1
  IN4 w0.089: v1(173.83,109.24) 173.92,109.33 174.81,109.33 175.5,110.02 176.44,110.02 179.41,113 198.72,113 199.3,112.41 205.94,112.41 208.12,114.6 208.12,120.59 213.26,125.73 215.06,125.73 215.29,125.95 215.29,126.2 v1(215.54,126.46)
PEG_TXP15: length 63.2
  TOP w0.14: U13114.BL42 172.03,114.14 172.03,113.9 172.35,113.58 172.35,113.11 172.98,112.48 172.98,111.36 173.4,110.94 173.72,110.94 173.83,110.83 v1(173.83,110.73) ; C1194.1 219.39,127.61 218.95,127.61 218.58,127.98 214.32,127.98 213.46,127.12 v1(213.46,126.88)
  IN4 w0.089: v1(213.46,126.88) 213.58,127.01 213.58,127.14 213.4,127.32 212.47,127.32 207.56,122.42 207.56,117.38 206.97,116.79 206.97,114.33 206.3,113.67 179.2,113.67 176.12,110.58 175.17,110.58 174.77,110.98 174.09,110.98 v1(173.83,110.73)
PEGX_RST#: length 41.9
  TOP w0.127: 160.2,113.09 160.2,113.84 160.41,114.05 160.41,114.41 160.76,114.76 U13114.BK26
  TOP w0.14: R21508.2 134.89,112.79 135.13,112.55 Q7861.2 135.18,112.23 135.86,111.55 v1(135.86,110.86) ; v1(149.85,103.85) 149.32,103.32 v1(149.32,103.24) 149.32,102.89 150.07,102.13 151.84,102.13 152.04,102.33 153.15,102.33 155.62,104.79 155.62,105.81 155.82,106.01 156.13,106.01 156.84,106.72 156.84,107.38 157.12,107.66 R21609.1 157.32,108.17 157.53,108.37 157.53,110.42 160.2,113.09
  IN5 w0.089: v1(135.86,110.86) 136.39,110.33 139.74,110.33 144.93,105.14 144.93,104.23 145.18,103.98 148.41,103.98 148.61,104.18 149.52,104.18 v1(149.85,103.85)
PEX_PLL_HVDD: length 0.6
  TOP w0.203: v2(163.53,121.14) 163.53,120.54 U13114.BB30
PEX_TERMP: length 9.2
  TOP w0.127: U13114.BL44 172.99,113.85
  TOP w0.14: R21506.2 v1(175.55,107.87) 175.56,107.88 175.56,108.7 174.39,109.87 174.39,110.35 174.87,110.84 174.87,111.93 174.57,112.23 173.88,112.23 173.63,112.49 173.63,112.59 172.99,113.23 172.99,113.85
PGDMON: length 18.3
  TOP w0.14: v2(308.93,62.32) 308.4,62.86 U13113.AR22
  IN1 w0.089: v2(308.93,62.32) 309.44,62.83 311.42,62.83 311.68,62.58 311.68,62.2 312,61.87 313.51,61.87 313.89,62.25 317.14,62.25 317.4,61.99 319.17,61.99 319.62,62.45 321.07,62.45 321.71,61.81 v1(321.71,61.33)
  BOTTOM w0.14: R21232.1 R21234.2 321.99,61.05 v1(321.71,61.33) 321.3,60.93 v1(321.3,60.67)
PLTRST#: length 646.5
  TOP w0.14: U13102.4 328.3,48.54 328.14,48.38 327.41,48.38 R21222.1 327.17,49.01 v1(327.45,49.29) ; v1(270.91,132.35) 270.71,132.55 R541.1 ; U13115.2 132.63,112.3 132.4,112.54 v1(131.41,112.54) ; U21.L4 v4(351.02,56.74)
  IN1 w0.089: v1(333.95,67.07) 333.42,66.54 332.15,66.54 330.58,64.96 330.58,64.21 329.94,63.57 329.94,60.58 330.99,59.54 330.99,58.23 330.68,57.92 330.68,52.66 329.42,51.4 327.17,51.4 326.66,50.89 326.66,50.14 327.45,49.34 v1(327.45,49.29)
  IN2 w0.089: v1(135.07,67.09) 134.58,66.61 133.78,66.61 133.24,67.15 133.24,72.61 127.51,78.34 127.51,83.39 128.37,84.26 128.37,87.03 130.33,88.98 130.33,105.12 130.63,105.43 130.63,111.76 v1(131.41,112.54) ; v4(351.02,56.74) 350.14,57.62 348.76,57.62 347.49,58.89 v1(347.49,64.81) ; v1(270.91,132.35) 270.91,130.92 271.8,130.03 271.8,129.05 271.08,128.32 271.08,127.7 270.61,127.24 269.94,127.24 267.21,124.52 262.82,124.52 262.22,123.92 262.22,117.61 262.96,116.88 265.12,116.88 274.72,107.28 274.72,104.23 276.5,102.45 276.5,96.36 277.47,95.39 277.47,82.53 283.09,76.91 284.77,76.91 285.14,76.55 285.14,74.54 283.59,72.99 283.59,65.85 v1(286.48,62.96)
  IN3 w0.079: v1(88.49,51.1) 86.72,49.33 74.35,49.33 73.62,50.06 70,50.06 68.4,51.66 67.05,51.66 65.56,53.16 64.31,53.16 62.12,55.34 61.72,55.34 58.98,58.09 57.23,58.09 57.01,58.31 51.43,58.31 v1(51.2,58.08) ; v1(327.45,49.29) 326.57,48.41 324.75,48.41 322.53,46.19 318.66,46.19 318.26,46.6 289.12,46.6 286.88,48.84 268.9,48.84 268.6,49.14 v1(268.07,49.14) 267.61,48.68 264.48,48.68 263.88,48.07 256.71,48.07 256.43,48.35 238.55,48.35 236.59,46.39 224.79,46.39 224.1,47.08 224.1,50.05 223.21,50.94 203.63,50.94 203.5,50.82 199.13,50.82 198.88,51.07 198.11,51.07 197.68,51.5 197.07,51.5 196.95,51.63 193.9,51.63 192.65,52.87 191.23,52.87 190.76,53.35 190.16,53.35 189.77,53.74 188.49,53.74 187.42,52.67 183.41,52.67 182.82,53.26 180.71,53.26 178.35,50.89 v1(178.33,50.89) ; v1(347.49,64.81) 347.49,64.02 346.37,62.9 336.88,62.9 335.55,64.23 335.55,64.99 334.2,66.34 334.2,66.83 v1(333.95,67.07) ; v1(74.32,23.38) 73.83,22.9 73.83,21.4 72.16,19.73 49.71,19.73 49.17,20.27 49.17,22.57 48.05,23.69 v1(48.05,23.94)
  IN5 w0.089: v1(51.2,58.08) 50.62,58.67 38.73,58.67 v1(38.25,58.18) ; v1(88.49,51.1) 89.07,51.68 91.71,51.68 93.47,53.44 100.41,53.44 101.05,54.07 111.16,54.07 112.34,55.26 118.13,55.26 119.07,54.32 125.08,54.32 125.57,54.81 128.62,54.81 129.19,54.23 137.32,54.23 v1(137.79,54.7) 138.28,54.21 155,54.21 155.66,53.55 168.98,53.55 170.17,54.74 173.09,54.74 174.65,56.3 v1(174.65,56.48)
  BOTTOM w0.14: v1(268.07,49.14) 268.38,49.46 280.09,49.46 283.1,52.47 283.1,53.38 283.97,54.25 283.97,54.93 283.59,55.31 283.59,60.9 284.88,62.2 285.72,62.2 v1(286.48,62.96) ; v1(174.65,56.48) 175.1,56.48 175.87,55.71 175.87,55.65 176.09,55.43 R821.1 177.13,54.63 179.65,54.63 180.06,54.22 180.06,53.69 178.33,51.96 v1(178.33,50.89) ; v1(74.32,23.38) 74.32,23.44 R21737.2 ; R21713.2 R21997.2 51.9,58.78 v1(51.2,58.08) ; v1(135.07,67.09) 135.07,65.66 135.12,65.6 135.12,63.52 135.58,63.06 135.58,62.5 135.39,62.31 R67340.1 134.26,61.18 133.12,60.04 133.12,58.64 133.93,57.83 134.82,57.83 137.79,54.86 v1(137.79,54.7) ; v1(38.25,58.18) 40.19,56.24 40.19,54.64 42.2,52.63 42.2,51.31 42.43,51.08 42.43,47.53 40.48,45.58 38.83,45.58 37.84,44.59 37.84,43.98 37.13,43.27 37.13,41.04 36.95,40.85 36.95,36.48 36.87,36.41 36.87,35.61 37.49,34.99 37.82,34.99 38.65,34.15 38.65,32.71 39.19,32.17 41.73,32.17 42.03,31.87 42.03,31.26 44.34,28.95 45.16,28.95 47.77,26.33 47.77,24.6 48.05,24.32 v1(48.05,23.94) 47.58,23.47 R21800.2 ; v1(347.49,64.81) 347.19,64.81 346.47,65.53 R21481.1
PLTRST#_EC: length 3.8
  TOP w0.14: U49.22 176.59,57.2 v1(176.27,56.89)
  BOTTOM w0.14: v1(177.15,56.22) 177.14,56.21 R821.2 176.35,56.24 176.35,56.81 v1(176.27,56.89)
PM_SYNC: length 112.8
  TOP w0.127: v1(263.61,127.79) 263.28,128.11 U41.BM34
  TOP w0.14: R21190.2 303.25,48.07 v1(303.4,47.92)
  IN1 w0.089: v1(303.4,47.92) 304.33,48.85 304.33,52.4 305.46,53.53 305.46,57.6 304.16,58.9 303.21,58.9 301.52,60.59 301.52,60.93 301.01,61.43 300.25,61.43 298.97,62.71 293.14,62.71 292.64,63.21 289.24,63.21 288.63,63.82 283.76,63.82 281.82,65.76 281.82,70.29 278.4,73.7 278.4,78.02 276.53,79.9 276.53,85.73 276.5,85.77 276.5,93.41 274.12,95.79 274.12,100.56 272.63,102.05 272.63,105.05 271.88,105.8 271.88,106.46 270.02,108.31 270.02,108.73 268.37,110.38 266.33,110.38 264.76,111.95 262.5,111.95 261.51,112.95 261.51,125.22 262.8,126.51 262.8,126.95 263.61,127.75 v1(263.61,127.79)
PM_SYNC_R: length 6.6
  TOP w0.102: U13113.AJ4 305.29,54.07 305.55,53.81 305.55,52.65 305.76,52.43 305.76,51.83 305.66,51.74 305.66,51.1 305.52,50.96 304.74,50.96 304.04,50.26 303.75,50.26 303.25,49.75 303.25,49.59
  TOP w0.14: R21190.1 303.25,49.59
PM_THRMTRIP#: length 291.9
  TOP w0.14: v1(245.72,51.99) 245.73,51.99 v1(246.73,50.99) 247.34,50.38 247.34,47.57 250.89,44.02 251.23,43.67 259.66,43.67 260.32,44.34 269.79,44.34 272.92,47.46 285.8,47.46 289.02,44.24 302.03,44.24 v1(303.4,45.61) 303.4,46.16 R21189.2 ; Q23.1 212.11,132.68 212.65,132.14 R20751.2 212.65,130.74 213.76,129.63 213.76,128.46 v1(213.3,128.01) ; U41.J31 230.29,126.48 v1(230.63,126.81) ; D13070.2 360.56,40.28 359.96,40.89 359.96,41.9 360.67,42.61 360.67,43.37 360.99,43.68 360.99,46.16 359.94,47.21 v1(359.94,47.59)
  IN2 w0.089: v1(210.97,92.68) 211.25,92.4 211.25,71.21 211.42,71.03 211.42,67.68 211.98,67.12 215.87,67.12 217.11,65.88 244.57,65.88 245.16,65.29 v1(245.16,63.95) ; v1(326.47,52.66) 326.47,51.8 324.07,49.4 322.22,49.4 321.95,49.12 321.21,49.12 321.08,49.25 318.66,49.25 318.45,49.46 317.86,49.46 316.88,48.47 316.41,48.47 314.73,46.79 310.3,46.79 309.76,47.33 308.15,47.33 307.63,46.81 304.29,46.81 303.4,45.91 v1(303.4,45.61)
  IN3 w0.079: v1(326.47,52.66) 326.47,53.11 326.89,53.53 327.56,53.53 327.78,53.31 331.61,53.31 331.75,53.17 334.37,53.17 335.1,53.89 340.6,53.89 345.21,58.5 345.7,58.5 346.48,59.27 347.19,59.27 347.9,59.99 348.64,59.99 349.32,59.3 351,59.3 351.09,59.2 351.91,59.2 352.44,58.67 355.52,58.67 355.82,58.37 356.57,58.37 357.11,57.83 358.3,57.83 358.72,57.41 358.72,51 359.94,49.78 v1(359.94,47.59)
  IN4 w0.089: v1(213.3,128.01) 213.32,127.99 213.93,127.99 214.95,126.97 216.04,126.97 217.43,125.57 223.57,125.57 224.61,126.61 228.98,126.61 229.38,126.21 230.25,126.21 230.63,126.58 v1(230.63,126.81)
  IN5 w0.089: v1(210.97,92.68) 210.38,92.68 208.71,94.35 208.71,98.49 205.89,101.31 205.89,102.33 205.32,102.89 205.32,108.02 211.66,114.35 211.66,126.95 212.72,128.01 v1(213.3,128.01)
  BOTTOM w0.14: v1(245.16,63.95) 245.47,63.63 245.47,63.31 246.32,62.46 246.32,53.97 245.72,53.37 v1(245.72,51.99)
PMON: length 323.5
  TOP w0.14: v1(258.08,165.19) 257.45,165.19 256.81,164.56 256.81,164 v1(258.01,162.81) 259.08,161.74 PR66869.1
  IN1 w0.089: v1(258.08,165.19) 254.4,165.19 253.35,164.15 237.21,164.15 234.89,161.83 234.89,159.54 231.64,156.29 231.64,156.28 231.62,156.25 231.62,153.83 228.16,150.38 224.38,150.38 222.4,152.37 216.23,152.37 213.08,149.21 213.08,140.6 214.27,139.41 214.27,138.14 213.08,136.95 213.08,130.95 214.18,129.85 214.18,129.08 215.55,127.71 216.14,127.71 218.87,124.98 218.87,117.69 218.21,117.03 214.02,117.03 213.28,116.3 213.28,113.68 204.69,105.09 204.69,101.69 205.2,101.18 205.2,97.71 203.6,96.1 203.6,93.37 200.77,90.54 200.77,85.22 206.16,79.83 206.16,77.68 205.7,77.23 205.7,76.39 206.16,75.93 206.16,74.95 205.64,74.42 205.47,74.42 205.05,74.01 204.74,74.01 203.09,75.66 203.09,76.17 201.57,77.69 200.93,77.69 200.05,76.8 197.3,76.8 193.31,72.81 188.92,72.81 188.23,73.5 187.65,73.5 186.96,72.81 184.09,72.81 183.75,73.16 181.74,73.16 177.9,69.31 176.68,69.31 175.89,68.52 173.32,68.52 171.72,66.92 171.72,66.29 171.44,66 169.01,66 168.93,66.08 167.78,66.08 165.16,63.47 158.35,63.47 156.34,61.46 152.65,61.46 151.35,60.16 134.92,60.16 134.83,60.08 133.36,60.08 132.23,58.95 128.12,58.95 126.52,60.54 124.96,60.54 124.38,61.13 120.77,61.13 119.17,62.73 117.24,62.73 115.08,60.57 112.91,60.57 112.37,60.03 106.78,60.03 v1(105.38,61.43)
  IN4 w0.089: v1(64.76,54.47) 64.76,54.45 64.79,54.47 66.95,54.47 67.39,54.92 67.39,55.27 67.71,55.59 67.71,57.5 68.55,58.34 68.55,62.78 69.07,63.3 74.43,63.3 79.06,67.94 86.19,67.94 88.85,65.28 91.39,65.28 94.09,62.57 103.45,62.57 104.59,61.43 v1(105.38,61.43)
  BOTTOM w0.203: PR23.1 65.35,54.68 65.15,54.47 v1(64.76,54.47) 65.4,53.84 PC18.2 66.09,53.8 PR25.1
PP_CABLE_A: length 3.6
  TOP w0.081: U13155.H10 369.37,29.24 369.37,29.68 369.53,29.84
  TOP w0.203: v1(369.53,31.14) 369.53,29.84
  BOTTOM w0.203: v1(369.53,31.14) 369.22,31.14 368.67,30.59 R67137.1
PROCHOT_EC: length 17.7
  TOP w0.14: v1(172.08,57.37) 172.08,57.6 171.09,58.59 171.09,60.04 v1(171.42,60.37) 171.42,61.04 173.98,63.6 Q32.2 ; v1(177.19,59.02) 177.37,59.2 U49.17
  IN2 w0.089: v1(177.19,59.02) 177.19,58.43 176.64,57.88 174.74,57.88 174.36,57.5 172.21,57.5 v1(172.08,57.37)
  BOTTOM w0.14: v1(177.19,59.02) 177.8,59.63 C96220.1 178.18,59.1 178.07,58.99 R815.2
PROCPWRGD: length 120.4
  TOP w0.102: U13113.AM3 306.96,53.74 306.72,53.5 306.72,53.17 306.83,53.07 ; 307.23,50.64 307.31,50.72 307.31,51.58 v1(307.03,51.86)
  TOP w0.112: 306.83,53.07 306.83,52.24 307.03,52.04 v1(307.03,51.86)
  TOP w0.14: U41.BT31 266.81,126.58 267.51,127.27 267.51,127.45 v1(268.4,128.34) 268.6,128.54 R560.2 ; 307.23,50.64 307.02,50.42 307.02,49.81 306.57,49.37 R21131.1
  IN1 w0.089: v1(307.03,51.86) 307.03,51.99 306.6,52.42 306.6,57.4 306.23,57.76 305.85,57.76 303.96,59.66 303.42,59.66 303.22,59.86 303.22,60.11 301.51,61.83 300.41,61.83 299.14,63.1 293.31,63.1 292.8,63.61 289.4,63.61 288.79,64.22 285.33,64.22 282.61,66.93 282.61,70.61 279.46,73.76 279.46,77.53 276.92,80.06 276.92,93.54 274.51,95.96 274.51,100.72 273.02,102.21 273.02,105.21 272.27,105.96 272.27,106.62 270.47,108.42 270.47,109.19 268.19,111.47 268.19,111.62 267.47,112.35 262.67,112.35 261.91,113.11 261.91,125.06 263.46,126.61 264.58,126.61 264.61,126.63 266.64,126.63 268.35,128.34 v1(268.4,128.34)
PS_FBVDD_PGOOD: length 291.5
  TOP w0.14: Q7828.2 242.09,163.22 v1(241.73,162.86) ; U13119.1 123.86,118.1 123.75,118.2 D8595.2 123.75,119.11 123.62,119.24 v1(123.08,119.24)
  TOP w0.203: v1(121.23,78.63) 120.95,78.35 PR9217.1
  IN1 w0.089: v1(121.23,78.63) 124.54,78.63 126.19,80.27 126.19,83.81 126.99,84.61 126.99,87.9 128.65,89.56 128.65,93.29 127.46,94.47 127.46,96.44 120.92,102.98 120.92,111.22 120.59,111.55 120.59,116.32 121.08,116.81 121.08,118.41 121.91,119.24 v1(123.08,119.24)
  IN2 w0.254: v1(204.36,69.87) 203.62,69.87 201.43,72.06 196.6,72.06 195.99,72.67 194.49,72.67 192.39,74.77 190.91,74.77 190.73,74.59 184.85,74.59 184.3,75.15 181.07,75.15 180.51,74.59 178.12,74.59 175.97,72.44 174.88,72.44 174.3,71.86 174.3,70.89 174.99,70.2 175.26,70.2 175.7,69.77 175.7,69.09 174.67,68.06 168.45,68.06 166.4,66.01 166.4,64.29 165.79,63.67 157.02,63.67 154.81,65.88 154.2,65.88 152.6,64.28 149.53,64.28 148.47,65.33 140.65,65.33 140.47,65.51 129.46,65.51 128.78,64.83 126.57,64.83 125.57,65.83 125.57,66.56 120.85,71.29 120.85,76.85 121.23,77.23 v1(121.23,78.63)
  IN5 w0.254: v1(204.36,69.87) 204.79,69.87 205.51,70.58 205.51,72.15 207.18,73.83 207.18,90.97 206.22,91.94 206.22,96.74 204.17,98.79 204.17,108.38 210.71,114.93 210.71,128.01 212.29,129.58 212.29,148.68 213.63,150.02 213.63,160.49 218.21,165.07 239.87,165.07 241.73,163.21 v1(241.73,162.86)
PSI: length 90.2
  TOP w0.14: v1(135.28,120.36) 135.4,120.23 R21574.2
  TOP w0.203: PR9224.2 110.64,73.89 109.3,73.89 v1(108.78,73.37)
  IN2 w0.203: v1(127.93,72) 127.1,72.84 127.1,83.56 127.96,84.43 127.96,87.27 129.92,89.22 129.92,99.18 129.81,99.28 129.81,104.72 129.46,105.07 129.46,112.53 128.46,113.53 128.46,114.61 130.01,116.15 131.05,116.15 132.21,117.31 133.53,117.31 134.15,117.93 134.15,119.19 135.28,120.31 v1(135.28,120.36)
  IN3 w0.203: v1(127.93,72) 127.73,72.2 127.73,73.07 127.91,73.24 131.03,73.24 131.67,72.61 v1(137.18,72.61)
  IN4 w0.254: v1(108.78,73.37) 109.32,73.91 116.3,73.91 116.64,73.56 120.53,73.56 121,74.03 125.9,74.03 v1(127.93,72)
  BOTTOM w0.254: v1(137.18,72.61) 137.43,72.36 PR9011.1
PW_VCC3_ANA_PCIE: length 1.2
  TOP w0.127: v4(351.02,51.54) U21.L16
  BOTTOM w0.127: C94044.2 350.73,51.25 v4(351.02,51.54)
PW_VCC3_ANA_USB: length 1.1
  TOP w0.127: U21.J16 v4(351.67,50.89)
  BOTTOM w0.127: C94599.2 351.52,50.74 v4(351.67,50.89)
PWM_LED#: length 64.8
  IN2 w0.089: v1(377.85,5.25) 377.85,5.39 375.33,7.92 v1(371.98,7.92)
  IN3 w0.079: v1(366.2,40.33) 365.58,39.71 365.58,35.4 367.15,33.82 367.15,33.01 367.63,32.53 368.4,32.53 368.87,32.06 368.87,30.94 370.89,28.92 370.89,25.39 371.97,24.31 371.97,23.34 372.26,23.05 372.26,21.96 374,20.22 374.58,20.22 375.26,19.54 375.26,18.53 375.77,18.02 377.8,18.02 378.75,17.07 378.75,13.41 379.23,12.93 379.23,11.08 377.95,9.8 377.95,8.12 378.84,7.22 379.92,7.22 380.14,7 380.14,6.46 379.65,5.97 378.58,5.97 v1(377.85,5.25)
  BOTTOM w0.14: R67385.1 C96255.2 365.48,40.81 365.96,40.33 v1(366.2,40.33) ; v1(377.85,5.25) 377.85,5.24 377.79,5.3 377.79,7.18 377.54,7.43 C96254.2 377.16,7.43 376.95,7.64 376.24,7.64 375.76,8.13 U13159.3 ; v1(371.98,7.92) 372.13,7.92 372.49,7.56 372.97,7.56 v1(372.99,7.59) 373.15,7.74 374.56,7.74 374.96,8.14 U13159.5
PWM_RST_PCU: length 283.8
  TOP w0.14: v1(195.55,69.05) 194.86,69.74 194.71,69.74 192.96,71.49 190.39,71.49 190.01,71.87 184.78,71.87 183.56,73.09 182.9,73.09 182.6,72.79 R67315.1 ; v1(379.69,6.79) 379.65,6.75 379.65,6.49 379.34,6.18 R67035.1
  IN2 w0.089: v1(195.37,55.11) 194.84,55.64 194.84,60.65 193.64,61.84 193.64,62.1 193.32,62.42 v1(192.88,62.42)
  IN3 w0.079: v1(379.69,6.79) 379.69,6.79 379.14,6.24 378.58,6.24 378.25,6.57 378.25,7.41 377.54,8.12 377.54,11.29 377.77,11.52 377.77,12.11 377.26,12.62 377.26,16.78 v1(377.49,17.01) 375.23,17.01 374.87,16.65 374.1,16.65 373.74,17.01 373.74,19.95 371.88,21.81 371.88,22.78 371.58,23.07 371.17,23.07 370.5,23.74 370.5,28.66 369.15,30.01 367.66,30.01 366.75,30.93 366.75,33.65 365.04,35.35 365.04,39.2 364.26,39.99 364.26,41.55 363.98,41.83 363.62,41.83 363.44,41.65 363.44,41.16 362.73,40.45 361.94,40.45 359.54,42.86 359.54,47.3 359.38,47.45 359.38,49.49 358.21,50.66 358.21,54.06 357.89,54.38 357.89,55.93 357.25,56.57 356.51,56.57 354.87,58.21 348.41,58.21 348.15,58.46 346.51,58.46 345.11,57.07 344.76,56.71 344.09,56.71 340.49,53.11 335.07,53.11 334.41,52.45 330.48,52.45 330.07,52.04 329.31,52.04 329.1,52.24 325.11,52.24 324.43,52.92 322.73,52.92 322.02,52.21 319.68,52.21 318.87,53.03 313.28,53.03 312.74,52.49 310.66,52.49 310.56,52.59 308.58,52.59 308.12,53.05 302.05,53.05 301.59,53.51 299.64,53.51 299.28,53.15 295.06,53.15 294.53,52.62 293.11,52.62 291.26,54.47 289.16,54.47 287.86,55.77 283.43,55.77 283.18,56.02 280.66,56.02 278.66,54.02 270.63,54.02 270.3,54.35 225.8,54.35 225.6,54.14 209.82,54.14 209.35,54.62 209.35,55.45 208.24,56.56 206.37,56.56 205.4,55.59 204.69,55.59 202.51,53.41 200.12,53.41 199.82,53.71 199.05,53.71 197.96,54.8 197.21,54.8 196.8,54.4 196.08,54.4 v1(195.37,55.11)
  BOTTOM w0.14: v1(192.88,62.42) 193.39,62.93 195.55,62.93 195.98,63.36 195.98,63.64 196.47,64.13 196.47,68.13 v1(195.55,69.05) ; Q7948.3 376.47,15.7 376.47,16.63 376.57,16.73 377.09,16.73 377.09,16.73 377.21,16.73 v1(377.49,17.01) ; v1(195.37,55.11) 193.62,55.11 193.31,55.41 192.04,55.41 191.56,54.93 191.41,54.93 191.18,54.71 R67332.2
PWM_RST_S0: length 343.3
  TOP w0.14: CN2076.16 140.05,61.99 140.18,62.13 141.93,62.13 142.44,62.13 142.59,61.97 142.59,56.18 145.46,53.31 146.3,53.31 146.98,53.99 146.98,54.95 147.26,55.24 148.58,55.24 148.91,55.57 149.32,55.57 v1(149.83,55.06) ; v1(277.44,52.29) 275.15,50 274.72,50 269.69,44.97 267.13,44.97 266.85,45.25 R21054.1 ; v1(33.42,89.5) 33.42,89.5 CN2074.5
  IN1 w0.089: v1(46.38,54.35) 45.77,54.96 45.77,55.54 42.87,58.44 40.34,58.44 31.57,67.21 31.57,68.44 28.11,71.9 28.11,76.83 30.78,79.49 30.78,85.94 33.42,88.59 v1(33.42,89.5)
  IN3 w0.079: v1(189,61.1) 190.09,60.01 190.09,59.27 190.52,58.84 191.08,58.84 191.36,59.12 193.01,59.12 193.29,58.84 193.29,55.92 194.51,54.7 195.56,54.7 196.01,54.25 196.87,54.25 197.25,54.63 197.91,54.63 199,53.53 199.71,53.53 200.02,53.23 202.59,53.23 202.97,53.61 204.34,53.61 204.77,54.04 204.77,54.32 205.43,54.98 205.43,55.13 206.5,56.2 208.15,56.2 209,55.35 209,54.46 209,54.46 209.67,53.79 225.75,53.79 225.95,53.99 270.2,53.99 271.9,52.29 277.44,52.29 v1(277.44,52.29) ; v1(46.38,54.35) 46.38,54.71 47.2,55.53 48.05,56.38 52.17,56.38 52.6,56.81 56.18,56.81 57.62,55.38 60.36,55.38 62.1,53.64 62.1,53.03 63.93,51.2 65.25,51.2 65.6,50.84 67.08,50.84 68.64,49.28 73.27,49.28 74,48.54 89.13,48.54 93,52.41 101.11,52.41 103.41,54.7 116.48,54.7 117.95,53.23 126.44,53.23 126.83,53.62 148.39,53.62 v1(149.83,55.06) 151.25,53.64 164.96,53.64 167.04,55.72 167.04,59.9 169.94,62.79 170.9,62.79 172.55,64.45 178.8,64.45 179.73,65.37 v1(180.03,65.37)
  IN5 w0.089: v1(180.03,65.37) 180.66,64.74 184.17,64.74 186.84,62.07 188.03,62.07 v1(189,61.1)
  BOTTOM w0.14: R67334.2 179.57,64.35 180.03,64.81 v1(180.03,65.37) ; v1(189,61.1) 188.57,61.53 R67335.2
PWR_LEVEL: length 29.5
  TOP w0.127: v2(146.41,118.06) U13114.BE6
  TOP w0.14: v1(125.08,114.61) 125.08,114.82 125.4,115.14 Q7859.1 125.4,115.72 125.74,116.06 R21593.2 ; v1(131.29,113.43) 130.69,112.83 D13095.2 129.6,113.12 R67380.1
  IN4 w0.089: v1(125.08,114.61) 125.64,114.61 126.82,113.43 v1(131.29,113.43)
  BOTTOM w0.14: v1(131.29,113.43) 132.15,113.43 133.37,114.65 135.22,114.65 135.62,114.25 136.44,114.25 137.57,115.38 141.25,115.38 142.83,116.96 143.53,116.96 143.95,117.38 145.73,117.38 v2(146.41,118.06)
R_SPK+: length 13
  IN3 w1.016: 29.74,22.97 29.18,22.41 29.18,21.63 26.4,18.85 26.4,14.53 24.15,12.28
  vias: v1(23.59,10.68) v1(23.91,11.25) v1(24.99,10.84) v1(31.64,26.79) v1(31.64,26.13)
R_SPK-: length 14.3
  IN3 w1.016: 28.98,24.01 27.88,22.92 27.88,22.14 25.13,19.38 25.13,17.91 24.66,17.44 24.66,14.6 22.72,12.65 22.72,12.28
  vias: v1(22.62,10.69) v1(23.04,11.22) v1(30.93,26) v1(30.96,26.66)
RASTER_SYNC0: length 8.5
  TOP w0.14: U13114.BA5 146.31,121.47 146.31,121.66 145.7,122.27 141.5,122.27 140.48,123.28 TP13112.1
RBIAS: length 2.4
  TOP w0.178: U13143.10 352.21,68.56 352.3,68.48 353.17,68.48 v1(353.36,68.29) 353.53,68.12 R21482.1
REGN6V: length 19.3
  TOP w0.254: v1(75.02,56.17) 75.1,56.09 75.1,54.01 74.89,53.8 74.18,53.8 v1(73.96,53.59)
  BOTTOM w0.14: PR39.1 71.76,48.36 74.33,48.36 75.79,49.81 75.79,51.76 v1(73.96,53.59)
  BOTTOM w0.178: v1(75.02,56.17) 75.26,56.41 75.26,56.52 PC9.1 74.54,57.09 74.34,56.89 74.34,56.15 73.94,55.75 PU1.24
RF_EN: length 165.4
  TOP w0.14: v1(51.63,59.88) 51.63,60.04 52.1,60.5 CN2068.56
  IN5 w0.089: v1(189.76,56.25) 187.68,56.25 187.28,56.65 180.57,56.65 180.33,56.89 178.13,56.89 177.14,55.9 174.77,55.9 173.25,54.39 170.33,54.39 169.13,53.19 155.51,53.19 154.85,53.85 129.07,53.85 128.47,54.46 125.72,54.46 125.23,53.97 118.92,53.97 118.02,54.87 112.46,54.87 111.3,53.72 101.2,53.72 100.56,53.08 93.77,53.08 91.96,51.27 90.83,51.27 89.44,49.88 84.16,49.88 83.35,49.07 73.85,49.07 72.69,50.24 70.67,50.24 66.92,53.99 66.45,53.99 65.6,54.84 65.6,59 64.49,60.11 62.24,60.11 60.8,61.56 60.8,65.79 59.45,67.14 57.29,67.14 56.33,66.18 54.92,66.18 52.93,64.19 52.93,61.18 v1(51.63,59.88)
  BOTTOM w0.14: R20904.1 190.49,54.38 v1(190.49,54.55) 190.49,54.78 190.11,55.16 190.11,55.9 v1(189.76,56.25)
RINRVP: length 71.8
  TOP w0.203: v1(32.1,36.84) 32.26,36.84 32.52,37.1 U13157.25
  TOP w0.508: v1(76.47,38.62) 76.47,40 78.09,41.61 R67350.2 78.58,42.59 79.83,43.83 v1(82.29,43.83) 84.51,43.83 86.68,46 86.68,48.23 85.18,49.73 CN2039.2
  IN1 w0.508: v1(32.1,36.84) 32.1,37.31 33.27,38.48 34.94,38.48 36.58,36.83 39.15,36.83 40.03,35.96 41.34,35.96 41.4,36.02 42.5,36.02 42.74,35.78 46.35,35.78 48.2,37.63 48.2,37.65 49.45,38.9 50.26,38.9 51.73,37.43 57.58,37.43 58.54,36.47 63.55,36.47 63.98,36.9 65.3,36.9 65.7,36.49 68.32,36.49 69.21,37.38 70.48,37.38 71.01,36.85 72.54,36.85 73.91,38.22 74.8,38.22 75.2,38.62 v1(76.47,38.62)
RIP: length 58.3
  TOP w0.102: v1(31.14,37.28) 31.3,37.44 v1(31.3,37.94)
  TOP w0.203: U13157.24 31.3,38.26 v1(31.3,37.94)
  TOP w0.508: v1(77.34,39.69) 77.5,39.85 R67350.1
  IN1 w0.508: v1(77.34,39.69) 77.01,39.36 75.03,39.36 74.54,39.84 70.56,39.84 69.16,38.45 67.86,38.45 67.73,38.58 66.17,38.58 65.81,38.22 63.34,38.22 62.61,37.48 59.28,37.48 58.95,37.81 58.95,38.88 58.39,39.44 57.45,39.44 56.46,38.45 52.16,38.45 50.68,39.92 49.03,39.92 48.2,39.08 43.78,39.08 43.15,38.45 40.76,38.45 40.36,38.85 40.36,39.92 39.87,40.4 v1(39.03,40.4) 35.71,40.4 35,39.69 33.05,39.69 v1(31.3,37.94)
  BOTTOM w0.508: v1(39.03,40.4) 39.24,40.61 39.24,41.23 L4235.2 ; v1(31.3,37.94) 31.45,38.09 C94630.2
ROM_CS: length 26.6
  TOP w0.112: U13114.BJ4 v2(145.01,115.96)
  TOP w0.14: R21549.2 126.41,101.74 v1(126.46,101.69)
  BOTTOM w0.14: v2(145.01,115.96) 144.83,115.78 144.83,115.15 144.57,114.9 144.57,114.82 144.37,114.62 144.17,114.62 142.74,113.2 142.66,113.2 141.15,111.69 140.79,111.69 139.34,110.24 136.42,110.24 136.12,109.94 135.21,109.94 131.97,106.7 131.97,106.14 v1(131.08,105.25) 127.66,101.82 126.59,101.82 v1(126.46,101.69)
ROM_CS_R: length 6.2
  TOP w0.14: R21548.2 124.86,102.45 124.4,102 TP13102.1 124.43,101.74 R21549.1 125.17,101.13 125.5,100.8 126.89,100.8 127.35,100.35 U13116.1
ROM_SCLK: length 27.8
  TOP w0.14: U13114.BK3 144.66,114.78 144.31,114.44 144.31,114.09 144.09,113.86 143.5,113.86 142.9,113.25 v1(142.06,113.25) ; v1(131.21,102.07) 131.32,102.18 R21550.2 133.51,101.92 R21541.2 R21538.1
  IN4 w0.089: v1(132.13,110.07) 132.13,109.16 130.83,107.87 130.83,106.6 130.58,106.34 130.58,102.71 v1(131.21,102.07)
  BOTTOM w0.14: v1(142.06,113.25) 141.35,113.25 140.75,112.65 139.71,112.65 138.38,111.33 135.08,111.33 134.72,110.96 133.01,110.96 v1(132.13,110.07)
ROM_SCLK_R: length 6.6
  TOP w0.14: R21550.1 132.61,102.63 TP13105.1 130.7,102.84 129.89,103.65 U13116.6 129.89,106.29 v1(130.02,106.42)
ROM_SI: length 18.8
  TOP w0.112: 142.77,114.24 143.1,114.57 143.61,114.57 U13114.BK2
  TOP w0.14: v1(141.46,112.7) 141.46,113.52 142.18,114.24 142.77,114.24 ; v1(133.75,109.19) 133.85,109.08 v1(133.85,107.74) 133.32,107.2 R21551.1 133.32,105.58 133.51,105.39 R21539.2 R21536.1
  BOTTOM w0.14: v1(133.75,109.19) 134.82,110.26 135.99,110.26 136.29,110.56 139.21,110.56 140.66,112.01 141.02,112.01 141.46,112.44 v1(141.46,112.7)
ROM_SI_R: length 4.4
  TOP w0.14: U13116.5 131.16,106.62 131.44,106.9 TP13104.1 132.87,106.77 R21551.2
ROM_SO: length 31.7
  TOP w0.112: U13114.BK4 145.36,114.8 145.01,114.45
  TOP w0.14: v1(129.31,102.71) 128.62,102.02 U13116.2 128.62,98.87 127.68,97.93 TP13103.1 127.88,96.77 R21540.2 R21537.1 ; 145.01,114.45 145.01,112.57 144.72,112.28 144.06,112.28 143.78,112.01 v1(143.33,112.01)
  BOTTOM w0.14: v1(143.33,112.01) 142.69,112.01 140.61,109.92 136.55,109.92 136.26,109.62 135.34,109.62 132.48,106.76 132.48,104.85 132.12,104.49 131.08,104.49 v1(129.31,102.71)
RSMRST#: length 185.3
  TOP w0.14: U49.112 186.4,64.06 187.28,63.18 187.28,60.61 186.37,59.7 186.37,57.99 v1(185.62,57.24)
  IN4 w0.089: v1(185.82,46.63) 188.03,44.42 198.83,44.42 199.05,44.64 199.05,45.91 199.91,46.77 202.55,46.77 203.59,45.73 262.38,45.73 262.64,45.47 269.5,45.47 271.9,47.87 286.87,47.87 288.54,46.19 291.73,46.19 293.54,48.01 299.44,48.01 300.85,49.42 303.42,49.42 303.73,49.72 304.08,49.72 304.84,48.97 313.83,48.97 314.06,49.2 315.23,49.2 316.12,48.3 320.14,48.3 v1(320.57,48.73)
  BOTTOM w0.14: R21129.1 314.11,57.89 C94814.1 315.57,57.89 315.84,57.62 315.84,56.1 316.23,55.71 316.86,55.71 318.81,53.75 318.81,52.65 319.21,52.26 319.23,52.26 319.5,51.98 319.5,50.42 320.57,49.36 v1(320.57,48.73) ; v1(185.82,46.63) 185.34,47.11 182.82,47.11 182.11,47.82 181.25,47.82 179.83,49.23 179.83,49.31 179.44,49.7 179.09,49.7 178.92,49.87 178.92,50.45 179.06,50.6 179.06,51.96 181.2,54.09 182.47,54.09 v1(185.62,57.24)
RST_LED#: length 2.3
  TOP w0.14: U13093.24 263.9,45.31 264.08,45.13 v1(264.76,45.13) 264.89,45.25 R21054.2
RSTN: length 3.5
  TOP w0.14: U13143.2 349.01,67.91 v1(348.79,67.68)
  BOTTOM w0.14: v1(348.79,67.68) 347.25,66.14 R21481.2
RTC_N03: length 3.4
  TOP w0.508: Q7935.2 35.3,75.3 v1(35.78,74.82) 36.01,74.59 R67270.1 35.58,73.94 35.54,73.98 R67269.2
RTC_RST#: length 22.5
  TOP w0.102: U13113.BC10 312.56,57.23 312.77,57.44 313.88,57.44 313.96,57.36
  TOP w0.114: 313.96,57.36 314.03,57.29 315.11,57.29 315.36,57.04 315.59,57.04 v1(316.3,56.33)
  TOP w0.14: 324.25,51.4 323.29,51.4 322.85,50.97 Q7933.3 322.31,50.17 v1(322.22,50.26)
  BOTTOM w0.14: v1(316.3,56.33) 316.69,56.72 317.17,56.72 317.69,56.2 318,56.2 318.7,55.5 321.55,55.5 323.07,53.98 323.07,53.17 323.87,52.37 323.87,51.97 322.97,51.06 322.97,50.23 R21137.2 323.07,49.66 323.03,49.62 C94810.1 322.6,49.88 v1(322.22,50.26)
RTC_X1: length 10.7
  TOP w0.102: 315.7,55.54 315.52,55.71 315.52,56.19 314.93,56.78 313.76,56.78 313.58,56.96 313.15,56.96 313.08,56.89 312.47,56.89 U13113.BC9
  TOP w0.14: Y1001.2 319.89,51.98 319.08,52.79 318.97,52.79 318.75,53.01 C94819.2 318.29,53.2 317.89,53.2 R21217.1 317,54.1 317,54.14 316.99,54.15 316.99,54.25 315.7,55.54
RTC_X2: length 10.6
  TOP w0.102: 316.06,55.9 316.06,55.91 315.96,55.91 315.88,55.84 315.79,55.84 315.7,55.93 315.7,56.27 315,56.97 313.84,56.97 313.66,57.15 313.43,57.15 313.31,57.26 313.06,57.26 U13113.BD10
  TOP w0.14: Y1001.1 320.42,53.81 320.26,53.66 319.78,53.66 319.43,53.31 319.19,53.31 C94821.2 318.2,53.73 318.11,53.73 317.52,54.31 R21217.2 317.52,54.45 316.06,55.9
RVN: length 83.4
  TOP w0.203: U13157.26 32.92,37.1 32.89,37.08 32.89,36.82 v1(32.74,36.67)
  TOP w0.508: v1(74.72,37.46) 74.72,38.04 75.84,39.16 75.84,40.45 76.83,41.44 76.83,42.46 79.27,44.9 84.07,44.9 85.95,46.78 85.95,47.66 85.19,48.43 84.78,48.43 83.93,49.28 CN2039.1
  IN1 w0.508: v1(74.72,37.46) 74.92,37.25 74.92,36.26 74.05,35.39 72.25,35.39 71.89,35.03 69.88,35.03 69.67,34.81 65.98,34.81 65.28,35.52 64.33,35.52 63.32,34.51 62.61,34.51 61.89,35.22 61.06,35.22 60.26,34.42 57.97,34.42 56.74,35.65 55.82,35.65 55.38,36.1 52.05,36.1 49.85,33.9 48.99,33.9 48.13,34.76 39.67,34.76 39.09,34.18 38.32,34.18 37.43,35.07 36.85,35.07 34.49,37.43 33.19,37.43 32.74,36.97 v1(32.74,36.67)
  IN4 w0.508: v1(32.74,36.67) 32.74,36.29 33.09,35.93 36.49,35.93 37.04,36.48 37.85,36.48 38.37,37 v1(38.37,37.81)
  BOTTOM w0.508: C94051.2 v1(38.37,37.81) 38.02,38.17 L4234.2
S5_ON: length 375
  TOP w0.14: U49.100 191.2,68.24 v1(191,68.44) ; v1(247.75,161.76) 247.75,161.71 246.86,160.82 PR266.1 ; v1(41.58,74.07) PR174.2
  TOP w0.203: v1(88.03,81.32) 88.31,81.04 PR100.1
  IN1 w0.089: v1(247.75,161.76) 247.7,161.81 247.7,162.07 246.34,163.43 237.55,163.43 235.65,161.54 235.65,159.3 232.43,156.07 232.43,153.64 228.46,149.67 223.95,149.67 221.97,151.65 216.81,151.65 214.7,149.55 214.7,142.23 219.86,137.08 223.34,137.08 224.3,136.11 224.3,131.71 222.41,129.82 222.41,129.53 220.52,127.64 220.52,117.73 217.61,114.82 215.68,114.82 206.25,105.39 206.25,97.29 207.05,96.49 207.05,94.78 206.19,93.92 206.19,92.34 207.05,91.48 207.05,74.58 206.01,73.54 205.84,73.54 205.36,73.06 202.06,73.06 200.87,71.87 196.79,71.87 193.87,68.95 191.51,68.95 v1(191,68.44) ; v1(103.12,58.23) 103.63,58.74 104.34,58.74 104.54,58.94 104.54,59.88 103.04,61.38 102.14,61.38 100.53,63 100.53,64.28 100.78,64.53 100.78,74.18 98.19,76.77 94.54,76.77 94.02,77.28 92.38,77.28 88.92,80.74 88.62,80.74 v1(88.03,81.32)
  IN3 w0.079: v1(191,68.44) 190.63,68.07 183.09,68.07 182.37,67.35 179.6,67.35 178.72,66.47 176.19,66.47 175.89,66.17 171.98,66.17 166.03,60.23 166.03,56.25 164.36,54.58 162.25,54.58 160.48,56.35 148.09,56.35 146.41,54.67 141.6,54.67 140.47,55.8 134.72,55.8 133.72,54.8 118.28,54.8 117.42,55.66 111.36,55.66 110.54,56.48 107.84,56.48 105.56,58.77 103.83,58.77 103.3,58.23 v1(103.12,58.23) 103.12,56.2 100.38,53.46 88.24,53.46 86.33,51.55 73.56,51.55 72.66,52.44 69.61,52.44 67.95,54.1 66.61,54.1 65.65,55.07 64.39,55.07 62.71,56.75 62.31,56.75 59.71,59.35 59.71,59.47 59.35,59.83 55.85,59.83 55.26,60.42 49.67,60.42 49.06,61.03 47.44,61.03 44.77,63.69 44.01,63.69 42.9,64.81 42.9,72.76 v1(41.58,74.07)
  BOTTOM w0.14: v1(191,68.44) 190.22,67.66 R382.1 ; v1(103.12,58.23) 103.3,58.23 103.77,57.76 PR131.2
S_GPIO: length 13.4
  TOP w0.102: U13113.AR45 308.17,74.5 308.17,76.02
  TOP w0.14: 308.17,76.02 307.77,76.42 R21242.1 307.28,78.24 307.28,79.04 v1(307,79.32) 307.03,79.34 R21236.2
  BOTTOM w0.14: v1(307,79.32) 307,80.1 306.37,80.74 306.37,81.65 305.9,82.12 304.01,82.12 303.91,82.01 303.91,81.31 R21281.1
SATA_LED#: length 8.2
  TOP w0.102: 303.17,75.65 303.17,75.38 303.27,75.28 303.27,74.26 303.12,74.11 U13113.AD44
  TOP w0.14: R21178.1 300.25,80.08 v1(300.68,79.65) 301,79.32 301,77.63 301.47,77.17 301.83,77.17 301.99,77.01 302.45,77.01 302.79,76.66 302.79,76.03 303.17,75.65
SATA_RXN0_C: length 8.4
  TOP w0.14: v1(73.71,29.15) 73.91,28.95 73.91,28.6 74.24,28.27 75.2,28.27 75.31,28.15 CN11.5
  BOTTOM w0.14: v1(73.71,29.15) 73.91,28.95 73.91,28.62 73.73,28.44 72.36,28.44 70.58,26.66 70.37,26.66 R67362.1
SATA_RXP0_C: length 8.4
  TOP w0.14: v1(74.39,29.15) 74.18,28.93 74.18,28.71 74.35,28.53 75.2,28.53 75.31,28.65 CN11.6
  BOTTOM w0.14: v1(74.39,29.15) 74.18,28.93 74.18,28.51 73.84,28.17 72.47,28.17 70.69,26.39 70.31,26.39 R67363.1
SATA_TXN0_C: length 9.4
  TOP w0.14: v1(74.29,27.7) 74.05,27.46 74.05,27.17 74.19,27.03 75.2,27.03 75.31,27.15 CN11.3
  BOTTOM w0.14: C96241.2 70.32,24.25 70.61,24.25 70.96,24.6 70.96,25.57 72.19,26.8 73.9,26.8 74.14,27.04 74.14,27.55 v1(74.29,27.7)
SATA_TXP0_C: length 9.4
  TOP w0.14: CN11.2 75.31,26.65 75.2,26.77 74.08,26.77 73.78,27.06 73.78,27.45 v1(73.58,27.65)
  BOTTOM w0.14: C96240.2 70.31,24.52 70.5,24.52 70.7,24.71 70.7,25.68 72.08,27.07 73.79,27.07 73.87,27.15 73.87,27.49 73.71,27.65 v1(73.58,27.65)
SENSEA: length 5.3
  TOP w0.203: v1(33.12,28.39) 33.12,28.49 32.74,28.87 32.1,28.87 31.94,28.71 U13108.48
  BOTTOM w0.14: R21457.1 33.32,29.07 33.12,28.87 v1(33.12,28.39) 34.41,28.39 34.92,27.88 R21456.2
SENSEA_EC: length 39.7
  TOP w0.14: v1(18.84,9.18) 18.41,9.18 18,9.59 R67310.1 ; Q7938.3 35.63,28.41 v1(36.27,27.78)
  IN5 w0.089: v1(18.84,9.18) 18.84,9.06 19.4,8.5 24.1,8.5 25.22,9.62 25.22,13.66 26.08,14.52 26.08,16.87 26.93,17.72 26.93,19.04 28.85,20.95 29.48,20.95 29.94,20.49 34.59,20.49 34.89,20.79 34.89,21.71 36.01,22.83 36.82,22.83 37.29,23.29 37.29,23.75 36.64,24.39 36.64,27.4 v1(36.27,27.78)
  BOTTOM w0.14: R21456.1 35.19,26.7 v1(36.27,27.78)
SENSEB: length 13.9
  TOP w0.203: v1(32.45,28.36) 32.45,27.93 32.13,27.6 31.74,27.6 31.54,27.81 U13108.47
  BOTTOM w0.14: R22092.1 32.3,28.51 v1(32.45,28.36) 32.91,27.91 33.7,27.91 33.95,27.65 33.95,26.71 31.85,24.6 31.16,24.6 29.69,23.13 v1(28.75,23.13) 27.96,23.92 R22093.1
SIO_EXT_SCI#: length 152
  TOP w0.14: v2(312.19,53.81) 312.16,53.84 311.75,53.84 U13113.BA4 ; v1(182.14,55.19) 182.14,55.8 181.6,56.33 180.82,56.33 180.13,57.01 179.42,57.01 179.21,56.8 U49.23 ; v1(313.58,52.04) 313.58,50.64 313.89,50.33 R21317.2
  IN3 w0.079: v1(182.14,55.19) 182.21,55.26 182.21,55.49 182.75,56.03 183.07,56.03 183.53,55.57 190.93,55.57 191.94,54.56 193.47,54.56 194.13,53.9 195.24,53.9 195.74,53.4 198.13,53.4 198.71,52.82 199.53,52.82 199.8,52.55 202.81,52.55 203.13,52.87 205.71,52.87 206.14,53.31 206.14,54.88 206.75,55.49 207.51,55.49 207.79,55.21 207.79,54.91 209.44,53.26 225.98,53.26 226.18,53.46 270,53.46 271.92,51.53 286.38,51.53 286.67,51.82 289.34,51.82 290.16,51 291.63,51 292.25,50.38 297.2,50.38 297.45,50.63 298.82,50.63 299.5,51.32 300.21,51.32 300.9,50.63 303.94,50.63 305.07,51.76 305.65,51.76 307.49,49.91 312,49.91 313.58,51.5 v1(313.58,52.04)
  BOTTOM w0.14: v2(312.19,53.81) 312.19,53.64 v1(312.77,53.05) 313.58,52.24 v1(313.58,52.04)
SIO_EXT_SMI#: length 140.3
  TOP w0.14: R67213.2 294.12,79.74 293.87,79.49 v1(293.87,79.29)
  IN3 w0.079: v1(293.87,79.29) 293.87,79.34 292.66,80.55 290.91,80.55 290.22,79.86 289.68,79.86 287.86,81.68 285.72,81.68 284.54,82.86 283.17,82.86 281.25,84.79 279.85,84.79 278.06,86.58 211.42,86.58 206.75,81.91 205.28,81.91 202.97,79.6 201.01,77.64 v1(200.25,77.64)
  IN5 w0.089: v1(179.52,59.88) 179.99,60.35 190.07,60.35 190.88,61.15 190.88,63.82 191.92,64.86 194.68,64.86 201.84,72.02 201.84,74.22 202.36,74.75 202.36,77.49 201.81,78.04 200.94,78.04 200.54,77.64 v1(200.25,77.64)
  BOTTOM w0.14: R67291.1 179.06,60.34 v1(179.52,59.88)
SIO_EXT_SMI#_R: length 9.5
  TOP w0.14: U13113.M45 296.91,74.64 294.53,77.02 R21090.1 294.77,77.85 295.02,78.1 295.02,79.48 294.9,79.59 R67213.1 R67214.1 295.68,80.36 295.81,80.5 296.65,80.5 v1(296.87,80.28)
SIO_RCIN#: length 162.5
  TOP w0.14: U13113.AT17 309.16,60.19 v2(309.01,60.04) ; U49.4 179.73,64.4 179.84,64.29 181.11,64.29 181.55,63.85 181.55,63 182.44,62.12 182.44,62.12 v1(183.26,61.31)
  IN1 w0.089: v1(319.17,56.71) 318.62,56.71 316.87,58.46 313.63,58.46 312.97,59.12 312.21,59.12 311.93,59.4 310.54,59.4 310.22,59.72 309.58,59.72 309.27,60.04 v2(309.01,60.04)
  IN2 w0.089: v1(183.26,61.31) 183.4,61.17 183.4,61.04 186.18,58.26 189.5,58.26 189.63,58.13 191.66,58.13 191.92,57.88 191.92,54.32 194.2,52.04 194.68,52.04 196.94,49.77 228.99,49.77 230.05,48.71 232.44,48.71 233.02,49.29 240.73,49.29 240.94,49.07 248.2,49.07 249.04,49.92 258.35,49.92 258.94,50.5 260.74,50.5 260.9,50.66 265.04,50.66 265.11,50.73 269.46,50.73 269.83,51.1 288.3,51.1 289.58,49.83 297.3,49.83 298.09,49.03 299.26,49.03 301.01,50.79 301.01,51.12 301.48,51.59 302.72,51.59 303.19,52.06 304.25,52.06 304.72,52.53 305.86,52.53 306.49,53.17 306.99,53.17 308.55,54.73 308.55,55.52 308.76,55.72 308.76,58.08 309.01,58.34 v2(309.01,60.04)
  BOTTOM w0.14: R21089.1 319.45,57.12 319.17,56.84 v1(319.17,56.71)
SKTOCC_N: length 5.8
  TOP w0.14: U41.BR33 265.55,127.7 266.11,127.7 266.21,127.8 266.69,127.8 268.24,129.35 268.24,130.39 268.37,130.52 R556.2
SKTOCC_N_R: length 93.1
  TOP w0.102: 300.73,75.3 300.73,74.95 300.91,74.78 300.91,74.11 300.84,74.04 U13113.Y44
  TOP w0.14: v1(270.4,131.03) 270.4,131.02 R556.1 ; 300.73,75.3 300.12,75.91 299.99,75.91 v1(299.74,76.17)
  IN2 w0.089: v1(270.4,131.03) 269.92,130.55 269.92,129.48 270.9,128.5 270.9,127.78 270.54,127.42 269.86,127.42 267.18,124.73 262.71,124.73 262.05,124.07 262.05,117.54 262.88,116.7 265.05,116.7 274.54,107.21 274.54,104.16 276.32,102.38 276.32,96.29 277.29,95.31 277.29,81.82 282.44,76.67 283.48,76.67 v1(283.89,76.27)
  IN3 w0.079: v1(283.89,76.27) 284.75,75.41 292.75,75.41 293.08,75.74 296.35,75.74 296.9,76.29 299.61,76.29 v1(299.74,76.17)
SM_INTRUDER#: length 7
  TOP w0.102: U13113.BE11 313.82,57.8 314.12,57.5 315.2,57.5 315.45,57.25 316.28,57.25 316.77,56.76
  TOP w0.14: R21231.1 v1(318.54,56.23) 317.64,56.23 317.11,56.76 316.77,56.76
SM_RCOMP_0: length 7.8
  TOP w0.305: U41.G1 228.84,103.56 228.09,102.81 228.09,99.38 227.73,99.03 v1(227.73,98.11)
  BOTTOM w0.305: v1(227.73,98.11) 227.73,98.37 227.53,98.57 R195.1
SM_RCOMP_1: length 10.2
  TOP w0.305: v1(227.71,96.49) 227.74,96.45 228.17,96.45 230.14,98.42 230.14,102.58 229.73,102.99 229.73,104.37 U41.H1
  BOTTOM w0.305: R193.2 227.55,96.33 v1(227.71,96.49)
SM_RCOMP_2: length 12.7
  TOP w0.305: U41.J2 230.01,104.7 230.19,104.51 230.19,103.65 230.96,102.88 v1(230.96,99.08) 230.96,98.09 228.51,95.64 227.85,95.64 v1(227.71,95.5)
  BOTTOM w0.254: v1(227.71,95.5) 227.48,95.27 R192.1
SM_VREF: length 123.6
  TOP w0.254: U41.BN13 264.26,112.75 v1(264.26,112.83)
  BOTTOM w0.508: v1(264.26,112.83) 265.71,112.83 266.24,113.35 266.24,113.63 266.59,113.99 267.64,113.99 270.63,110.99 270.78,110.99 272.36,109.41 272.36,107.79 275.2,104.94 275.2,103.62 275.79,103.04 275.79,99.76 278.73,96.82 278.73,91.81 285.36,85.18 285.36,82.13 284.12,80.89 284.12,77.94 283.24,77.07 283.24,72.6 283.37,72.47 283.37,63.34 282.72,62.69 282.72,56.27 279.72,53.28 279.72,51.96 278.05,50.29 266.5,50.29 264.03,47.82 259.8,47.82 258.49,46.51 249.03,46.51 245.7,49.85 v1(242.55,49.85) 240.3,49.85 239.05,51.1 C94889.1 R21406.1
SMB1ALERT#: length 12.9
  TOP w0.14: U13113.AT27 308.68,65.82 v2(308.68,65.83)
  BOTTOM w0.14: R21230.2 R21233.1 317.43,68.14 316.22,68.14 315.85,67.76 315.35,67.76 314.73,67.15 313.51,67.15 312.36,66.01 312.36,65.83 312,65.46 311.46,65.46 311.42,65.5 309.5,65.5 v1(309.39,65.4) 309.11,65.4 v2(308.68,65.83)
SMB_ME0_CLK: length 8
  TOP w0.14: U13113.AY44 311.21,73.46 v2(311.25,73.42)
  BOTTOM w0.14: R21139.2 316.11,77.55 315.23,76.67 313.68,76.67 v1(311.91,74.9) 311.22,74.21 311.22,73.45 v2(311.25,73.42)
SMB_ME0_DAT: length 7.1
  TOP w0.14: v2(310.74,71.75) 310.89,71.59 311.77,71.59 U13113.BB39
  BOTTOM w0.14: R21140.2 315.36,73.12 314.16,71.92 313.6,71.92 313.57,71.95 v1(313.31,71.95) 313.11,71.76 310.75,71.76 v2(310.74,71.75)
SMB_ME1_CLK: length 11.1
  TOP w0.112: U13113.AW42 310.19,72.94 310.19,74.17 310.1,74.26 310.1,74.46 310.19,74.55 310.19,75.48
  TOP w0.14: v1(311.47,81.47) 311.89,81.06 Q7909.4 311.04,80.86 R21143.2 310.52,80.22 311.35,79.39 311.35,78.45 311.44,78.36 311.44,77.78 310.17,76.51 310.17,75.52 310.19,75.5 310.19,75.48
SMB_ME1_DAT: length 7.4
  TOP w0.112: 310.42,76.13 310.42,74.4 U13113.AW45
  TOP w0.14: v1(313.94,79.93) 313.87,79.86 Q7909.1 312.94,79.55 312.94,78.76 R21144.2 312.06,77.66 310.99,76.6 310.89,76.6 310.42,76.13
SMB_ME2_CLK: length 8.3
  TOP w0.102: 316.08,72.69 315.45,72.06 315.45,71.08 314.29,69.92 313.78,69.92 313.55,69.68 313.47,69.68 313.13,69.35 313,69.35 U13113.BD34
  TOP w0.14: R21227.1 318.63,72.96 318.36,72.69 316.08,72.69
SMB_ME2_DAT: length 1.6
  TOP w0.127: v2(310.94,70.42) 310.94,70.04 U13113.AW35
  BOTTOM w0.14: v2(310.94,70.42) 311.3,70.78 R21228.1
SMB_ME3_CLK: length 6.7
  TOP w0.102: 315.23,71.21 315.23,71.15 314.2,70.12 313.7,70.12 313.46,69.89 313.39,69.89 313.05,69.55 312.71,69.55 312.48,69.78 U13113.BC35
  TOP w0.127: 315.23,71.21 315.23,72.46 316.02,73.24 R21224.1
SMB_ME3_DAT: length 1.6
  TOP w0.127: U13113.BA35 311.4,70.16 v2(311.65,70.42)
  BOTTOM w0.14: R21226.1 312.19,70.7 311.9,70.42 v2(311.65,70.42)
SMB_ME4_CLK: length 8.5
  TOP w0.127: U13113.BD39 312.92,71.51 313.14,71.73 313.84,71.73 314.29,72.17 314.29,72.81 315.47,73.99 315.47,74.5 316.89,75.91 R21221.1
  TOP w0.14: v1(318.46,76.34) 317.21,76.34 317.04,76.17 R21221.1
SMB_ME4_DAT: length 8.3
  TOP w0.102: 315.78,71.59 315.78,71.12 314.37,69.71 313.87,69.71 U13113.BE34
  TOP w0.14: R21223.1 319.2,72.77 318.61,72.17 316.1,72.17 315.77,71.85 315.77,71.6 315.78,71.59
SMB_PCH_CLK: length 10.1
  TOP w0.112: U13113.AW44 310.66,74.08 310.66,74.87
  TOP w0.14: Q7911.6 315.58,80.7 v1(315.21,80.33) 314.7,79.82 314.7,78.66 313.75,77.71 R21146.2 312.12,76.19 311.04,76.19 310.79,75.94 310.79,75 310.66,74.87
SMB_PCH_DAT: length 19.2
  TOP w0.14: v1(317.77,79.85) 318.36,80.43 v1(319.07,80.43) 319.25,80.43 320.16,81.35 320.16,81.91 319.73,82.34 317.4,82.34 317.19,82.13 Q7911.3 ; v2(311.7,72.94) 311.8,73.03 U13113.BB43
  BOTTOM w0.14: v2(311.7,72.94) 311.86,73.09 311.86,74.08 313.91,76.14 315.45,76.14 R21147.2 316.62,76.29 317.14,76.29 317.52,76.67 317.52,78.96 317.77,79.21 v1(317.77,79.85)
SMB_RUN_CLK: length 166.5
  TOP w0.14: v1(211.86,71.34) 213.04,72.52 213.04,73.45 213.18,73.6 CN2062.253 ; CN2063.253 213.18,60.88 213.05,60.75 213.05,59.76 212.75,59.45 211.27,59.45 v1(210.81,59) ; Q7911.1 317.38,81.13 317.52,80.98 R21174.2 319.04,80.98 v1(319.68,81.63)
  IN1 w0.089: v1(210.81,59) 210.87,59.05 210.87,59.78 209.35,61.3 209.35,62.12 210.33,63.1 210.33,64.6 210.73,65 210.73,69.63 211.4,70.3 211.4,70.88 v1(211.86,71.34)
  IN2 w0.089: v1(210.81,59) 210.81,58.71 212.31,57.21 212.31,54.78 213.09,54 247.14,54 248.01,54.87 248.01,60.64 249.12,61.75 281.61,61.75 282.15,61.22 283.61,61.22 284.48,62.09 286.82,62.09 287.34,62.6 287.34,63.8 284.4,66.73 284.4,72.51 288.93,77.04 288.93,80.26 291.48,82.81 318.78,82.81 319.68,81.91 v1(319.68,81.63)
SMB_RUN_DAT: length 158.4
  TOP w0.14: CN2062.254 212.94,69.04 v1(211.88,70.1) ; v1(211.5,58.92) 212.62,57.8 212.62,54.86 212.94,54.54 CN2063.254 ; Q7911.4 314.98,82.13 314.96,82.14 R21172.2 313.84,82.14 313.53,82.45 312.88,82.45 312.49,82.85 304.57,82.85 304.11,83.3 301.11,83.3 v1(300.63,83.79)
  IN1 w0.089: v1(211.5,58.92) 211.35,59.07 211.35,60.01 209.82,61.54 209.82,61.92 210.84,62.95 210.84,64.45 211.2,64.8 211.2,69.41 v1(211.88,70.1)
  IN2 w0.089: v1(211.5,58.92) 211.58,58.92 213,57.5 213,55.07 213.6,54.47 246.95,54.47 247.54,55.07 247.54,60.84 248.93,62.22 281.81,62.22 282.34,61.69 283.42,61.69 284.29,62.56 286.63,62.56 286.87,62.8 286.87,63.6 283.93,66.54 283.93,72.71 288.46,77.24 288.46,80.46 291.28,83.28 300.12,83.28 v1(300.63,83.79)
SMBALERT#: length 6.9
  TOP w0.14: v2(311.73,72.33) 311.73,72.36 312.06,72.69 U13113.BB41
  BOTTOM w0.14: R21274.2 R21276.1 315.24,75.51 v1(314.52,74.79) 313.66,73.93 313.41,73.93 312.99,73.51 312.99,72.88 312.85,72.74 312.16,72.74 311.78,72.36 311.75,72.36 v2(311.73,72.33)
SMDDR_VREF_DQ0_M3: length 5.3
  TOP w0.127: 268.37,112.11 264.91,112.11 U41.BP13
  TOP w0.508: 268.37,112.11 268.63,111.85 T4.1
SMDDR_VREF_DQ1_M3: length 124.5
  TOP w0.279: 266.34,112.97 266.19,112.82 265.56,112.82 265.24,112.5 U41.BR13
  TOP w0.508: v1(267,113.11) 266.47,113.11 266.34,112.97
  BOTTOM w0.508: v1(267,113.11) 267.79,112.32 267.87,112.32 270.21,109.97 270.34,109.97 271.34,108.97 271.34,107.33 273.83,104.84 273.83,102.81 274.7,101.95 274.7,99.2 277.03,96.87 277.03,78.81 280.94,74.9 280.94,72.08 281.34,71.69 281.34,64.49 280.69,63.85 280.69,57.12 276.7,53.13 270.98,53.13 270.55,53.56 266.87,53.56 266.53,53.9 263.03,53.9 262.67,54.26 258.49,54.26 256.82,52.59 252.65,52.59 251.3,51.25 v1(246.35,51.25) 245.54,51.25 243.94,52.85 243.23,52.85 241.45,54.63 241.45,67.38 240.48,68.34 R21433.1 C94919.1
