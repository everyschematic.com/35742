# Allegro board DAZGLMB1ED0 dazglmb1ed0-d-ver a-165 (.BRD) .brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
BGA2152-NVIDIA-N17E-G2
  round 0.305 smd: A2(-17.85,-17.15) A3(-17.85,-16.45) A4(-17.85,-15.75) A5(-17.85,-15.05) A6(-17.85,-14.35) A8(-17.85,-12.95) A9(-17.85,-12.25) A11(-17.85,-10.85) A12(-17.85,-10.15) A14(-17.85,-8.75) A15(-17.85,-8.05) A17(-17.85,-6.65) A18(-17.85,-5.95) A20(-17.85,-4.55) A21(-17.85,-3.85) A23(-17.85,-2.45) A24(-17.85,-1.75) A26(-17.85,-0.35) A27(-17.85,0.35) A29(-17.85,1.75) A30(-17.85,2.45) A32(-17.85,3.85) A33(-17.85,4.55) A35(-17.85,5.95) A36(-17.85,6.65) A38(-17.85,8.05) A39(-17.85,8.75) A41(-17.85,10.15) A42(-17.85,10.85) A44(-17.85,12.25) A45(-17.85,12.95) A47(-17.85,14.35) A48(-17.85,15.05) A49(-17.85,15.75) A50(-17.85,16.45) A51(-17.85,17.15) AA1(-3.85,-17.85) AA2(-3.85,-17.15) AA3(-3.85,-16.45) AA4(-3.85,-15.75) AA5(-3.85,-15.05) AA6(-3.85,-14.35) AA7(-3.85,-13.65) AA8(-3.85,-12.95) AA9(-3.85,-12.25) AA10(-3.85,-11.55) AA11(-3.85,-10.85) AA14(-3.85,-8.75) AA15(-3.85,-8.05) AA16(-3.85,-7.35) AA17(-3.85,-6.65) AA18(-3.85,-5.95) AA19(-3.85,-5.25) AA20(-3.85,-4.55) AA21(-3.85,-3.85) AA22(-3.85,-3.15) AA23(-3.85,-2.45) AA24(-3.85,-1.75) AA25(-3.85,-1.05) AA26(-3.85,-0.35) AA27(-3.85,0.35) AA28(-3.85,1.05) AA29(-3.85,1.75) AA30(-3.85,2.45) AA31(-3.85,3.15) AA32(-3.85,3.85) AA33(-3.85,4.55) AA34(-3.85,5.25) AA35(-3.85,5.95) AA36(-3.85,6.65) AA37(-3.85,7.35) AA38(-3.85,8.05) AA39(-3.85,8.75) AA42(-3.85,10.85) AA43(-3.85,11.55) AA44(-3.85,12.25) AA45(-3.85,12.95) AA46(-3.85,13.65) AA47(-3.85,14.35) AA48(-3.85,15.05) AA49(-3.85,15.75) AA50(-3.85,16.45) AA51(-3.85,17.15) AA52(-3.85,17.85) AB2(-3.15,-17.15) AB4(-3.15,-15.75) AB6(-3.15,-14.35) AB8(-3.15,-12.95) AB10(-3.15,-11.55) AB13(-3.15,-9.45) AB14(-3.15,-8.75) AB15(-3.15,-8.05) AB16(-3.15,-7.35) AB17(-3.15,-6.65) AB18(-3.15,-5.95) AB19(-3.15,-5.25) AB20(-3.15,-4.55) AB21(-3.15,-3.85) AB22(-3.15,-3.15) AB23(-3.15,-2.45) AB24(-3.15,-1.75) AB25(-3.15,-1.05) AB26(-3.15,-0.35) AB27(-3.15,0.35) AB28(-3.15,1.05) AB29(-3.15,1.75) AB30(-3.15,2.45) AB31(-3.15,3.15) AB32(-3.15,3.85) AB33(-3.15,4.55) AB34(-3.15,5.25) AB35(-3.15,5.95) AB36(-3.15,6.65) AB37(-3.15,7.35) AB38(-3.15,8.05) AB39(-3.15,8.75) AB40(-3.15,9.45) AB43(-3.15,11.55) AB45(-3.15,12.95) AB47(-3.15,14.35) AB49(-3.15,15.75) AB51(-3.15,17.15) AC1(-2.45,-17.85) AC2(-2.45,-17.15) AC3(-2.45,-16.45) AC4(-2.45,-15.75) AC5(-2.45,-15.05) AC6(-2.45,-14.35) AC7(-2.45,-13.65) AC8(-2.45,-12.95) AC9(-2.45,-12.25) AC10(-2.45,-11.55) AC11(-2.45,-10.85) AC14(-2.45,-8.75) AC15(-2.45,-8.05) AC16(-2.45,-7.35) AC17(-2.45,-6.65) AC18(-2.45,-5.95) AC19(-2.45,-5.25) AC20(-2.45,-4.55) AC21(-2.45,-3.85) AC22(-2.45,-3.15) AC23(-2.45,-2.45) AC24(-2.45,-1.75) AC25(-2.45,-1.05) AC26(-2.45,-0.35) AC27(-2.45,0.35) AC28(-2.45,1.05) AC29(-2.45,1.75) AC30(-2.45,2.45) AC31(-2.45,3.15) AC32(-2.45,3.85) AC33(-2.45,4.55) AC34(-2.45,5.25) AC35(-2.45,5.95) AC36(-2.45,6.65) AC37(-2.45,7.35) AC38(-2.45,8.05) AC39(-2.45,8.75) AC42(-2.45,10.85) AC43(-2.45,11.55) AC44(-2.45,12.25) AC45(-2.45,12.95) AC46(-2.45,13.65) AC47(-2.45,14.35) AC48(-2.45,15.05) AC49(-2.45,15.75) AC50(-2.45,16.45) AC51(-2.45,17.15) AC52(-2.45,17.85) AD1(-1.75,-17.85) AD2(-1.75,-17.15) AD3(-1.75,-16.45) AD4(-1.75,-15.75) AD5(-1.75,-15.05) AD6(-1.75,-14.35) AD7(-1.75,-13.65) AD8(-1.75,-12.95) AD9(-1.75,-12.25) AD10(-1.75,-11.55) AD11(-1.75,-10.85) AD14(-1.75,-8.75) AD15(-1.75,-8.05) AD16(-1.75,-7.35) AD17(-1.75,-6.65) AD18(-1.75,-5.95) AD19(-1.75,-5.25) AD20(-1.75,-4.55) AD21(-1.75,-3.85) AD22(-1.75,-3.15) AD23(-1.75,-2.45) AD24(-1.75,-1.75) AD25(-1.75,-1.05) AD26(-1.75,-0.35) AD27(-1.75,0.35) AD28(-1.75,1.05) AD29(-1.75,1.75) AD30(-1.75,2.45) AD31(-1.75,3.15) AD32(-1.75,3.85) AD33(-1.75,4.55) AD34(-1.75,5.25) AD35(-1.75,5.95) AD36(-1.75,6.65) AD37(-1.75,7.35) AD38(-1.75,8.05) AD39(-1.75,8.75) AD42(-1.75,10.85) AD43(-1.75,11.55) AD44(-1.75,12.25) AD45(-1.75,12.95) AD46(-1.75,13.65) AD47(-1.75,14.35) AD48(-1.75,15.05) AD49(-1.75,15.75) AD50(-1.75,16.45) AD51(-1.75,17.15) AD52(-1.75,17.85) AE2(-1.05,-17.15) AE4(-1.05,-15.75) AE6(-1.05,-14.35) AE8(-1.05,-12.95) AE10(-1.05,-11.55) AE14(-1.05,-8.75) AE15(-1.05,-8.05) AE16(-1.05,-7.35) AE17(-1.05,-6.65) AE18(-1.05,-5.95) AE19(-1.05,-5.25) AE20(-1.05,-4.55) AE21(-1.05,-3.85) AE22(-1.05,-3.15) AE23(-1.05,-2.45) AE24(-1.05,-1.75) AE25(-1.05,-1.05) AE26(-1.05,-0.35) AE27(-1.05,0.35) AE28(-1.05,1.05) AE29(-1.05,1.75) AE30(-1.05,2.45) AE31(-1.05,3.15) AE32(-1.05,3.85) AE33(-1.05,4.55) AE34(-1.05,5.25) AE35(-1.05,5.95) AE36(-1.05,6.65) AE37(-1.05,7.35) AE38(-1.05,8.05) AE39(-1.05,8.75) AE43(-1.05,11.55) AE45(-1.05,12.95) AE47(-1.05,14.35) AE49(-1.05,15.75) AE51(-1.05,17.15) AF1(-0.35,-17.85) AF2(-0.35,-17.15) AF3(-0.35,-16.45) AF4(-0.35,-15.75) AF5(-0.35,-15.05) AF6(-0.35,-14.35) AF7(-0.35,-13.65) AF8(-0.35,-12.95) AF9(-0.35,-12.25) AF10(-0.35,-11.55) AF11(-0.35,-10.85) AF13(-0.35,-9.45) AF14(-0.35,-8.75) AF15(-0.35,-8.05) AF16(-0.35,-7.35) AF17(-0.35,-6.65) AF18(-0.35,-5.95) AF19(-0.35,-5.25) AF20(-0.35,-4.55) AF21(-0.35,-3.85) AF22(-0.35,-3.15) AF23(-0.35,-2.45) AF24(-0.35,-1.75) AF25(-0.35,-1.05) AF26(-0.35,-0.35) AF27(-0.35,0.35) AF28(-0.35,1.05) AF29(-0.35,1.75) AF30(-0.35,2.45) AF31(-0.35,3.15) AF32(-0.35,3.85) AF33(-0.35,4.55) AF34(-0.35,5.25) AF35(-0.35,5.95) AF36(-0.35,6.65) AF37(-0.35,7.35) AF38(-0.35,8.05) AF39(-0.35,8.75) AF40(-0.35,9.45) AF42(-0.35,10.85) AF43(-0.35,11.55) AF44(-0.35,12.25) AF45(-0.35,12.95) AF46(-0.35,13.65) AF47(-0.35,14.35) AF48(-0.35,15.05) AF49(-0.35,15.75) AF50(-0.35,16.45) AF51(-0.35,17.15) AF52(-0.35,17.85) AG1(0.35,-17.85) AG2(0.35,-17.15) AG3(0.35,-16.45) AG4(0.35,-15.75) AG5(0.35,-15.05) AG6(0.35,-14.35) AG7(0.35,-13.65) AG8(0.35,-12.95) AG9(0.35,-12.25) AG10(0.35,-11.55) AG11(0.35,-10.85) AG13(0.35,-9.45) AG14(0.35,-8.75) AG15(0.35,-8.05) AG16(0.35,-7.35) AG17(0.35,-6.65) AG18(0.35,-5.95) AG19(0.35,-5.25) AG20(0.35,-4.55) AG21(0.35,-3.85) AG22(0.35,-3.15) AG23(0.35,-2.45) AG24(0.35,-1.75) AG25(0.35,-1.05) AG26(0.35,-0.35) AG27(0.35,0.35) AG28(0.35,1.05) AG29(0.35,1.75) AG30(0.35,2.45) AG31(0.35,3.15) AG32(0.35,3.85) AG33(0.35,4.55) AG34(0.35,5.25) AG35(0.35,5.95) AG36(0.35,6.65) AG37(0.35,7.35) AG38(0.35,8.05) AG39(0.35,8.75) AG40(0.35,9.45) AG42(0.35,10.85) AG43(0.35,11.55) AG44(0.35,12.25) AG45(0.35,12.95) AG46(0.35,13.65) AG47(0.35,14.35) AG48(0.35,15.05) AG49(0.35,15.75) AG50(0.35,16.45) AG51(0.35,17.15) AG52(0.35,17.85) AH2(1.05,-17.15) AH4(1.05,-15.75) AH6(1.05,-14.35) AH8(1.05,-12.95) AH10(1.05,-11.55) AH14(1.05,-8.75) AH15(1.05,-8.05) AH16(1.05,-7.35) AH17(1.05,-6.65) AH18(1.05,-5.95) AH19(1.05,-5.25) AH20(1.05,-4.55) AH21(1.05,-3.85) AH22(1.05,-3.15) AH23(1.05,-2.45) AH24(1.05,-1.75) AH25(1.05,-1.05) AH26(1.05,-0.35) AH27(1.05,0.35) AH28(1.05,1.05) AH29(1.05,1.75) AH30(1.05,2.45) AH31(1.05,3.15) AH32(1.05,3.85) AH33(1.05,4.55) AH34(1.05,5.25) AH35(1.05,5.95) AH36(1.05,6.65) AH37(1.05,7.35) AH38(1.05,8.05) AH39(1.05,8.75) AH43(1.05,11.55) AH45(1.05,12.95) AH47(1.05,14.35) AH49(1.05,15.75) AH51(1.05,17.15) AJ1(1.75,-17.85) AJ2(1.75,-17.15) AJ3(1.75,-16.45) AJ4(1.75,-15.75) AJ5(1.75,-15.05) AJ6(1.75,-14.35) AJ7(1.75,-13.65) AJ8(1.75,-12.95) AJ9(1.75,-12.25) AJ10(1.75,-11.55) AJ11(1.75,-10.85) AJ14(1.75,-8.75) AJ15(1.75,-8.05) AJ16(1.75,-7.35) AJ17(1.75,-6.65) AJ18(1.75,-5.95) AJ19(1.75,-5.25) AJ20(1.75,-4.55) AJ21(1.75,-3.85) AJ22(1.75,-3.15) AJ23(1.75,-2.45) AJ24(1.75,-1.75) AJ25(1.75,-1.05) AJ26(1.75,-0.35) AJ27(1.75,0.35) AJ28(1.75,1.05) AJ29(1.75,1.75) AJ30(1.75,2.45) AJ31(1.75,3.15) AJ32(1.75,3.85) AJ33(1.75,4.55) AJ34(1.75,5.25) AJ35(1.75,5.95) AJ36(1.75,6.65) AJ37(1.75,7.35) AJ38(1.75,8.05) AJ39(1.75,8.75) AJ42(1.75,10.85) AJ43(1.75,11.55) AJ44(1.75,12.25) AJ45(1.75,12.95) AJ46(1.75,13.65) AJ47(1.75,14.35) AJ48(1.75,15.05) AJ49(1.75,15.75) AJ50(1.75,16.45) AJ51(1.75,17.15) AJ52(1.75,17.85) AK1(2.45,-17.85) AK2(2.45,-17.15) AK3(2.45,-16.45) AK4(2.45,-15.75) AK5(2.45,-15.05) AK6(2.45,-14.35) AK7(2.45,-13.65) AK8(2.45,-12.95) AK9(2.45,-12.25) AK10(2.45,-11.55) AK11(2.45,-10.85) AK14(2.45,-8.75) AK15(2.45,-8.05) AK16(2.45,-7.35) AK17(2.45,-6.65) AK18(2.45,-5.95) AK19(2.45,-5.25) AK20(2.45,-4.55) AK21(2.45,-3.85) AK22(2.45,-3.15) AK23(2.45,-2.45) AK24(2.45,-1.75) AK25(2.45,-1.05) AK26(2.45,-0.35) AK27(2.45,0.35) AK28(2.45,1.05) AK29(2.45,1.75) AK30(2.45,2.45) AK31(2.45,3.15) AK32(2.45,3.85) AK33(2.45,4.55) AK34(2.45,5.25) AK35(2.45,5.95) AK36(2.45,6.65) AK37(2.45,7.35) AK38(2.45,8.05) AK39(2.45,8.75) AK42(2.45,10.85) AK43(2.45,11.55) AK44(2.45,12.25) AK45(2.45,12.95) AK46(2.45,13.65) AK47(2.45,14.35) AK48(2.45,15.05) AK49(2.45,15.75) AK50(2.45,16.45) AK51(2.45,17.15) AK52(2.45,17.85) AL2(3.15,-17.15) AL4(3.15,-15.75) AL6(3.15,-14.35) AL8(3.15,-12.95) AL10(3.15,-11.55) AL13(3.15,-9.45) AL14(3.15,-8.75) AL15(3.15,-8.05) AL16(3.15,-7.35) AL17(3.15,-6.65) AL18(3.15,-5.95) AL19(3.15,-5.25) AL20(3.15,-4.55) AL21(3.15,-3.85) AL22(3.15,-3.15) AL23(3.15,-2.45) AL24(3.15,-1.75) AL25(3.15,-1.05) AL26(3.15,-0.35) AL27(3.15,0.35) AL28(3.15,1.05) AL29(3.15,1.75) AL30(3.15,2.45) AL31(3.15,3.15) AL32(3.15,3.85) AL33(3.15,4.55) AL34(3.15,5.25) AL35(3.15,5.95) AL36(3.15,6.65) AL37(3.15,7.35) AL38(3.15,8.05) AL39(3.15,8.75) AL40(3.15,9.45) AL43(3.15,11.55) AL45(3.15,12.95) AL47(3.15,14.35) AL49(3.15,15.75) AL51(3.15,17.15) AM1(3.85,-17.85) AM2(3.85,-17.15) AM3(3.85,-16.45) AM4(3.85,-15.75) AM5(3.85,-15.05) AM6(3.85,-14.35) AM7(3.85,-13.65) AM8(3.85,-12.95) AM9(3.85,-12.25) AM10(3.85,-11.55) AM11(3.85,-10.85) AM14(3.85,-8.75) AM15(3.85,-8.05) AM16(3.85,-7.35) AM17(3.85,-6.65) AM18(3.85,-5.95) AM19(3.85,-5.25) AM20(3.85,-4.55) AM21(3.85,-3.85) AM22(3.85,-3.15) AM23(3.85,-2.45) AM24(3.85,-1.75) AM25(3.85,-1.05) AM26(3.85,-0.35) AM27(3.85,0.35) AM28(3.85,1.05) AM29(3.85,1.75) AM30(3.85,2.45) AM31(3.85,3.15) AM32(3.85,3.85) AM33(3.85,4.55) AM34(3.85,5.25) AM35(3.85,5.95) AM36(3.85,6.65) AM37(3.85,7.35) AM38(3.85,8.05) AM39(3.85,8.75) AM42(3.85,10.85) AM43(3.85,11.55) AM44(3.85,12.25) AM45(3.85,12.95) AM46(3.85,13.65) AM47(3.85,14.35) AM48(3.85,15.05) AM49(3.85,15.75) AM50(3.85,16.45) AM51(3.85,17.15) AM52(3.85,17.85) AN1(4.55,-17.85) AN2(4.55,-17.15) AN3(4.55,-16.45) AN4(4.55,-15.75) AN5(4.55,-15.05) AN6(4.55,-14.35) AN7(4.55,-13.65) AN8(4.55,-12.95) AN9(4.55,-12.25) AN10(4.55,-11.55) AN11(4.55,-10.85) AN14(4.55,-8.75) AN15(4.55,-8.05) AN16(4.55,-7.35) AN17(4.55,-6.65) AN18(4.55,-5.95) AN19(4.55,-5.25) AN20(4.55,-4.55) AN21(4.55,-3.85) AN22(4.55,-3.15) AN23(4.55,-2.45) AN24(4.55,-1.75) AN25(4.55,-1.05) AN26(4.55,-0.35) AN27(4.55,0.35) AN28(4.55,1.05) AN29(4.55,1.75) AN30(4.55,2.45) AN31(4.55,3.15) AN32(4.55,3.85) AN33(4.55,4.55) AN34(4.55,5.25) AN35(4.55,5.95) AN36(4.55,6.65) AN37(4.55,7.35) AN38(4.55,8.05) AN39(4.55,8.75) AN42(4.55,10.85) AN43(4.55,11.55) AN44(4.55,12.25) AN45(4.55,12.95) AN46(4.55,13.65) AN47(4.55,14.35) AN48(4.55,15.05) AN49(4.55,15.75) AN50(4.55,16.45) AN51(4.55,17.15) AN52(4.55,17.85) AP2(5.25,-17.15) AP4(5.25,-15.75) AP6(5.25,-14.35) AP8(5.25,-12.95) AP10(5.25,-11.55) AP14(5.25,-8.75) AP15(5.25,-8.05) AP16(5.25,-7.35) AP17(5.25,-6.65) AP18(5.25,-5.95) AP19(5.25,-5.25) AP20(5.25,-4.55) AP21(5.25,-3.85) AP22(5.25,-3.15) AP23(5.25,-2.45) AP24(5.25,-1.75) AP25(5.25,-1.05) AP26(5.25,-0.35) AP27(5.25,0.35) AP28(5.25,1.05) AP29(5.25,1.75) AP30(5.25,2.45) AP31(5.25,3.15) AP32(5.25,3.85) AP33(5.25,4.55) AP34(5.25,5.25) AP35(5.25,5.95) AP36(5.25,6.65) AP37(5.25,7.35) AP38(5.25,8.05) AP39(5.25,8.75) AP43(5.25,11.55) AP45(5.25,12.95) AP47(5.25,14.35) AP49(5.25,15.75) AP51(5.25,17.15) AR1(5.95,-17.85) AR2(5.95,-17.15) AR3(5.95,-16.45) AR4(5.95,-15.75) AR5(5.95,-15.05) AR6(5.95,-14.35) AR7(5.95,-13.65) AR8(5.95,-12.95) AR9(5.95,-12.25) AR10(5.95,-11.55) AR11(5.95,-10.85) AR13(5.95,-9.45) AR14(5.95,-8.75) AR15(5.95,-8.05) AR16(5.95,-7.35) AR17(5.95,-6.65) AR18(5.95,-5.95) AR19(5.95,-5.25) AR20(5.95,-4.55) AR21(5.95,-3.85) AR22(5.95,-3.15) AR23(5.95,-2.45) AR24(5.95,-1.75) AR25(5.95,-1.05) AR26(5.95,-0.35) AR27(5.95,0.35) AR28(5.95,1.05) AR29(5.95,1.75) AR30(5.95,2.45) AR31(5.95,3.15) AR32(5.95,3.85) AR33(5.95,4.55) AR34(5.95,5.25) AR35(5.95,5.95) AR36(5.95,6.65) AR37(5.95,7.35) AR38(5.95,8.05) AR39(5.95,8.75) AR40(5.95,9.45) AR42(5.95,10.85) AR43(5.95,11.55) AR44(5.95,12.25) AR45(5.95,12.95) AR46(5.95,13.65) AR47(5.95,14.35) AR48(5.95,15.05) AR49(5.95,15.75) AR50(5.95,16.45) AR51(5.95,17.15) AR52(5.95,17.85) AT1(6.65,-17.85) AT2(6.65,-17.15) AT3(6.65,-16.45) AT4(6.65,-15.75) AT5(6.65,-15.05) AT6(6.65,-14.35) AT7(6.65,-13.65) AT8(6.65,-12.95) AT9(6.65,-12.25) AT10(6.65,-11.55) AT11(6.65,-10.85) AT14(6.65,-8.75) AT15(6.65,-8.05) AT16(6.65,-7.35) AT17(6.65,-6.65) AT18(6.65,-5.95) AT19(6.65,-5.25) AT20(6.65,-4.55) AT21(6.65,-3.85) AT22(6.65,-3.15) AT23(6.65,-2.45) AT24(6.65,-1.75) AT25(6.65,-1.05) AT26(6.65,-0.35) AT27(6.65,0.35) AT28(6.65,1.05) AT29(6.65,1.75) AT30(6.65,2.45) AT31(6.65,3.15) AT32(6.65,3.85) AT33(6.65,4.55) AT34(6.65,5.25) AT35(6.65,5.95) AT36(6.65,6.65) AT37(6.65,7.35) AT38(6.65,8.05) AT39(6.65,8.75) AT42(6.65,10.85) AT43(6.65,11.55) AT44(6.65,12.25) AT45(6.65,12.95) AT46(6.65,13.65) AT47(6.65,14.35) AT48(6.65,15.05) AT49(6.65,15.75) AT50(6.65,16.45) AT51(6.65,17.15) AT52(6.65,17.85) AU2(7.35,-17.15) AU4(7.35,-15.75) AU6(7.35,-14.35) AU8(7.35,-12.95) AU10(7.35,-11.55) AU14(7.35,-8.75) AU15(7.35,-8.05) AU16(7.35,-7.35) AU17(7.35,-6.65) AU18(7.35,-5.95) AU19(7.35,-5.25) AU20(7.35,-4.55) AU21(7.35,-3.85) AU22(7.35,-3.15) AU23(7.35,-2.45) AU24(7.35,-1.75) AU25(7.35,-1.05) AU26(7.35,-0.35) AU27(7.35,0.35) AU28(7.35,1.05) AU29(7.35,1.75) AU30(7.35,2.45) AU31(7.35,3.15) AU32(7.35,3.85) AU33(7.35,4.55) AU34(7.35,5.25) AU35(7.35,5.95) AU36(7.35,6.65) AU37(7.35,7.35) AU38(7.35,8.05) AU39(7.35,8.75) AU43(7.35,11.55) AU45(7.35,12.95) AU47(7.35,14.35) AU49(7.35,15.75) AU51(7.35,17.15) AV1(8.05,-17.85) AV2(8.05,-17.15) AV3(8.05,-16.45) AV4(8.05,-15.75) AV5(8.05,-15.05) AV6(8.05,-14.35) AV7(8.05,-13.65) AV8(8.05,-12.95) AV9(8.05,-12.25) AV10(8.05,-11.55) AV11(8.05,-10.85) AV14(8.05,-8.75) AV15(8.05,-8.05) AV16(8.05,-7.35) AV17(8.05,-6.65) AV18(8.05,-5.95) AV19(8.05,-5.25) AV20(8.05,-4.55) AV21(8.05,-3.85) AV22(8.05,-3.15) AV23(8.05,-2.45) AV24(8.05,-1.75) AV25(8.05,-1.05) AV26(8.05,-0.35) AV27(8.05,0.35) AV28(8.05,1.05) AV29(8.05,1.75) AV30(8.05,2.45) AV31(8.05,3.15) AV32(8.05,3.85) AV33(8.05,4.55) AV34(8.05,5.25) AV35(8.05,5.95) AV36(8.05,6.65) AV37(8.05,7.35) AV38(8.05,8.05) AV39(8.05,8.75) AV42(8.05,10.85) AV43(8.05,11.55) AV44(8.05,12.25) AV45(8.05,12.95) AV46(8.05,13.65) AV47(8.05,14.35) AV48(8.05,15.05) AV49(8.05,15.75) AV50(8.05,16.45) AV51(8.05,17.15) AV52(8.05,17.85) AW1(8.75,-17.85) AW2(8.75,-17.15) AW3(8.75,-16.45) AW4(8.75,-15.75) AW5(8.75,-15.05) AW6(8.75,-14.35) AW7(8.75,-13.65) AW8(8.75,-12.95) AW9(8.75,-12.25) AW10(8.75,-11.55) AW11(8.75,-10.85) AW13(8.75,-9.45) AW14(8.75,-8.75) AW15(8.75,-8.05) AW16(8.75,-7.35) AW17(8.75,-6.65) AW18(8.75,-5.95) AW19(8.75,-5.25) AW20(8.75,-4.55) AW21(8.75,-3.85) AW22(8.75,-3.15) AW23(8.75,-2.45) AW24(8.75,-1.75) AW25(8.75,-1.05) AW26(8.75,-0.35) AW27(8.75,0.35) AW28(8.75,1.05) AW29(8.75,1.75) AW30(8.75,2.45) AW31(8.75,3.15) AW32(8.75,3.85) AW33(8.75,4.55) AW34(8.75,5.25) AW35(8.75,5.95) AW36(8.75,6.65) AW37(8.75,7.35) AW38(8.75,8.05) AW39(8.75,8.75) AW40(8.75,9.45) AW42(8.75,10.85) AW43(8.75,11.55) AW44(8.75,12.25) AW45(8.75,12.95) AW46(8.75,13.65) AW47(8.75,14.35) AW48(8.75,15.05) AW49(8.75,15.75) AW50(8.75,16.45) AW51(8.75,17.15) AW52(8.75,17.85) AY2(9.45,-17.15) AY4(9.45,-15.75) AY6(9.45,-14.35) AY8(9.45,-12.95) AY10(9.45,-11.55) AY14(9.45,-8.75) AY18(9.45,-5.95) AY22(9.45,-3.15) AY26(9.45,-0.35) AY27(9.45,0.35) AY31(9.45,3.15) AY35(9.45,5.95) AY39(9.45,8.75) AY43(9.45,11.55) AY45(9.45,12.95) AY47(9.45,14.35) AY49(9.45,15.75) AY51(9.45,17.15) B1(-17.15,-17.85) B2(-17.15,-17.15) B3(-17.15,-16.45) B4(-17.15,-15.75) B5(-17.15,-15.05) B6(-17.15,-14.35) B7(-17.15,-13.65) B8(-17.15,-12.95) B9(-17.15,-12.25) B10(-17.15,-11.55) B11(-17.15,-10.85) B12(-17.15,-10.15) B13(-17.15,-9.45) B14(-17.15,-8.75) B15(-17.15,-8.05) B16(-17.15,-7.35) B17(-17.15,-6.65) B18(-17.15,-5.95) B19(-17.15,-5.25) B20(-17.15,-4.55) B21(-17.15,-3.85) B22(-17.15,-3.15) B23(-17.15,-2.45) B24(-17.15,-1.75) B25(-17.15,-1.05) B26(-17.15,-0.35) B27(-17.15,0.35) B28(-17.15,1.05) B29(-17.15,1.75) B30(-17.15,2.45) B31(-17.15,3.15) B32(-17.15,3.85) B33(-17.15,4.55) B34(-17.15,5.25) B35(-17.15,5.95) B36(-17.15,6.65) B37(-17.15,7.35) B38(-17.15,8.05) B39(-17.15,8.75) B40(-17.15,9.45) B41(-17.15,10.15) B42(-17.15,10.85) B43(-17.15,11.55) B44(-17.15,12.25) B45(-17.15,12.95) B46(-17.15,13.65) B47(-17.15,14.35) B48(-17.15,15.05) B49(-17.15,15.75) B50(-17.15,16.45) B51(-17.15,17.15) B52(-17.15,17.85) BA1(10.15,-17.85) BA2(10.15,-17.15) BA3(10.15,-16.45) BA4(10.15,-15.75) BA5(10.15,-15.05) BA6(10.15,-14.35) BA7(10.15,-13.65) BA8(10.15,-12.95) BA9(10.15,-12.25) BA10(10.15,-11.55) BA43(10.15,11.55) BA44(10.15,12.25) BA45(10.15,12.95) BA46(10.15,13.65) BA47(10.15,14.35) BA48(10.15,15.05) BA49(10.15,15.75) BA50(10.15,16.45) BA51(10.15,17.15) BA52(10.15,17.85) BB1(10.85,-17.85) BB2(10.85,-17.15) BB3(10.85,-16.45) BB4(10.85,-15.75) BB5(10.85,-15.05) BB6(10.85,-14.35) BB7(10.85,-13.65) BB8(10.85,-12.95) BB14(10.85,-8.75) BB15(10.85,-8.05) BB17(10.85,-6.65) BB18(10.85,-5.95) BB20(10.85,-4.55) BB21(10.85,-3.85) BB23(10.85,-2.45) BB24(10.85,-1.75) BB26(10.85,-0.35) BB27(10.85,0.35) BB29(10.85,1.75) BB30(10.85,2.45) BB32(10.85,3.85) BB33(10.85,4.55) BB35(10.85,5.95) BB36(10.85,6.65) BB38(10.85,8.05) BB39(10.85,8.75) BB45(10.85,12.95) BB46(10.85,13.65) BB47(10.85,14.35) BB48(10.85,15.05) BB49(10.85,15.75) BB50(10.85,16.45) BB51(10.85,17.15) BB52(10.85,17.85) BC2(11.55,-17.15) BC4(11.55,-15.75) BC6(11.55,-14.35) BC8(11.55,-12.95) BC12(11.55,-10.15) BC13(11.55,-9.45) BC14(11.55,-8.75) BC15(11.55,-8.05) BC16(11.55,-7.35) BC17(11.55,-6.65) BC18(11.55,-5.95) BC19(11.55,-5.25) BC20(11.55,-4.55) BC21(11.55,-3.85) BC22(11.55,-3.15) BC23(11.55,-2.45) BC24(11.55,-1.75) BC25(11.55,-1.05) BC26(11.55,-0.35) BC27(11.55,0.35) BC28(11.55,1.05) BC29(11.55,1.75) BC30(11.55,2.45) BC31(11.55,3.15) BC32(11.55,3.85) BC33(11.55,4.55) BC34(11.55,5.25) BC35(11.55,5.95) BC36(11.55,6.65) BC37(11.55,7.35) BC38(11.55,8.05) BC39(11.55,8.75) BC40(11.55,9.45) BC41(11.55,10.15) BC45(11.55,12.95) BC47(11.55,14.35) BC49(11.55,15.75) BC51(11.55,17.15) BD1(12.25,-17.85) BD2(12.25,-17.15) BD3(12.25,-16.45) BD4(12.25,-15.75) BD5(12.25,-15.05) BD6(12.25,-14.35) BD7(12.25,-13.65) BD12(12.25,-10.15) BD14(12.25,-8.75) BD15(12.25,-8.05) BD17(12.25,-6.65) BD18(12.25,-5.95) BD20(12.25,-4.55) BD21(12.25,-3.85) BD23(12.25,-2.45) BD24(12.25,-1.75) BD26(12.25,-0.35) BD27(12.25,0.35) BD29(12.25,1.75) BD30(12.25,2.45) BD32(12.25,3.85) BD33(12.25,4.55) BD35(12.25,5.95) BD36(12.25,6.65) BD38(12.25,8.05) BD39(12.25,8.75) BD41(12.25,10.15) BD46(12.25,13.65) BD47(12.25,14.35) BD48(12.25,15.05) BD49(12.25,15.75) BD50(12.25,16.45) BD51(12.25,17.15) BD52(12.25,17.85) BE1(12.95,-17.85) BE2(12.95,-17.15) BE3(12.95,-16.45) BE4(12.95,-15.75) BE5(12.95,-15.05) BE6(12.95,-14.35) BE7(12.95,-13.65) BE10(12.95,-11.55) BE11(12.95,-10.85) BE12(12.95,-10.15) BE13(12.95,-9.45) BE14(12.95,-8.75) BE15(12.95,-8.05) BE16(12.95,-7.35) BE17(12.95,-6.65) BE18(12.95,-5.95) BE19(12.95,-5.25) BE20(12.95,-4.55) BE21(12.95,-3.85) BE22(12.95,-3.15) BE23(12.95,-2.45) BE24(12.95,-1.75) BE25(12.95,-1.05) BE26(12.95,-0.35) BE27(12.95,0.35) BE28(12.95,1.05) BE29(12.95,1.75) BE30(12.95,2.45) BE31(12.95,3.15) BE32(12.95,3.85) BE33(12.95,4.55) BE34(12.95,5.25) BE35(12.95,5.95) BE36(12.95,6.65) BE37(12.95,7.35) BE38(12.95,8.05) BE39(12.95,8.75) BE40(12.95,9.45) BE41(12.95,10.15) BE42(12.95,10.85) BE43(12.95,11.55) BE46(12.95,13.65) BE47(12.95,14.35) BE48(12.95,15.05) BE49(12.95,15.75) BE50(12.95,16.45) BE51(12.95,17.15) BE52(12.95,17.85) BF2(13.65,-17.15) BF4(13.65,-15.75) BF6(13.65,-14.35) BF8(13.65,-12.95) BF9(13.65,-12.25) BF11(13.65,-10.85) BF12(13.65,-10.15) BF14(13.65,-8.75) BF15(13.65,-8.05) BF17(13.65,-6.65) BF18(13.65,-5.95) BF20(13.65,-4.55) BF21(13.65,-3.85) BF23(13.65,-2.45) BF24(13.65,-1.75) BF26(13.65,-0.35) BF27(13.65,0.35) BF29(13.65,1.75) BF30(13.65,2.45) BF32(13.65,3.85) BF33(13.65,4.55) BF35(13.65,5.95) BF36(13.65,6.65) BF38(13.65,8.05) BF39(13.65,8.75) BF41(13.65,10.15) BF42(13.65,10.85) BF44(13.65,12.25) BF45(13.65,12.95) BF47(13.65,14.35) BF49(13.65,15.75) BF51(13.65,17.15) BG1(14.35,-17.85) BG2(14.35,-17.15) BG3(14.35,-16.45) BG4(14.35,-15.75) BG5(14.35,-15.05) BG6(14.35,-14.35) BG7(14.35,-13.65) BG8(14.35,-12.95) BG9(14.35,-12.25) BG10(14.35,-11.55) BG11(14.35,-10.85) BG12(14.35,-10.15) BG13(14.35,-9.45) BG14(14.35,-8.75) BG15(14.35,-8.05) BG16(14.35,-7.35) BG17(14.35,-6.65) BG18(14.35,-5.95) BG19(14.35,-5.25) BG20(14.35,-4.55) BG21(14.35,-3.85) BG22(14.35,-3.15) BG23(14.35,-2.45) BG24(14.35,-1.75) BG25(14.35,-1.05) BG26(14.35,-0.35) BG27(14.35,0.35) BG28(14.35,1.05) BG29(14.35,1.75) BG30(14.35,2.45) BG31(14.35,3.15) BG32(14.35,3.85) BG33(14.35,4.55) BG34(14.35,5.25) BG35(14.35,5.95) BG36(14.35,6.65) BG37(14.35,7.35) BG38(14.35,8.05) BG39(14.35,8.75) BG40(14.35,9.45) BG41(14.35,10.15) BG42(14.35,10.85) BG43(14.35,11.55) BG44(14.35,12.25) BG45(14.35,12.95) BG46(14.35,13.65) BG47(14.35,14.35) BG48(14.35,15.05) BG49(14.35,15.75) BG50(14.35,16.45) BG51(14.35,17.15) BG52(14.35,17.85) BH1(15.05,-17.85) BH2(15.05,-17.15) BH3(15.05,-16.45) BH4(15.05,-15.75) BH5(15.05,-15.05) BH6(15.05,-14.35) BH8(15.05,-12.95) BH9(15.05,-12.25) BH11(15.05,-10.85) BH12(15.05,-10.15) BH14(15.05,-8.75) BH15(15.05,-8.05) BH17(15.05,-6.65) BH18(15.05,-5.95) BH20(15.05,-4.55) BH21(15.05,-3.85) BH23(15.05,-2.45) BH24(15.05,-1.75) BH26(15.05,-0.35) BH27(15.05,0.35) BH29(15.05,1.75) BH30(15.05,2.45) BH32(15.05,3.85) BH33(15.05,4.55) BH35(15.05,5.95) BH36(15.05,6.65) BH38(15.05,8.05) BH39(15.05,8.75) BH41(15.05,10.15) BH42(15.05,10.85) BH44(15.05,12.25) BH45(15.05,12.95) BH47(15.05,14.35) BH48(15.05,15.05) BH49(15.05,15.75) BH50(15.05,16.45) BH51(15.05,17.15) BH52(15.05,17.85) BJ1(15.75,-17.85) BJ2(15.75,-17.15) BJ3(15.75,-16.45) BJ4(15.75,-15.75) BJ5(15.75,-15.05) BJ6(15.75,-14.35) BJ7(15.75,-13.65) BJ8(15.75,-12.95) BJ9(15.75,-12.25) BJ10(15.75,-11.55) BJ11(15.75,-10.85) BJ12(15.75,-10.15) BJ13(15.75,-9.45) BJ14(15.75,-8.75) BJ15(15.75,-8.05) BJ16(15.75,-7.35) BJ17(15.75,-6.65) BJ18(15.75,-5.95) BJ19(15.75,-5.25) BJ20(15.75,-4.55) BJ21(15.75,-3.85) BJ22(15.75,-3.15) BJ23(15.75,-2.45) BJ24(15.75,-1.75) BJ25(15.75,-1.05) BJ26(15.75,-0.35) BJ27(15.75,0.35) BJ28(15.75,1.05) BJ29(15.75,1.75) BJ30(15.75,2.45) BJ31(15.75,3.15) BJ32(15.75,3.85) BJ33(15.75,4.55) BJ34(15.75,5.25) BJ35(15.75,5.95) BJ36(15.75,6.65) BJ37(15.75,7.35) BJ38(15.75,8.05) BJ39(15.75,8.75) BJ40(15.75,9.45) BJ41(15.75,10.15) BJ42(15.75,10.85) BJ43(15.75,11.55) BJ44(15.75,12.25) BJ45(15.75,12.95) BJ46(15.75,13.65) BJ47(15.75,14.35) BJ48(15.75,15.05) BJ49(15.75,15.75) BJ50(15.75,16.45) BJ51(15.75,17.15) BJ52(15.75,17.85) BK1(16.45,-17.85) BK2(16.45,-17.15) BK3(16.45,-16.45) BK4(16.45,-15.75) BK5(16.45,-15.05) BK6(16.45,-14.35) BK8(16.45,-12.95) BK9(16.45,-12.25) BK11(16.45,-10.85) BK12(16.45,-10.15) BK14(16.45,-8.75) BK15(16.45,-8.05) BK17(16.45,-6.65) BK18(16.45,-5.95) BK20(16.45,-4.55) BK21(16.45,-3.85) BK23(16.45,-2.45) BK24(16.45,-1.75) BK26(16.45,-0.35) BK27(16.45,0.35) BK29(16.45,1.75) BK30(16.45,2.45) BK32(16.45,3.85) BK33(16.45,4.55) BK35(16.45,5.95) BK36(16.45,6.65) BK38(16.45,8.05) BK39(16.45,8.75) BK41(16.45,10.15) BK42(16.45,10.85) BK44(16.45,12.25) BK45(16.45,12.95) BK47(16.45,14.35) BK48(16.45,15.05) BK49(16.45,15.75) BK50(16.45,16.45) BK51(16.45,17.15) BK52(16.45,17.85) BL1(17.15,-17.85) BL2(17.15,-17.15) BL3(17.15,-16.45) BL4(17.15,-15.75) BL5(17.15,-15.05) BL6(17.15,-14.35) BL7(17.15,-13.65) BL8(17.15,-12.95) BL9(17.15,-12.25) BL10(17.15,-11.55) BL11(17.15,-10.85) BL12(17.15,-10.15) BL13(17.15,-9.45) BL14(17.15,-8.75) BL15(17.15,-8.05) BL16(17.15,-7.35) BL17(17.15,-6.65) BL18(17.15,-5.95) BL19(17.15,-5.25) BL20(17.15,-4.55) BL21(17.15,-3.85) BL22(17.15,-3.15) BL23(17.15,-2.45) BL24(17.15,-1.75) BL25(17.15,-1.05) BL26(17.15,-0.35) BL27(17.15,0.35) BL28(17.15,1.05) BL29(17.15,1.75) BL30(17.15,2.45) BL31(17.15,3.15) BL32(17.15,3.85) BL33(17.15,4.55) BL34(17.15,5.25) BL35(17.15,5.95) BL36(17.15,6.65) BL37(17.15,7.35) BL38(17.15,8.05) BL39(17.15,8.75) BL40(17.15,9.45) BL41(17.15,10.15) BL42(17.15,10.85) BL43(17.15,11.55) BL44(17.15,12.25) BL45(17.15,12.95) BL46(17.15,13.65) BL47(17.15,14.35) BL48(17.15,15.05) BL49(17.15,15.75) BL50(17.15,16.45) BL51(17.15,17.15) BL52(17.15,17.85) BM2(17.85,-17.15) BM3(17.85,-16.45) BM4(17.85,-15.75) BM5(17.85,-15.05) BM6(17.85,-14.35) BM8(17.85,-12.95) BM9(17.85,-12.25) BM11(17.85,-10.85) BM12(17.85,-10.15) BM14(17.85,-8.75) BM15(17.85,-8.05) BM17(17.85,-6.65) BM18(17.85,-5.95) BM20(17.85,-4.55) BM21(17.85,-3.85) BM23(17.85,-2.45) BM24(17.85,-1.75) BM26(17.85,-0.35) BM27(17.85,0.35) BM29(17.85,1.75) BM30(17.85,2.45) BM32(17.85,3.85) BM33(17.85,4.55) BM35(17.85,5.95) BM36(17.85,6.65) BM38(17.85,8.05) BM39(17.85,8.75) BM41(17.85,10.15) BM42(17.85,10.85) BM44(17.85,12.25) BM45(17.85,12.95) BM47(17.85,14.35) BM48(17.85,15.05) BM49(17.85,15.75) BM50(17.85,16.45) BM51(17.85,17.15) C1(-16.45,-17.85) C2(-16.45,-17.15) C3(-16.45,-16.45) C4(-16.45,-15.75) C5(-16.45,-15.05) C6(-16.45,-14.35) C8(-16.45,-12.95) C9(-16.45,-12.25) C11(-16.45,-10.85) C12(-16.45,-10.15) C14(-16.45,-8.75) C15(-16.45,-8.05) C17(-16.45,-6.65) C18(-16.45,-5.95) C20(-16.45,-4.55) C21(-16.45,-3.85) C23(-16.45,-2.45) C24(-16.45,-1.75) C26(-16.45,-0.35) C27(-16.45,0.35) C29(-16.45,1.75) C30(-16.45,2.45) C32(-16.45,3.85) C33(-16.45,4.55) C35(-16.45,5.95) C36(-16.45,6.65) C38(-16.45,8.05) C39(-16.45,8.75) C41(-16.45,10.15) C42(-16.45,10.85) C44(-16.45,12.25) C45(-16.45,12.95) C47(-16.45,14.35) C48(-16.45,15.05) C49(-16.45,15.75) C50(-16.45,16.45) C51(-16.45,17.15) C52(-16.45,17.85) D1(-15.75,-17.85) D2(-15.75,-17.15) D3(-15.75,-16.45) D4(-15.75,-15.75) D5(-15.75,-15.05) D6(-15.75,-14.35) D7(-15.75,-13.65) D8(-15.75,-12.95) D9(-15.75,-12.25) D10(-15.75,-11.55) D11(-15.75,-10.85) D12(-15.75,-10.15) D13(-15.75,-9.45) D14(-15.75,-8.75) D15(-15.75,-8.05) D16(-15.75,-7.35) D17(-15.75,-6.65) D18(-15.75,-5.95) D19(-15.75,-5.25) D20(-15.75,-4.55) D21(-15.75,-3.85) D22(-15.75,-3.15) D23(-15.75,-2.45) D24(-15.75,-1.75) D25(-15.75,-1.05) D26(-15.75,-0.35) D27(-15.75,0.35) D28(-15.75,1.05) D29(-15.75,1.75) D30(-15.75,2.45) D31(-15.75,3.15) D32(-15.75,3.85) D33(-15.75,4.55) D34(-15.75,5.25) D35(-15.75,5.95) D36(-15.75,6.65) D37(-15.75,7.35) D38(-15.75,8.05) D39(-15.75,8.75) D40(-15.75,9.45) D41(-15.75,10.15) D42(-15.75,10.85) D43(-15.75,11.55) D44(-15.75,12.25) D45(-15.75,12.95) D46(-15.75,13.65) D47(-15.75,14.35) D48(-15.75,15.05) D49(-15.75,15.75) D50(-15.75,16.45) D51(-15.75,17.15) D52(-15.75,17.85) E1(-15.05,-17.85) E2(-15.05,-17.15) E3(-15.05,-16.45) E4(-15.05,-15.75) E5(-15.05,-15.05) E6(-15.05,-14.35) E8(-15.05,-12.95) E9(-15.05,-12.25) E11(-15.05,-10.85) E12(-15.05,-10.15) E14(-15.05,-8.75) E15(-15.05,-8.05) E17(-15.05,-6.65) E18(-15.05,-5.95) E20(-15.05,-4.55) E21(-15.05,-3.85) E23(-15.05,-2.45) E24(-15.05,-1.75) E26(-15.05,-0.35) E27(-15.05,0.35) E29(-15.05,1.75) E30(-15.05,2.45) E32(-15.05,3.85) E33(-15.05,4.55) E35(-15.05,5.95) E36(-15.05,6.65) E38(-15.05,8.05) E39(-15.05,8.75) E41(-15.05,10.15) E42(-15.05,10.85) E44(-15.05,12.25) E45(-15.05,12.95) E47(-15.05,14.35) E48(-15.05,15.05) E49(-15.05,15.75) E50(-15.05,16.45) E51(-15.05,17.15) E52(-15.05,17.85) F1(-14.35,-17.85) F2(-14.35,-17.15) F3(-14.35,-16.45) F4(-14.35,-15.75) F5(-14.35,-15.05) F6(-14.35,-14.35) F7(-14.35,-13.65) F8(-14.35,-12.95) F9(-14.35,-12.25) F10(-14.35,-11.55) F11(-14.35,-10.85) F12(-14.35,-10.15) F13(-14.35,-9.45) F14(-14.35,-8.75) F15(-14.35,-8.05) F16(-14.35,-7.35) F17(-14.35,-6.65) F18(-14.35,-5.95) F19(-14.35,-5.25) F20(-14.35,-4.55) F21(-14.35,-3.85) F22(-14.35,-3.15) F23(-14.35,-2.45) F24(-14.35,-1.75) F25(-14.35,-1.05) F26(-14.35,-0.35) F27(-14.35,0.35) F28(-14.35,1.05) F29(-14.35,1.75) F30(-14.35,2.45) F31(-14.35,3.15) F32(-14.35,3.85) F33(-14.35,4.55) F34(-14.35,5.25) F35(-14.35,5.95) F36(-14.35,6.65) F37(-14.35,7.35) F38(-14.35,8.05) F39(-14.35,8.75) F40(-14.35,9.45) F41(-14.35,10.15) F42(-14.35,10.85) F43(-14.35,11.55) F44(-14.35,12.25) F45(-14.35,12.95) F46(-14.35,13.65) F47(-14.35,14.35) F48(-14.35,15.05) F49(-14.35,15.75) F50(-14.35,16.45) F51(-14.35,17.15) F52(-14.35,17.85) G2(-13.65,-17.15) G4(-13.65,-15.75) G6(-13.65,-14.35) G8(-13.65,-12.95) G9(-13.65,-12.25) G11(-13.65,-10.85) G12(-13.65,-10.15) G14(-13.65,-8.75) G15(-13.65,-8.05) G17(-13.65,-6.65) G18(-13.65,-5.95) G20(-13.65,-4.55) G21(-13.65,-3.85) G23(-13.65,-2.45) G24(-13.65,-1.75) G26(-13.65,-0.35) G27(-13.65,0.35) G29(-13.65,1.75) G30(-13.65,2.45) G32(-13.65,3.85) G33(-13.65,4.55) G35(-13.65,5.95) G36(-13.65,6.65) G38(-13.65,8.05) G39(-13.65,8.75) G41(-13.65,10.15) G42(-13.65,10.85) G44(-13.65,12.25) G45(-13.65,12.95) G47(-13.65,14.35) G49(-13.65,15.75) G51(-13.65,17.15) H1(-12.95,-17.85) H2(-12.95,-17.15) H3(-12.95,-16.45) H4(-12.95,-15.75) H5(-12.95,-15.05) H6(-12.95,-14.35) H7(-12.95,-13.65) H10(-12.95,-11.55) H11(-12.95,-10.85) H12(-12.95,-10.15) H13(-12.95,-9.45) H14(-12.95,-8.75) H15(-12.95,-8.05) H16(-12.95,-7.35) H17(-12.95,-6.65) H18(-12.95,-5.95) H19(-12.95,-5.25) H20(-12.95,-4.55) H21(-12.95,-3.85) H22(-12.95,-3.15) H23(-12.95,-2.45) H24(-12.95,-1.75) H25(-12.95,-1.05) H26(-12.95,-0.35) H27(-12.95,0.35) H28(-12.95,1.05) H29(-12.95,1.75) H30(-12.95,2.45) H31(-12.95,3.15) H32(-12.95,3.85) H33(-12.95,4.55) H34(-12.95,5.25) H35(-12.95,5.95) H36(-12.95,6.65) H37(-12.95,7.35) H38(-12.95,8.05) H39(-12.95,8.75) H40(-12.95,9.45) H41(-12.95,10.15) H42(-12.95,10.85) H43(-12.95,11.55) H46(-12.95,13.65) H47(-12.95,14.35) H48(-12.95,15.05) H49(-12.95,15.75) H50(-12.95,16.45) H51(-12.95,17.15) H52(-12.95,17.85) J1(-12.25,-17.85) J2(-12.25,-17.15) J3(-12.25,-16.45) J4(-12.25,-15.75) J5(-12.25,-15.05) J6(-12.25,-14.35) J7(-12.25,-13.65) J12(-12.25,-10.15) J14(-12.25,-8.75) J15(-12.25,-8.05) J17(-12.25,-6.65) J18(-12.25,-5.95) J20(-12.25,-4.55) J21(-12.25,-3.85) J23(-12.25,-2.45) J24(-12.25,-1.75) J26(-12.25,-0.35) J27(-12.25,0.35) J29(-12.25,1.75) J30(-12.25,2.45) J32(-12.25,3.85) J33(-12.25,4.55) J35(-12.25,5.95) J36(-12.25,6.65) J38(-12.25,8.05) J39(-12.25,8.75) J41(-12.25,10.15) J46(-12.25,13.65) J47(-12.25,14.35) J48(-12.25,15.05) J49(-12.25,15.75) J50(-12.25,16.45) J51(-12.25,17.15) J52(-12.25,17.85) K2(-11.55,-17.15) K4(-11.55,-15.75) K6(-11.55,-14.35) K8(-11.55,-12.95) K12(-11.55,-10.15) K13(-11.55,-9.45) K14(-11.55,-8.75) K15(-11.55,-8.05) K16(-11.55,-7.35) K17(-11.55,-6.65) K18(-11.55,-5.95) K19(-11.55,-5.25) K20(-11.55,-4.55) K21(-11.55,-3.85) K22(-11.55,-3.15) K23(-11.55,-2.45) K24(-11.55,-1.75) K25(-11.55,-1.05) K26(-11.55,-0.35) K27(-11.55,0.35) K28(-11.55,1.05) K29(-11.55,1.75) K30(-11.55,2.45) K31(-11.55,3.15) K32(-11.55,3.85) K33(-11.55,4.55) K34(-11.55,5.25) K35(-11.55,5.95) K36(-11.55,6.65) K37(-11.55,7.35) K38(-11.55,8.05) K39(-11.55,8.75) K40(-11.55,9.45) K41(-11.55,10.15) K45(-11.55,12.95) K47(-11.55,14.35) K49(-11.55,15.75) K51(-11.55,17.15) L1(-10.85,-17.85) L2(-10.85,-17.15) L3(-10.85,-16.45) L4(-10.85,-15.75) L5(-10.85,-15.05) L6(-10.85,-14.35) L7(-10.85,-13.65) L8(-10.85,-12.95) L14(-10.85,-8.75) L15(-10.85,-8.05) L17(-10.85,-6.65) L18(-10.85,-5.95) L20(-10.85,-4.55) L21(-10.85,-3.85) L23(-10.85,-2.45) L24(-10.85,-1.75) L26(-10.85,-0.35) L27(-10.85,0.35) L29(-10.85,1.75) L30(-10.85,2.45) L32(-10.85,3.85) L33(-10.85,4.55) L35(-10.85,5.95) L36(-10.85,6.65) L38(-10.85,8.05) L39(-10.85,8.75) L45(-10.85,12.95) L46(-10.85,13.65) L47(-10.85,14.35) L48(-10.85,15.05) L49(-10.85,15.75) L50(-10.85,16.45) L51(-10.85,17.15) L52(-10.85,17.85) M1(-10.15,-17.85) M2(-10.15,-17.15) M3(-10.15,-16.45) M4(-10.15,-15.75) M5(-10.15,-15.05) M6(-10.15,-14.35) M7(-10.15,-13.65) M8(-10.15,-12.95) M9(-10.15,-12.25) M10(-10.15,-11.55) M43(-10.15,11.55) M44(-10.15,12.25) M45(-10.15,12.95) M46(-10.15,13.65) M47(-10.15,14.35) M48(-10.15,15.05) M49(-10.15,15.75) M50(-10.15,16.45) M51(-10.15,17.15) M52(-10.15,17.85) N2(-9.45,-17.15) N4(-9.45,-15.75) N6(-9.45,-14.35) N8(-9.45,-12.95) N10(-9.45,-11.55) N14(-9.45,-8.75) N18(-9.45,-5.95) N22(-9.45,-3.15) N26(-9.45,-0.35) N27(-9.45,0.35) N31(-9.45,3.15) N35(-9.45,5.95) N39(-9.45,8.75) N43(-9.45,11.55) N45(-9.45,12.95) N47(-9.45,14.35) N49(-9.45,15.75) N51(-9.45,17.15) P1(-8.75,-17.85) P2(-8.75,-17.15) P3(-8.75,-16.45) P4(-8.75,-15.75) P5(-8.75,-15.05) P6(-8.75,-14.35) P7(-8.75,-13.65) P8(-8.75,-12.95) P9(-8.75,-12.25) P10(-8.75,-11.55) P11(-8.75,-10.85) P13(-8.75,-9.45) P14(-8.75,-8.75) P15(-8.75,-8.05) P16(-8.75,-7.35) P17(-8.75,-6.65) P18(-8.75,-5.95) P19(-8.75,-5.25) P20(-8.75,-4.55) P21(-8.75,-3.85) P22(-8.75,-3.15) P23(-8.75,-2.45) P24(-8.75,-1.75) P25(-8.75,-1.05) P26(-8.75,-0.35) P27(-8.75,0.35) P28(-8.75,1.05) P29(-8.75,1.75) P30(-8.75,2.45) P31(-8.75,3.15) P32(-8.75,3.85) P33(-8.75,4.55) P34(-8.75,5.25) P35(-8.75,5.95) P36(-8.75,6.65) P37(-8.75,7.35) P38(-8.75,8.05) P39(-8.75,8.75) P40(-8.75,9.45) P42(-8.75,10.85) P43(-8.75,11.55) P44(-8.75,12.25) P45(-8.75,12.95) P46(-8.75,13.65) P47(-8.75,14.35) P48(-8.75,15.05) P49(-8.75,15.75) P50(-8.75,16.45) P51(-8.75,17.15) P52(-8.75,17.85) R1(-8.05,-17.85) R2(-8.05,-17.15) R3(-8.05,-16.45) R4(-8.05,-15.75) R5(-8.05,-15.05) R6(-8.05,-14.35) R7(-8.05,-13.65) R8(-8.05,-12.95) R9(-8.05,-12.25) R10(-8.05,-11.55) R11(-8.05,-10.85) R14(-8.05,-8.75) R15(-8.05,-8.05) R16(-8.05,-7.35) R17(-8.05,-6.65) R18(-8.05,-5.95) R19(-8.05,-5.25) R20(-8.05,-4.55) R21(-8.05,-3.85) R22(-8.05,-3.15) R23(-8.05,-2.45) R24(-8.05,-1.75) R25(-8.05,-1.05) R26(-8.05,-0.35) R27(-8.05,0.35) R28(-8.05,1.05) R29(-8.05,1.75) R30(-8.05,2.45) R31(-8.05,3.15) R32(-8.05,3.85) R33(-8.05,4.55) R34(-8.05,5.25) R35(-8.05,5.95) R36(-8.05,6.65) R37(-8.05,7.35) R38(-8.05,8.05) R39(-8.05,8.75) R42(-8.05,10.85) R43(-8.05,11.55) R44(-8.05,12.25) R45(-8.05,12.95) R46(-8.05,13.65) R47(-8.05,14.35) R48(-8.05,15.05) R49(-8.05,15.75) R50(-8.05,16.45) R51(-8.05,17.15) R52(-8.05,17.85) T2(-7.35,-17.15) T4(-7.35,-15.75) T6(-7.35,-14.35) T8(-7.35,-12.95) T10(-7.35,-11.55) T14(-7.35,-8.75) T15(-7.35,-8.05) T16(-7.35,-7.35) T17(-7.35,-6.65) T18(-7.35,-5.95) T19(-7.35,-5.25) T20(-7.35,-4.55) T21(-7.35,-3.85) T22(-7.35,-3.15) T23(-7.35,-2.45) T24(-7.35,-1.75) T25(-7.35,-1.05) T26(-7.35,-0.35) T27(-7.35,0.35) T28(-7.35,1.05) T29(-7.35,1.75) T30(-7.35,2.45) T31(-7.35,3.15) T32(-7.35,3.85) T33(-7.35,4.55) T34(-7.35,5.25) T35(-7.35,5.95) T36(-7.35,6.65) T37(-7.35,7.35) T38(-7.35,8.05) T39(-7.35,8.75) T43(-7.35,11.55) T45(-7.35,12.95) T47(-7.35,14.35) T49(-7.35,15.75) T51(-7.35,17.15) U1(-6.65,-17.85) U2(-6.65,-17.15) U3(-6.65,-16.45) U4(-6.65,-15.75) U5(-6.65,-15.05) U6(-6.65,-14.35) U7(-6.65,-13.65) U8(-6.65,-12.95) U9(-6.65,-12.25) U10(-6.65,-11.55) U11(-6.65,-10.85) U14(-6.65,-8.75) U15(-6.65,-8.05) U16(-6.65,-7.35) U17(-6.65,-6.65) U18(-6.65,-5.95) U19(-6.65,-5.25) U20(-6.65,-4.55) U21(-6.65,-3.85) U22(-6.65,-3.15) U23(-6.65,-2.45) U24(-6.65,-1.75) U25(-6.65,-1.05) U26(-6.65,-0.35) U27(-6.65,0.35) U28(-6.65,1.05) U29(-6.65,1.75) U30(-6.65,2.45) U31(-6.65,3.15) U32(-6.65,3.85) U33(-6.65,4.55) U34(-6.65,5.25) U35(-6.65,5.95) U36(-6.65,6.65) U37(-6.65,7.35) U38(-6.65,8.05) U39(-6.65,8.75) U42(-6.65,10.85) U43(-6.65,11.55) U44(-6.65,12.25) U45(-6.65,12.95) U46(-6.65,13.65) U47(-6.65,14.35) U48(-6.65,15.05) U49(-6.65,15.75) U50(-6.65,16.45) U51(-6.65,17.15) U52(-6.65,17.85) V1(-5.95,-17.85) V2(-5.95,-17.15) V3(-5.95,-16.45) V4(-5.95,-15.75) V5(-5.95,-15.05) V6(-5.95,-14.35) V7(-5.95,-13.65) V8(-5.95,-12.95) V9(-5.95,-12.25) V10(-5.95,-11.55) V11(-5.95,-10.85) V13(-5.95,-9.45) V14(-5.95,-8.75) V15(-5.95,-8.05) V16(-5.95,-7.35) V17(-5.95,-6.65) V18(-5.95,-5.95) V19(-5.95,-5.25) V20(-5.95,-4.55) V21(-5.95,-3.85) V22(-5.95,-3.15) V23(-5.95,-2.45) V24(-5.95,-1.75) V25(-5.95,-1.05) V26(-5.95,-0.35) V27(-5.95,0.35) V28(-5.95,1.05) V29(-5.95,1.75) V30(-5.95,2.45) V31(-5.95,3.15) V32(-5.95,3.85) V33(-5.95,4.55) V34(-5.95,5.25) V35(-5.95,5.95) V36(-5.95,6.65) V37(-5.95,7.35) V38(-5.95,8.05) V39(-5.95,8.75) V40(-5.95,9.45) V42(-5.95,10.85) V43(-5.95,11.55) V44(-5.95,12.25) V45(-5.95,12.95) V46(-5.95,13.65) V47(-5.95,14.35) V48(-5.95,15.05) V49(-5.95,15.75) V50(-5.95,16.45) V51(-5.95,17.15) V52(-5.95,17.85) W2(-5.25,-17.15) W4(-5.25,-15.75) W6(-5.25,-14.35) W8(-5.25,-12.95) W10(-5.25,-11.55) W14(-5.25,-8.75) W15(-5.25,-8.05) W16(-5.25,-7.35) W17(-5.25,-6.65) W18(-5.25,-5.95) W19(-5.25,-5.25) W20(-5.25,-4.55) W21(-5.25,-3.85) W22(-5.25,-3.15) W23(-5.25,-2.45) W24(-5.25,-1.75) W25(-5.25,-1.05) W26(-5.25,-0.35) W27(-5.25,0.35) W28(-5.25,1.05) W29(-5.25,1.75) W30(-5.25,2.45) W31(-5.25,3.15) W32(-5.25,3.85) W33(-5.25,4.55) W34(-5.25,5.25) W35(-5.25,5.95) W36(-5.25,6.65) W37(-5.25,7.35) W38(-5.25,8.05) W39(-5.25,8.75) W43(-5.25,11.55) W45(-5.25,12.95) W47(-5.25,14.35) W49(-5.25,15.75) W51(-5.25,17.15) Y1(-4.55,-17.85) Y2(-4.55,-17.15) Y3(-4.55,-16.45) Y4(-4.55,-15.75) Y5(-4.55,-15.05) Y6(-4.55,-14.35) Y7(-4.55,-13.65) Y8(-4.55,-12.95) Y9(-4.55,-12.25) Y10(-4.55,-11.55) Y11(-4.55,-10.85) Y14(-4.55,-8.75) Y15(-4.55,-8.05) Y16(-4.55,-7.35) Y17(-4.55,-6.65) Y18(-4.55,-5.95) Y19(-4.55,-5.25) Y20(-4.55,-4.55) Y21(-4.55,-3.85) Y22(-4.55,-3.15) Y23(-4.55,-2.45) Y24(-4.55,-1.75) Y25(-4.55,-1.05) Y26(-4.55,-0.35) Y27(-4.55,0.35) Y28(-4.55,1.05) Y29(-4.55,1.75) Y30(-4.55,2.45) Y31(-4.55,3.15) Y32(-4.55,3.85) Y33(-4.55,4.55) Y34(-4.55,5.25) Y35(-4.55,5.95) Y36(-4.55,6.65) Y37(-4.55,7.35) Y38(-4.55,8.05) Y39(-4.55,8.75) Y42(-4.55,10.85) Y43(-4.55,11.55) Y44(-4.55,12.25) Y45(-4.55,12.95) Y46(-4.55,13.65) Y47(-4.55,14.35) Y48(-4.55,15.05) Y49(-4.55,15.75) Y50(-4.55,16.45) Y51(-4.55,17.15) Y52(-4.55,17.85)
C0201
  rect 0.203x0.381 smd: 1(-0.225,0) 2(0.225,0)
C0402
  custom 0.12x0.12 smd: 1(0.39,0) 2(-0.39,0)
C0402_2
  custom 0.12x0.12 smd: 1(0.39,0) 2(-0.39,0)
C0603
  rect 0.686x0.813 smd: 1(0.6,0) 2(-0.6,0)
C0805
  rect 0.864x1.372 smd: 1(0.88,0) 2(-0.88,0)
C1206
  rect 1.219x1.626 smd: 1(1.4,0) 2(-1.4,0)
C3528
  rect 1.6x2.591 smd: 1(1.5,0) 2(-1.5,0)
CC1808
  rect 2.159x2.286 smd: 1(-2.349,0) 2(2.349,0)
CC7343
  rect 2.413x2.819 smd: 1(-3.2,0) 2(3.2,0)
CHOKE-PCMC063T-3R3MN-SMT
  rect 1.854x3.505 smd: 1(-3.275,0) 2(3.275,0)
CLIP-39X39-89X20-3P
  rect 2.261x0.508 smd: 1(-2.125,0) 3(2.125,0)
  rect 0.991x0.991 smd: 2(0,0)
D-0_6X0_3-0_32H-SMT
  custom 0.051x0.051 smd: 1(-0.242,0) 2(0.242,0)
D-1_2X0_8-0_7H
  rect 0.61x0.787 smd: 1(-0.85,0) 2(0.85,0)
D-2_8X1_78
  rect 2.21x1.397 smd: 1(-0.95,0)
  rect 0.889x1.397 smd: 2(1.6,0)
D-3_8X2_5
  rect 1.6x1.905 smd: 1(-2.15,0) 2(2.15,0)
D-SOT523_213-1_6-1
  rect 0.508x0.406 smd: 1(0.65,0.5) 2(0.65,-0.5) 3(-0.65,0)
D-TO277_213-6_1X4_3
  rect 1.168x1.397 smd: 1(3.885,1.05) 2(3.885,-1.05)
  rect 4.648x3.505 smd: 3(0,0)
DCJK-JPD113D-DB570-7H-5P
  round 1.702 hole 1.702 unplated: (-3.5,0) (3.5,0)
  oval 2.007x3.505 hole 0.991x2.489: 1(5.7,-2.45) 2(-5.7,-2.45) 3(5.7,3.35) 4(-5.7,3.35) 8(0,2.2) 9(0,-2)
  oval 2.718x2.007 hole 1.702x0.991: 5(3,5.35) 6(-3,5.35)
  round 1.905 hole 1.499: 7(0,5.35)
DDR4-ADDR0107-P005A-RVS-SMT
  round 1.092 hole 1.092 unplated: (-34.4,0)
  round 1.6 hole 1.6 unplated: (34.4,0)
  rect 0.254x1.753 smd: 1(33.375,4.1) 2(33.125,-4.1) 3(32.875,4.1) 4(32.625,-4.1) 5(32.375,4.1) 6(32.125,-4.1) 7(31.875,4.1) 8(31.625,-4.1) 9(31.375,4.1) 10(31.125,-4.1) 11(30.875,4.1) 12(30.625,-4.1) 13(30.375,4.1) 14(30.125,-4.1) 15(29.875,4.1) 16(29.625,-4.1) 17(29.375,4.1) 18(29.125,-4.1) 19(28.875,4.1) 20(28.625,-4.1) 21(28.375,4.1) 22(28.125,-4.1) 23(27.875,4.1) 24(27.625,-4.1) 25(27.375,4.1) 26(27.125,-4.1) 27(26.875,4.1) 28(26.625,-4.1) 29(26.375,4.1) 30(26.125,-4.1) 31(25.875,4.1) 32(25.625,-4.1) 33(25.375,4.1) 34(25.125,-4.1) 35(24.875,4.1) 36(24.625,-4.1) 37(24.375,4.1) 38(24.125,-4.1) 39(23.875,4.1) 40(23.625,-4.1) 41(23.375,4.1) 42(23.125,-4.1) 43(22.875,4.1) 44(22.625,-4.1) 45(22.375,4.1) 46(22.125,-4.1) 47(21.875,4.1) 48(21.625,-4.1) 49(21.375,4.1) 50(21.125,-4.1) 51(20.875,4.1) 52(20.625,-4.1) 53(20.375,4.1) 54(20.125,-4.1) 55(19.875,4.1) 56(19.625,-4.1) 57(19.375,4.1) 58(19.125,-4.1) 59(18.875,4.1) 60(18.625,-4.1) 61(18.375,4.1) 62(18.125,-4.1) 63(17.875,4.1) 64(17.625,-4.1) 65(17.375,4.1) 66(17.125,-4.1) 67(16.875,4.1) 68(16.625,-4.1) 69(16.375,4.1) 70(16.125,-4.1) 71(15.875,4.1) 72(15.625,-4.1) 73(15.375,4.1) 74(15.125,-4.1) 75(14.875,4.1) 76(14.625,-4.1) 77(14.375,4.1) 78(14.125,-4.1) 79(13.875,4.1) 80(13.625,-4.1) 81(13.375,4.1) 82(13.125,-4.1) 83(12.875,4.1) 84(12.625,-4.1) 85(12.375,4.1) 86(12.125,-4.1) 87(11.875,4.1) 88(11.625,-4.1) 89(11.375,4.1) 90(11.125,-4.1) 91(10.875,4.1) 92(10.625,-4.1) 93(10.375,4.1) 94(10.125,-4.1) 95(9.875,4.1) 96(9.625,-4.1) 97(9.375,4.1) 98(9.125,-4.1) 99(8.875,4.1) 100(8.625,-4.1) 101(8.375,4.1) 102(8.125,-4.1) 103(7.875,4.1) 104(7.625,-4.1) 105(7.375,4.1) 106(7.125,-4.1) 107(6.875,4.1) 108(6.625,-4.1) 109(6.375,4.1) 110(6.125,-4.1) 111(5.875,4.1) 112(5.625,-4.1) 113(5.375,4.1) 114(5.125,-4.1) 115(4.875,4.1) 116(4.625,-4.1) 117(4.375,4.1) 118(4.125,-4.1) 119(3.875,4.1) 120(3.625,-4.1) 121(3.375,4.1) 122(3.125,-4.1) 123(2.875,4.1) 124(2.625,-4.1) 125(2.375,4.1) 126(2.125,-4.1) 127(1.875,4.1) 128(1.625,-4.1) 129(1.375,4.1) 130(1.125,-4.1) 131(0.875,4.1) 132(0.625,-4.1) 133(0.375,4.1) 134(0.125,-4.1) 135(-0.125,4.1) 136(-0.375,-4.1) 137(-0.625,4.1) 138(-0.875,-4.1) 139(-1.125,4.1) 140(-1.375,-4.1) 141(-1.625,4.1) 142(-1.875,-4.1) 143(-2.125,4.1) 144(-2.375,-4.1) 145(-4.625,4.1) 146(-4.875,-4.1) 147(-5.125,4.1) 148(-5.375,-4.1) 149(-5.625,4.1) 150(-5.875,-4.1) 151(-6.125,4.1) 152(-6.375,-4.1) 153(-6.625,4.1) 154(-6.875,-4.1) 155(-7.125,4.1) 156(-7.375,-4.1) 157(-7.625,4.1) 158(-7.875,-4.1) 159(-8.125,4.1) 160(-8.375,-4.1) 161(-8.625,4.1) 162(-8.875,-4.1) 163(-9.125,4.1) 164(-9.375,-4.1) 165(-9.625,4.1) 166(-9.875,-4.1) 167(-10.125,4.1) 168(-10.375,-4.1) 169(-10.625,4.1) 170(-10.875,-4.1) 171(-11.125,4.1) 172(-11.375,-4.1) 173(-11.625,4.1) 174(-11.875,-4.1) 175(-12.125,4.1) 176(-12.375,-4.1) 177(-12.625,4.1) 178(-12.875,-4.1) 179(-13.125,4.1) 180(-13.375,-4.1) 181(-13.625,4.1) 182(-13.875,-4.1) 183(-14.125,4.1) 184(-14.375,-4.1) 185(-14.625,4.1) 186(-14.875,-4.1) 187(-15.125,4.1) 188(-15.375,-4.1) 189(-15.625,4.1) 190(-15.875,-4.1) 191(-16.125,4.1) 192(-16.375,-4.1) 193(-16.625,4.1) 194(-16.875,-4.1) 195(-17.125,4.1) 196(-17.375,-4.1) 197(-17.625,4.1) 198(-17.875,-4.1) 199(-18.125,4.1) 200(-18.375,-4.1) 201(-18.625,4.1) 202(-18.875,-4.1) 203(-19.125,4.1) 204(-19.375,-4.1) 205(-19.625,4.1) 206(-19.875,-4.1) 207(-20.125,4.1) 208(-20.375,-4.1) 209(-20.625,4.1) 210(-20.875,-4.1) 211(-21.125,4.1) 212(-21.375,-4.1) 213(-21.625,4.1) 214(-21.875,-4.1) 215(-22.125,4.1) 216(-22.375,-4.1) 217(-22.625,4.1) 218(-22.875,-4.1) 219(-23.125,4.1) 220(-23.375,-4.1) 221(-23.625,4.1) 222(-23.875,-4.1) 223(-24.125,4.1) 224(-24.375,-4.1) 225(-24.625,4.1) 226(-24.875,-4.1) 227(-25.125,4.1) 228(-25.375,-4.1) 229(-25.625,4.1) 230(-25.875,-4.1) 231(-26.125,4.1) 232(-26.375,-4.1) 233(-26.625,4.1) 234(-26.875,-4.1) 235(-27.125,4.1) 236(-27.375,-4.1) 237(-27.625,4.1) 238(-27.875,-4.1) 239(-28.125,4.1) 240(-28.375,-4.1) 241(-28.625,4.1) 242(-28.875,-4.1) 243(-29.125,4.1) 244(-29.375,-4.1) 245(-29.625,4.1) 246(-29.875,-4.1) 247(-30.125,4.1) 248(-30.375,-4.1) 249(-30.625,4.1) 250(-30.875,-4.1) 251(-31.125,4.1) 252(-31.375,-4.1) 253(-31.625,4.1) 254(-31.875,-4.1) 255(-32.125,4.1) 256(-32.375,-4.1) 257(-32.625,4.1) 258(-32.875,-4.1) 259(-33.125,4.1) 260(-33.375,-4.1)
  rect 3.505x4.597 smd: 261(33.8,12) 262(-33.8,12)
DDR4-D4AR0-26001-1P80-RVS-SMT
  round 1.092 hole 1.092 unplated: (-34.4,0)
  round 1.6 hole 1.6 unplated: (34.4,0)
  rect 0.254x1.753 smd: 1(33.375,4.1) 2(33.125,-4.1) 3(32.875,4.1) 4(32.625,-4.1) 5(32.375,4.1) 6(32.125,-4.1) 7(31.875,4.1) 8(31.625,-4.1) 9(31.375,4.1) 10(31.125,-4.1) 11(30.875,4.1) 12(30.625,-4.1) 13(30.375,4.1) 14(30.125,-4.1) 15(29.875,4.1) 16(29.625,-4.1) 17(29.375,4.1) 18(29.125,-4.1) 19(28.875,4.1) 20(28.625,-4.1) 21(28.375,4.1) 22(28.125,-4.1) 23(27.875,4.1) 24(27.625,-4.1) 25(27.375,4.1) 26(27.125,-4.1) 27(26.875,4.1) 28(26.625,-4.1) 29(26.375,4.1) 30(26.125,-4.1) 31(25.875,4.1) 32(25.625,-4.1) 33(25.375,4.1) 34(25.125,-4.1) 35(24.875,4.1) 36(24.625,-4.1) 37(24.375,4.1) 38(24.125,-4.1) 39(23.875,4.1) 40(23.625,-4.1) 41(23.375,4.1) 42(23.125,-4.1) 43(22.875,4.1) 44(22.625,-4.1) 45(22.375,4.1) 46(22.125,-4.1) 47(21.875,4.1) 48(21.625,-4.1) 49(21.375,4.1) 50(21.125,-4.1) 51(20.875,4.1) 52(20.625,-4.1) 53(20.375,4.1) 54(20.125,-4.1) 55(19.875,4.1) 56(19.625,-4.1) 57(19.375,4.1) 58(19.125,-4.1) 59(18.875,4.1) 60(18.625,-4.1) 61(18.375,4.1) 62(18.125,-4.1) 63(17.875,4.1) 64(17.625,-4.1) 65(17.375,4.1) 66(17.125,-4.1) 67(16.875,4.1) 68(16.625,-4.1) 69(16.375,4.1) 70(16.125,-4.1) 71(15.875,4.1) 72(15.625,-4.1) 73(15.375,4.1) 74(15.125,-4.1) 75(14.875,4.1) 76(14.625,-4.1) 77(14.375,4.1) 78(14.125,-4.1) 79(13.875,4.1) 80(13.625,-4.1) 81(13.375,4.1) 82(13.125,-4.1) 83(12.875,4.1) 84(12.625,-4.1) 85(12.375,4.1) 86(12.125,-4.1) 87(11.875,4.1) 88(11.625,-4.1) 89(11.375,4.1) 90(11.125,-4.1) 91(10.875,4.1) 92(10.625,-4.1) 93(10.375,4.1) 94(10.125,-4.1) 95(9.875,4.1) 96(9.625,-4.1) 97(9.375,4.1) 98(9.125,-4.1) 99(8.875,4.1) 100(8.625,-4.1) 101(8.375,4.1) 102(8.125,-4.1) 103(7.875,4.1) 104(7.625,-4.1) 105(7.375,4.1) 106(7.125,-4.1) 107(6.875,4.1) 108(6.625,-4.1) 109(6.375,4.1) 110(6.125,-4.1) 111(5.875,4.1) 112(5.625,-4.1) 113(5.375,4.1) 114(5.125,-4.1) 115(4.875,4.1) 116(4.625,-4.1) 117(4.375,4.1) 118(4.125,-4.1) 119(3.875,4.1) 120(3.625,-4.1) 121(3.375,4.1) 122(3.125,-4.1) 123(2.875,4.1) 124(2.625,-4.1) 125(2.375,4.1) 126(2.125,-4.1) 127(1.875,4.1) 128(1.625,-4.1) 129(1.375,4.1) 130(1.125,-4.1) 131(0.875,4.1) 132(0.625,-4.1) 133(0.375,4.1) 134(0.125,-4.1) 135(-0.125,4.1) 136(-0.375,-4.1) 137(-0.625,4.1) 138(-0.875,-4.1) 139(-1.125,4.1) 140(-1.375,-4.1) 141(-1.625,4.1) 142(-1.875,-4.1) 143(-2.125,4.1) 144(-2.375,-4.1) 145(-4.625,4.1) 146(-4.875,-4.1) 147(-5.125,4.1) 148(-5.375,-4.1) 149(-5.625,4.1) 150(-5.875,-4.1) 151(-6.125,4.1) 152(-6.375,-4.1) 153(-6.625,4.1) 154(-6.875,-4.1) 155(-7.125,4.1) 156(-7.375,-4.1) 157(-7.625,4.1) 158(-7.875,-4.1) 159(-8.125,4.1) 160(-8.375,-4.1) 161(-8.625,4.1) 162(-8.875,-4.1) 163(-9.125,4.1) 164(-9.375,-4.1) 165(-9.625,4.1) 166(-9.875,-4.1) 167(-10.125,4.1) 168(-10.375,-4.1) 169(-10.625,4.1) 170(-10.875,-4.1) 171(-11.125,4.1) 172(-11.375,-4.1) 173(-11.625,4.1) 174(-11.875,-4.1) 175(-12.125,4.1) 176(-12.375,-4.1) 177(-12.625,4.1) 178(-12.875,-4.1) 179(-13.125,4.1) 180(-13.375,-4.1) 181(-13.625,4.1) 182(-13.875,-4.1) 183(-14.125,4.1) 184(-14.375,-4.1) 185(-14.625,4.1) 186(-14.875,-4.1) 187(-15.125,4.1) 188(-15.375,-4.1) 189(-15.625,4.1) 190(-15.875,-4.1) 191(-16.125,4.1) 192(-16.375,-4.1) 193(-16.625,4.1) 194(-16.875,-4.1) 195(-17.125,4.1) 196(-17.375,-4.1) 197(-17.625,4.1) 198(-17.875,-4.1) 199(-18.125,4.1) 200(-18.375,-4.1) 201(-18.625,4.1) 202(-18.875,-4.1) 203(-19.125,4.1) 204(-19.375,-4.1) 205(-19.625,4.1) 206(-19.875,-4.1) 207(-20.125,4.1) 208(-20.375,-4.1) 209(-20.625,4.1) 210(-20.875,-4.1) 211(-21.125,4.1) 212(-21.375,-4.1) 213(-21.625,4.1) 214(-21.875,-4.1) 215(-22.125,4.1) 216(-22.375,-4.1) 217(-22.625,4.1) 218(-22.875,-4.1) 219(-23.125,4.1) 220(-23.375,-4.1) 221(-23.625,4.1) 222(-23.875,-4.1) 223(-24.125,4.1) 224(-24.375,-4.1) 225(-24.625,4.1) 226(-24.875,-4.1) 227(-25.125,4.1) 228(-25.375,-4.1) 229(-25.625,4.1) 230(-25.875,-4.1) 231(-26.125,4.1) 232(-26.375,-4.1) 233(-26.625,4.1) 234(-26.875,-4.1) 235(-27.125,4.1) 236(-27.375,-4.1) 237(-27.625,4.1) 238(-27.875,-4.1) 239(-28.125,4.1) 240(-28.375,-4.1) 241(-28.625,4.1) 242(-28.875,-4.1) 243(-29.125,4.1) 244(-29.375,-4.1) 245(-29.625,4.1) 246(-29.875,-4.1) 247(-30.125,4.1) 248(-30.375,-4.1) 249(-30.625,4.1) 250(-30.875,-4.1) 251(-31.125,4.1) 252(-31.375,-4.1) 253(-31.625,4.1) 254(-31.875,-4.1) 255(-32.125,4.1) 256(-32.375,-4.1) 257(-32.625,4.1) 258(-32.875,-4.1) 259(-33.125,4.1) 260(-33.375,-4.1)
  rect 2.007x3.505 smd: 261(37.75,8) 262(-37.75,12)
DFN6-1_5X1-5
  rect 0.711x0.229 smd: 1(0.465,-0.5) 2(0.465,0) 3(0.465,0.5) 4(-0.465,0.5) 5(-0.465,0) 6(-0.465,-0.5)
DFN10-3X3-5-11P-G5318
  rect 0.254x0.711 smd: 1(-1,-1.5) 2(-0.5,-1.5) 3(0,-1.5) 4(0.5,-1.5) 5(1,-1.5) 6(1,1.5) 7(0.5,1.5) 8(0,1.5) 9(-0.5,1.5) 10(-1,1.5)
  rect 2.591x1.6 smd: 11(0,0)
DFN10-3X3-5-11P-RT9296
  rect 0.305x0.991 smd: 1(-1,-1.6) 2(-0.5,-1.6) 3(0,-1.6) 4(0.5,-1.6) 5(1,-1.6) 6(1,1.6) 7(0.5,1.6) 8(0,1.6) 9(-0.5,1.6) 10(-1,1.6)
  rect 2.464x1.626 smd: 11(0,0)
DFN10-4_1X2-8-11P
  rect 0.203x0.61 smd: 1(-1.8,-0.9) 2(-1,-0.9) 3(-0.2,-0.9) 4(0.6,-0.9) 5(1.4,-0.9) 6(1.8,0.9) 7(1,0.9) 8(0.2,0.9) 9(-0.6,0.9) 10(-1.4,0.9)
  rect 1.397x0.787 smd: 11(-0.4,0)
DFN-8L-3X3-65-5P-0_9H
  rect 0.508x0.356 smd: 1(1.4,-0.975) 2(1.4,-0.325) 3(1.4,0.325) 4(1.4,0.975)
  custom 0.57x0.57 smd: 5(-0.51,0)
DP-3VD11201-D7AC-7H-20P-SMT
  round 0.762 hole 0.559: 1(6.36,6.88) 2(5,5.88) 3(5.36,6.88) 4(4,5.88) 5(4.36,6.88) 6(3,5.88) 7(2.51,6.88) 8(2,5.88) 9(1.51,6.88) 10(1,5.88) 11(-0.35,6.88) 12(0,5.88) 13(-1.35,6.88) 14(-1,5.88) 15(-2.35,6.88) 16(-2,5.88) 17(-3.35,6.88) 18(-3,5.88) 19(-4.35,6.88) 20(-4,5.88)
  oval 1.194x2.794 hole 0.61x2.21: 21(8.25,6.48) 23(-8.25,6.48)
  oval 1.194x2.311 hole 0.61x1.702: 22(8.25,0) 24(-8.25,0)
DSM
  rect 1.016x0.508 smd: 1(-1.3,0) 2(1.321,0)
ECAP5X3_8-6
  rect 2.997x1.6 smd: 1(2.2,0) 2(-2.2,0)
ECAP6_3X5_8-7_2
  rect 3.505x1.6 smd: 1(2.35,0) 2(-2.35,0)
ECAP6_3X6_1-7_2
  rect 3.505x1.6 smd: 1(2.8,0) 2(-2.8,0)
ESD-1X0_6-2P
  rect 0.559x0.61 smd: 1(-0.425,0) 2(0.425,0)
ESD-6X3
  rect 0.152x0.079 smd: 1(0,0)
ESD-6X6
  custom 0.035x0.035 smd: 1(0,0)
FILTER-MCM2012B900GBE-4P
  rect 0.762x0.406 smd: 1(-0.925,0.4) 2(0.925,0.4) 3(0.925,-0.4) 4(-0.925,-0.4)
GS12201-1011-9F-20P-L-SMT
  round 0.965 hole 0.965 unplated: (-5.8,0.2) (5.8,0.2)
  rect 0.254x1.143 smd: 1(-4.75,-2.125) 2(-4.25,-2.125) 3(-3.75,-2.125) 4(-3.25,-2.125) 5(-2.75,-2.125) 6(-2.25,-2.125) 7(-1.75,-2.125) 8(-1.25,-2.125) 9(-0.75,-2.125) 10(-0.25,-2.125) 11(0.25,-2.125) 12(0.75,-2.125) 13(1.25,-2.125) 14(1.75,-2.125) 15(2.25,-2.125) 16(2.75,-2.125) 17(3.25,-2.125) 18(3.75,-2.125) 19(4.25,-2.125) 20(4.75,-2.125)
  rect 1.295x1.397 smd: 21(-5.8,-2) 22(5.8,-2) 23(-5.8,2) 24(5.8,2)
GS12401-1011-9H-40P-R
  round 0.762 hole 0.762 unplated: (-10.5,0) (10.5,0)
  rect 0.254x1.143 smd: 1(9.75,2.125) 2(9.25,2.125) 3(8.75,2.125) 4(8.25,2.125) 5(7.75,2.125) 6(7.25,2.125) 7(6.75,2.125) 8(6.25,2.125) 9(5.75,2.125) 10(5.25,2.125) 11(4.75,2.125) 12(4.25,2.125) 13(3.75,2.125) 14(3.25,2.125) 15(2.75,2.125) 16(2.25,2.125) 17(1.75,2.125) 18(1.25,2.125) 19(0.75,2.125) 20(0.25,2.125) 21(-0.25,2.125) 22(-0.75,2.125) 23(-1.25,2.125) 24(-1.75,2.125) 25(-2.25,2.125) 26(-2.75,2.125) 27(-3.25,2.125) 28(-3.75,2.125) 29(-4.25,2.125) 30(-4.75,2.125) 31(-5.25,2.125) 32(-5.75,2.125) 33(-6.25,2.125) 34(-6.75,2.125) 35(-7.25,2.125) 36(-7.75,2.125) 37(-8.25,2.125) 38(-8.75,2.125) 39(-9.25,2.125) 40(-9.75,2.125)
  rect 1.499x2.997 smd: 41(12.25,0) 42(-12.25,0)
  rect 2.794x1.499 smd: 43(5.7,-2.05) 44(-5.7,-2.05)
