# Allegro board DAZGLMB1ED0 dazglmb1ed0-d-ver a-165 (.BRD) .brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
PR66878  100_1%_2  [R0201]  251.48 141.19 0 bottom
PR66879  *Short_0201  [S0201]  271.62 163.54 180 top
PR66880  *0_5%_2  [R0201]  269.54 157.78 180 top
PR66881  *Short_0201  [S0201]  271.62 164.25 180 top
PR66882  100_1%_2  [R0201]  251.61 138.01 270 bottom
PR66883  *Short_0201  [S0201]  270.05 159.48 0 top
PR66884  *0_5%_2  [R0201]  260.14 168.47 90 top
PR66885  54.9K_1%_4  [R0402]  269.26 163.39 270 bottom
PR66886  *Short_0201  [S0201]  270.05 160.19 0 top
PR66887  332K/F_4  [R0402]  271.98 165.95 180 bottom
PR66888  100_1%_2  [R0201]  251.48 138.9 0 bottom
PR66889  *Short_0201  [S0201]  260.85 168.47 270 top
PR66890  100_1%_2  [R0201]  232.05 138.65 180 bottom
PR66891  68K_1%_4  [R0402]  271.98 165.09 0 top
PR66892  *Short_0201  [S0201]  271.62 161.38 0 top
PR66893  *Short_0201  [S0201]  262.02 161.76 90 bottom
PR66894  *Short_0201  [S0201]  271.62 162.12 0 top
PR66895  49.9K_1%_4  [R0402]  263.29 162.4 180 bottom
PR66896  100_1%_2  [R0201]  233.19 138.01 180 bottom
PR66897  *0_5%_2  [R0201]  271.83 159.4 0 top
PR66898  8.06K_1%_4  [R0402]  271.47 160.27 180 top
PR66900  *Short_0201  [S0201]  260.9 161.66 180 bottom
PR66902  *2.2_5%_6  [R0603]  241.17 150.77 270 bottom
PR66905  *Short_0201  [S0201]  260.9 160.95 180 bottom
PR66907  *2.2_5%_6  [R0603]  248.43 150.79 270 bottom
PR66912  *2.2_5%_6  [R0603]  255.8 150.74 270 bottom
PR66915  *Short_0201  [S0201]  260.9 162.37 180 bottom
PR66917  *2.2_5%_6  [R0603]  270.71 148.23 270 bottom
PR66920  *Short_0201  [S0201]  260.9 159.53 180 bottom
PR66922  *2.2_5%_6  [R0603]  263.47 148.17 270 bottom
PR66925  *Short_0201  [S0201]  229.64 148.23 270 top
PR66927  *2.2_5%_6  [R0603]  226.33 145.08 90 bottom
PR66931  10K_1%_2  [R0201]  264.41 168.47 270 bottom
PR66932  10K_1%_2  [R0201]  265.12 168.47 270 bottom
PR66937  *Short_0201  [S0201]  265.83 168.47 270 top
PR66938  *10K_1%_4  [R0402]  266.03 170.17 90 top
PR66939  *Short_0201  [S0201]  260.24 163.06 180 top
PR66940  *Short_0201  [S0201]  261.61 170.48 90 top
PR66941  *Short_0201  [S0201]  266.26 158.03 180 bottom
PR66942  *Short_0201  [S0201]  260.24 163.77 180 top
PR66943  *Short_0201  [S0201]  262.33 170.48 90 top
PR66944  *Short_0201  [S0201]  265.27 158.03 180 bottom
PR66945  *Short_0201  [S0201]  260.24 164.48 180 top
PR66946  *Short_0201  [S0201]  260.9 160.24 180 bottom
PR66947  *Short_0201  [S0201]  263.04 170.48 90 top
PR66948  *Short_0201  [S0201]  264.28 158.06 180 bottom
PR66949  *Short_0201  [S0201]  260.24 165.19 180 top
PR66950  *Short_0201  [S0201]  264.46 170.48 90 top
PR66951  *Short_0201  [S0201]  263.29 158.06 0 bottom
PR66952  *Short_0201  [S0201]  260.24 165.9 180 top
PR66953  *Short_0201  [S0201]  263.75 170.48 90 top
PR66954  *Short_0201  [S0201]  262.3 158.06 0 bottom
PR66955  *Short_0201  [S0201]  260.24 166.62 180 top
PR66956  *Short_0201  [S0201]  230.35 148.23 270 top
PR66957  *Short_0201  [S0201]  228.92 148.23 270 top
PR66968  10_5%_6  [R0603]  91.46 77.44 270 top
PR66969  *2.2_5%_6  [R0603]  94.18 84.78 90 bottom
PR66970  *EV@2.2_5%_6  [R0603]  120.31 88.51 270 bottom
PR66971  EV@1_5%_6  [R0603]  119.48 78.05 270 top
PR66972  1M_5%_6  [R0603]  213.53 162.81 90 top
PR66975  *Short_0201  [S0201]  139.54 81.65 0 top
PR66976  *Short_0201  [S0201]  144.88 81.68 180 top
PR66977  *Short_0201  [S0201]  156.2 79.72 90 top
PR66978  *Short_0201  [S0201]  156.23 85.06 270 top
PR66979  *Short_0201  [S0201]  167 79.72 90 top
PR66980  *Short_0201  [S0201]  167 85.08 270 top
PR66981  *EV@2.2_5%_6  [R0603]  137.54 80.66 270 bottom
PR66982  *EV@2.2_5%_6  [R0603]  155.19 77.26 0 bottom
PR66983  *EV@2.2_5%_6  [R0603]  166.01 76.09 0 bottom
PR66984  EV@3.3_5%_6  [R0603]  127.22 81.86 0 top
PR66985  EV@3.3_5%_6  [R0603]  154.43 67.5 90 top
PR66986  EV@3.3_5%_6  [R0603]  166.26 67.5 90 top
PR66987  *Short_0402  [S0402]  129.97 86.38 180 top
PR66988  *Short_0402  [S0402]  150.26 70.04 270 top
PR66989  *Short_0402  [S0402]  161.84 69.99 270 top
PR66990  *Short_0402  [S0402]  127.68 84.04 180 top
PR66991  *Short_0402  [S0402]  127.68 86.22 180 top
PR66992  *Short_0402  [S0402]  152.27 67.94 270 top
PR66993  *Short_0402  [S0402]  150.34 67.94 270 top
PR66994  *Short_0402  [S0402]  164.1 67.96 270 top
PR66995  *Short_0402  [S0402]  162.15 67.96 270 top
PR66996  *EV@0_5%_4  [R0402]  127.68 83.07 0 top
PR66997  *Short_0402  [S0402]  127.68 85.26 180 top
PR66998  *EV@0_5%_4  [R0402]  153.23 67.94 90 top
PR66999  *Short_0402  [S0402]  151.3 67.94 90 top
PR67000  *EV@0_5%_4  [R0402]  165.07 67.96 90 top
PR67001  *Short_0402  [S0402]  163.14 67.96 90 top
PR67002  *EV@0_5%_4  [R0402]  164.36 58.08 0 bottom
PR67003  4.3K_1%_4  [R0402]  243.89 162.5 180 top
PR67004  *Short_0201  [S0201]  70.3 65.14 0 bottom
PR67005  *Short_0201  [S0201]  102.15 63.21 90 bottom
PR67006  *Short_0201  [S0201]  100.6 63.19 90 bottom
PR67007  *Short_0201  [S0201]  216.53 157.12 90 top
PR67009  *EV@0_5%_4  [R0402]  111.25 72.71 0 top
PR67010  *Short_0402  [S0402]  158.9 58.06 180 bottom
PR67171  *VL@100K_1%_6  [R0603]  352.95 90.9 0 top
PR67172  VL@22_5%_8  [R0805]  361.36 86.91 270 top
PR67173  VL@1M_5%_6  [R0603]  352.83 88.23 270 top
PR67174  VL@1M_5%_6  [R0603]  351.3 88.23 90 top
PR67175  *Short_0402  [S0402]  355.52 91.18 180 top
PR67176  *Short_0805  [S0805]  352.06 93.44 180 top
PR67194  EV@10_1%_4  [R0402]  133.32 66.56 180 bottom
PR67195  *Short_0201  [S0201]  129.31 73.47 180 top
PR67196  *Short_0201  [S0201]  127.74 73.47 0 top
PR67197  *Short_0201  [S0201]  127.75 75.73 0 top
PR67198  *Short_0201  [S0201]  129.32 75.73 180 top
PR67199  *Short_0402  [S0402]  125.37 62.96 0 bottom
PR67201  *Short_0402  [S0402]  115.72 68.04 270 bottom
PR67217  *EV@10K_1%_4  [R0402]  125.37 61.94 0 bottom
PR67219  *Short_0201  [S0201]  67.99 55.92 270 top
PR67220  *100K_5%_4  [R0402]  69.72 52.52 0 top
PR67223  *VL@0_5%_2  [R0201]  346.2 92.98 90 top
PR67224  *VL@0_5%_2  [R0201]  345.41 92.98 90 top
PR67225  *Short_0201  [S0201]  344.67 92.98 90 top
PR67226  *EV@0_5%_4  [R0402]  117.93 69.82 270 bottom
PR67229  *0_5%_4  [R0402]  173.71 81.88 90 bottom
PR67230  EV@1M_5%_6  [R0603]  109.95 61.74 90 top
PR67231  EV@22_5%_8  [R0805]  107.87 62.93 90 top
PR67232  EV@1M_5%_6  [R0603]  105.81 60.52 0 top
PR67233  *EV@100K_1%_6  [R0603]  106.07 58.06 270 top
PR67234  100K_1%_4  [R0402]  63.8 50.42 90 top
PR67235  10K_1%_4  [R0402]  65.84 59.29 90 top
PR67236  *Short_0402  [S0402]  65.37 50.51 270 top
PR67239  100K_1%_4  [R0402]  62.88 61.95 0 top
PR67240  10K_1%_4  [R0402]  68.91 54.74 270 top
PU1  BQ24780SRUYR  [QFN28-4X4-4-38P]  71.04 55.35 180 bottom
PU5  AOZ1331DI  [SON14-3X2-4-15P-SMT]  109.4 58.74 90 bottom
PU8  AOZ1331DI  [SON14-3X2-4-15P-SMT]  40.69 69.91 180 top
PU9  TPS51225RUKR  [QFN20-3X3-4-26P]  81.48 72.31 180 bottom
PU12  EV@HPA01113AIRGVR  [QFN16-4X4-65-17P-MAX4063]  127.58 66.51 180 bottom
PU19  G5719CTB1U  [SOT23-6-2_8-95-6P-G5126TB1U]  193.97 75.15 0 top
PU37  MP2949AGQKT-0092-Z  [QFN48-6X6-4-49P-MP2939]  266.36 163.47 0 top
PU38  MP86903-CGLT-Z  [QFN21-3X4-4-15P]  240.05 154.93 90 top
PU39  MP86903-CGLT-Z  [QFN21-3X4-4-15P]  247.52 154.96 90 top
PU43  MP86901-AGQT-Z  [QFN13-3X3-4]  228.87 145.48 270 top
PU44  MP86903-CGLT-Z  [QFN21-3X4-4-15P]  254.76 154.96 90 top
PU45  MP86903-CGLT-Z  [QFN21-3X4-4-15P]  261.98 152.5 90 top
PU46  MP86903-CGLT-Z  [QFN21-3X4-4-15P]  269.37 152.45 90 top
PU2001  RT8231BGQW  [WQFN20-3X3-4-21P]  179.12 80.59 180 bottom
PU3002  TMP708AIDBVR  [SOT23-5-2_8-95-5P-G708]  288.3 83.2 270 top
PU8006  VL@TPS61087DRCR  [QFN10-3X3-5-16P]  366.02 85.23 0 top
PU9001  EV@UP9511QQKI  [QFN32-4X4-4-33P-UP9511Q]  142.21 69.05 0 bottom
PU9004  EV@AOZ1331DI  [SON14-3X2-4-15P-SMT]  104.9 70.27 180 top
PU9005  EV@G9336ADJTP1U  [TSOT23-6-2_8-95-6P-1H]  160.27 58.89 180 top
PU9009  EV@RT8816AGQW  [WQFN20-3X3-4-21P]  115.29 75.89 270 top
PU9010  M5671RE1U  [DFN10-3X3-5-11P-G5318]  91.69 81.3 180 top
PU9011  EV@FDMF3035  [QFN31-5X5-5-19P]  134.72 94.76 270 top
PU9012  EV@FDMF3035  [QFN31-5X5-5-19P]  131.95 82.67 270 top
PU9013  EV@FDMF3035  [QFN31-5X5-5-19P]  153.87 72.15 0 top
PU9014  EV@FDMF3035  [QFN31-5X5-5-19P]  165.6 72.18 0 top
PU9015  RT8237CZQW_2  [DFN10-3X3-5-11P-RT9296]  240.38 160.77 90 top
Q16  METR3904-G  [SOT23_213-3_3-2]  320.82 77.82 180 top
Q20  DMG301NU-7  [SOT23_213-3_3-2]  213 140.17 180 top
Q23  METR3904-G  [SOT23_213-3_3-2]  213.13 134.2 180 top
Q32  2N7002KTB  [SOT523_213-1_6-1-0_6H]  173.63 64.1 0 top
Q34  PJX138K  [SOT563-1_6-5-6P-PJX138K]  228.37 168.88 270 bottom
Q35  PJX8838  [SOT563-1_6-5-6P-PJX138K]  346.6 91.79 270 bottom
Q42  *PJ4N3KDW  [SC70-2_1-65-6P]  173.76 67.66 90 top
Q44  PJA138K  [SOT23_213-3_3-2]  177.57 74.21 0 top
Q7819  DIS@DMG1012T-7  [D-SOT523_213-1_6-1]  337.99 87.21 270 bottom
Q7820  DIS@DMG1012T-7  [D-SOT523_213-1_6-1]  340.13 87.21 270 bottom
Q7821  NVSR@LTC044EUBFS8TL  [UMT_213-3-1_3]  333.67 84.09 180 top
Q7822  DIS@DMG1012T-7  [D-SOT523_213-1_6-1]  352.6 93.34 90 bottom
Q7823  DIS@DMG1012T-7  [D-SOT523_213-1_6-1]  355.01 93.34 90 bottom
Q7824  LTC044EUBFS8TL  [UMT_213-3-1_3]  344.9 90.34 180 top
Q7827  2N7002KTB  [SOT523_213-1_6-1-0_6H]  244.83 164.2 270 top
Q7828  2N7002KTB  [SOT523_213-1_6-1-0_6H]  242.59 164.18 270 top
Q7831  2N7002KTB  [SOT523_213-1_6-1-0_6H]  244.83 166.41 270 top
Q7832  2N7002KTB  [SOT523_213-1_6-1-0_6H]  242.72 166.39 270 top
Q7833  AP2331SA-7  [SOT23_213-3_3-2]  232.43 167.99 90 top
Q7834  *METR3904-G  [SOT23_213-3_3-2]  221.1 137.53 270 top
Q7838  *PJA3413  [SOT23_213-3_3-2]  131.47 64.99 90 top
Q7840  2N7002KTB  [SOT523_213-1_6-1-0_6H]  293.9 84.93 270 bottom
Q7842  METR3904-G  [SOT23_213-3_3-2]  295.93 82.41 270 top
Q7843  *2N7002KTB  [SOT523_213-1_6-1-0_6H]  310.84 79.21 0 bottom
Q7844  *LTC044EUBFS8TL  [UMT_213-3-1_3]  272.94 108.07 180 top
Q7845  *PJA3404  [SOT23_213-3_3-2]  44.85 46.96 270 top
Q7846  *LTC044EUBFS8TL  [UMT_213-3-1_3]  41.47 46.7 270 top
Q7847  *PJA138K  [SOT23_213-3_3-2]  42.08 51.6 270 top
Q7848  *2N7002KTB  [SOT523_213-1_6-1-0_6H]  345.74 74.57 270 top
Q7849  *2N7002KTB  [SOT523_213-1_6-1-0_6H]  343.68 74.57 270 top
Q7851  DMG1012T-7  [D-SOT523_213-1_6-1]  158.9 105.38 90 top
Q7852  DMG1012T-7  [D-SOT523_213-1_6-1]  135.15 116.55 180 top
Q7853  DMG1012T-7  [D-SOT523_213-1_6-1]  131.74 118.2 270 bottom
Q7854  DMG1012T-7  [D-SOT523_213-1_6-1]  137.92 111.73 270 top
Q7855  DMG1012T-7  [D-SOT523_213-1_6-1]  129.66 119.6 270 top
Q7856  DMG1012T-7  [D-SOT523_213-1_6-1]  129.66 117.31 90 top
Q7857  DMG1012T-7  [D-SOT523_213-1_6-1]  156.74 105.5 0 top
Q7858  PJX138K  [SOT563-1_6-5-6P-PJX138K]  147.98 99.53 90 bottom
Q7859  DMG1012T-7  [D-SOT523_213-1_6-1]  125.9 114.65 90 top
Q7860  PJX138K  [SOT563-1_6-5-6P-PJX138K]  150.39 99.53 270 bottom
Q7861  *DMG1012T-7  [D-SOT523_213-1_6-1]  135.78 111.73 180 top
Q7863  DMG1012T-7  [D-SOT523_213-1_6-1]  125.12 115.54 0 bottom
Q7864  DMG1012T-7  [D-SOT523_213-1_6-1]  128.42 115.92 0 bottom
Q7865  DMG1012T-7  [D-SOT523_213-1_6-1]  126.77 117.06 90 bottom
Q7866  DMG1012T-7  [D-SOT523_213-1_6-1]  121.1 112.87 0 bottom
Q7867  DMG1012T-7  [D-SOT523_213-1_6-1]  122.32 115.79 90 bottom
Q7874  2N7002KTB  [SOT523_213-1_6-1-0_6H]  66.21 22.67 270 bottom
Q7875  2N7002KTB  [SOT523_213-1_6-1-0_6H]  42.77 29.4 270 top
Q7876  DMG1012T-7  [D-SOT523_213-1_6-1]  205 128.11 0 top
Q7877  DMG1012T-7  [D-SOT523_213-1_6-1]  187.47 171.67 0 bottom
Q7878  DMG1012T-7  [D-SOT523_213-1_6-1]  142.65 177.89 90 bottom
Q7879  DMG1012T-7  [D-SOT523_213-1_6-1]  117.75 137.76 180 bottom
Q7880  DMG1012T-7  [D-SOT523_213-1_6-1]  131.82 118.2 270 top
Q7886  *2N7002KTB  [SOT523_213-1_6-1-0_6H]  338.09 60.29 0 top
Q7888  2N7002KTB  [SOT523_213-1_6-1-0_6H]  62.31 51.03 90 top
Q7889  *2N7002KTB  [SOT523_213-1_6-1-0_6H]  60.09 50.89 90 top
Q7890  *WIGIG@2N7002KTB  [SOT523_213-1_6-1-0_6H]  47.65 50.64 90 top
Q7891  *WIGIG@2N7002KTB  [SOT523_213-1_6-1-0_6H]  49.68 50.66 270 top
Q7892  *PJX8838  [SOT563-1_6-5-6P-PJX138K]  122.7 65.12 0 top
Q7896  P_KB@PJX8838  [SOT563-1_6-5-6P-PJX138K]  270 47.13 90 top
Q7901  2N7002KTB  [SOT523_213-1_6-1-0_6H]  216.17 168.24 270 bottom
Q7902  METR3904-G  [SOT23_213-3_3-2]  49.68 76.29 270 top
Q7903  PJX8838  [SOT563-1_6-5-6P-PJX138K]  249.83 163.67 90 top
Q7904  PJX8838  [SOT563-1_6-5-6P-PJX138K]  246.88 163.67 90 top
Q7909  PJX8838  [SOT563-1_6-5-6P-PJX138K]  312.57 80.36 0 top
Q7911  PJX8838  [SOT563-1_6-5-6P-PJX138K]  316.25 81.63 0 top
Q7915  PJX8838  [SOT563-1_6-5-6P-PJX138K]  13.69 31.61 180 top
Q7916  PJX8838  [SOT563-1_6-5-6P-PJX138K]  373.03 17.41 270 top
Q7917  *2N7002KTB  [SOT523_213-1_6-1-0_6H]  332.25 65.96 0 top
Q7923  *PJX8838  [SOT563-1_6-5-6P-PJX138K]  363.62 39.59 180 top
Q7924  Tobii@AP2331SA-7  [SOT23_213-3_3-2]  25.95 90.87 0 top
Q7926  *PJX8838  [SOT563-1_6-5-6P-PJX138K]  359.58 37.25 180 top
Q7927  *2N7002KTB  [SOT523_213-1_6-1-0_6H]  371.88 18.61 0 bottom
Q7930  PJX8838  [SOT563-1_6-5-6P-PJX138K]  366.16 39.56 180 top
Q7931  OP@PJA138K  [SOT23_213-3_3-2]  323.74 54.35 90 top
Q7932  OP@PJA138K  [SOT23_213-3_3-2]  326.94 58.49 90 top
Q7933  2N7002KTB  [SOT523_213-1_6-1-0_6H]  322.85 49.5 270 top
Q7934  *2N7002KTB  [SOT523_213-1_6-1-0_6H]  325.14 48.48 270 top
Q7935  METR3904-G  [SOT23_213-3_3-2]  33.55 76.32 0 top
Q7937  LTC044EUBFS8TL  [UMT_213-3-1_3]  40.03 28.92 0 top
Q7938  LTC044EUBFS8TL  [UMT_213-3-1_3]  36.62 28.92 0 top
Q7939  M_KB@2N7002KTB  [SOT523_213-1_6-1-0_6H]  128.03 50.01 180 bottom
Q7941  *2N7002KTB  [SOT523_213-1_6-1-0_6H]  198.72 53.23 90 bottom
Q7943  DMG1012T-7  [D-SOT523_213-1_6-1]  126 110.58 0 bottom
Q7944  DMG1012T-7  [D-SOT523_213-1_6-1]  128.8 110.71 90 bottom
Q7945  NVSR@DMG1012T-7  [D-SOT523_213-1_6-1]  129.18 118.71 0 bottom
Q7947  *SUB@PJX8838  [SOT563-1_6-5-6P-PJX138K]  31.74 47.01 90 bottom
Q7948  DMG1012T-7  [D-SOT523_213-1_6-1]  375.38 15.26 180 bottom
Q7949  PJX8838  [SOT563-1_6-5-6P-PJX138K]  359.52 40.06 90 bottom
R116  24.9_1%_4  [R0402]  222.02 130.52 90 top
R124  *1K_1%_2  [R0201]  273.93 127.02 0 top
R126  20_1%_2  [R0201]  211.48 123.79 270 bottom
R129  49.9_1%_2  [R0201]  273.2 123.54 90 top
R145  100_1%_2  [R0201]  230.12 114.44 270 bottom
R151  *Short_0603  [S0603]  239.75 112.18 180 bottom
R178  1K_1%_4  [R0402]  206.73 102.61 180 bottom
R179  60.4_1%_4  [R0402]  210.41 103.5 270 bottom
R180  *100K_1%_4  [R0402]  266.59 99.31 180 bottom
R181  *0_5%_4  [R0402]  266.59 100.42 180 bottom
R184  *100K_1%_4  [R0402]  212.11 137.76 180 top
R191  1K_1%_4  [R0402]  212.11 136.62 180 top
R192  100_1%_2  [R0201]  226.59 95.27 180 bottom
R193  75_1%_4  [R0402]  226.61 96.33 180 bottom
R194  24.9_1%_4  [R0402]  226.61 97.45 180 bottom
R195  121_1%_4  [R0402]  226.61 98.57 0 bottom
R202  *0_5%_4  [R0402]  206.19 98.62 180 bottom
R204  *0_5%_4  [R0402]  206.06 100.22 0 bottom
R205  10K_1%_2  [R0201]  206.01 101.18 0 bottom
R222  1K_1%_4  [R0402]  318.41 78.45 90 top
R223  10K_1%_2  [R0201]  327.22 77.44 90 top
R229  10K_1%_2  [R0201]  324.25 77.6 90 top
R230  *Short_0402  [S0402]  329.51 78.66 180 top
R251  *0_5%_4  [R0402]  175.79 70.2 0 top
R379  3.01K_1%_4  [R0402]  349.12 50 90 bottom
R381  SUB@10K_1%_2  [R0201]  29.84 43.68 90 bottom
R382  100K_1%_4  [R0402]  189.5 67.66 0 bottom
R388  4.7K_1%_4  [R0402]  187.6 70.32 270 top
R395  43_5%_4  [R0402]  184.81 67.15 270 bottom
R396  100_1%_2  [R0201]  352.45 61.43 270 top
R397  100K_1%_4  [R0402]  345.36 55.46 0 bottom
R400  14K_1%_4  [R0402]  346.22 48.35 90 bottom
R402  4.75K_0.1%_4  [R0402]  352.65 55.49 180 bottom
R403  1M_1%_4  [R0402]  359.68 56.1 180 top
R454  10K_1%_2  [R0201]  341.78 57.5 0 bottom
R538  56.2_1%_2  [R0201]  273.93 129.02 180 top
R539  *54.9_1%_2  [R0201]  273.93 128.26 180 top
R540  *Short_0402  [S0402]  272.18 128.74 180 top
R541  *1.5K_1%_2  [R0201]  270.15 132.55 180 top
R542  *750_1%_2  [R0201]  269.13 132.55 0 top
R543  *Short_0402  [S0402]  271.67 126.71 180 top
R544  100_1%_2  [R0201]  271.29 125.7 90 top
R545  220_1%_2  [R0201]  272.28 129.76 0 top
R547  *100_1%_2  [R0201]  251.48 140.43 180 bottom
R549  *100_1%_2  [R0201]  251.48 139.67 0 bottom
R552  *49.9_1%_2  [R0201]  249.19 138.78 0 bottom
R556  *Short_0402  [S0402]  269.51 130.52 0 top
R559  20_1%_2  [R0201]  271.55 130.65 180 top
R560  *10K_1%_2  [R0201]  269.13 128.54 180 top
R563  13_1%_4  [R0402]  270.53 131.66 0 top
R564  51_1%_2  [R0201]  270.12 129.05 0 top
R566  1K_1%_4  [R0402]  271.88 127.75 180 top
R571  49.9_1%_2  [R0201]  270.45 125.44 270 top
R578  51_1%_2  [R0201]  270.15 124.17 90 top
R618  100K_1%_4  [R0402]  175.79 68.98 0 top
R807  *33_1%_2  [R0201]  191.66 59.53 180 bottom
R812  100K_1%_4  [R0402]  178.46 53.81 0 bottom
R813  10K_1%_2  [R0201]  178.38 57.57 180 bottom
R815  100K_1%_4  [R0402]  178.46 58.79 0 bottom
R816  100K_1%_4  [R0402]  178.84 62.83 270 bottom
R817  *22_1%_4  [R0402]  181 60.67 0 bottom
R821  *Short_0402  [S0402]  176.32 55.82 270 bottom
R823  10K_1%_2  [R0201]  189.63 69.94 90 top
R966  2.2_1%_6  [R0603]  174.52 60.52 180 top
R2708  *SUB@0_5%_4  [R0402]  38.27 51.91 270 bottom
R2709  *SUB@10K_1%_2  [R0201]  35.99 52.06 270 bottom
R17808  *49.9K_1%_4  [R0402]  305.96 78.2 270 top
R20689  100K_1%_4  [R0402]  348.38 61.43 270 top
R20690  14K_1%_4  [R0402]  348.89 57.75 90 bottom
R20693  10K_1%_2  [R0201]  344.83 63.59 270 top
R20694  10K_1%_2  [R0201]  353.72 57.75 90 bottom
R20751  1K_1%_4  [R0402]  212.26 131.64 180 top
R20752  *1K_1%_4  [R0402]  208.99 102.73 180 bottom
R20753  *51_1%_2  [R0201]  269.26 124.04 180 top
R20754  *51_1%_2  [R0201]  272.44 124.17 90 top
R20755  *51_1%_2  [R0201]  271.67 124.17 90 top
R20756  51_1%_2  [R0201]  269.13 124.88 180 top
R20757  *0_5%_2  [R0201]  270.91 124.17 90 top
R20758  *Short_0402  [S0402]  273.96 125.34 270 top
R20761  *100_1%_2  [R0201]  250.85 138.01 90 bottom
R20762  *1K_1%_4  [R0402]  273.12 112.31 180 top
R20763  *1K_1%_4  [R0402]  271.06 110.43 90 top
R20764  *1K_1%_4  [R0402]  273.48 115.21 180 top
R20765  *1K_1%_4  [R0402]  272.03 110.43 90 top
R20766  *1K_1%_4  [R0402]  273.12 113.28 180 top
R20767  1K_1%_4  [R0402]  273.96 110.46 90 top
R20768  OP@1K_1%_4  [R0402]  273.48 114.24 180 top
R20811  30_1%_4  [R0402]  211.48 125.57 270 bottom
R20812  *100_1%_2  [R0201]  248.05 138.32 0 bottom
R20813  *49.9_1%_2  [R0201]  269.13 125.65 180 top
R20814  *49.9_1%_2  [R0201]  273.96 123.41 270 top
R20815  *49.9_1%_2  [R0201]  269.01 122.98 270 top
R20816  *Short_0402  [S0402]  230.53 113.12 0 bottom
R20817  *Short_0402  [S0402]  232 114.44 180 bottom
R20818  100_1%_2  [R0201]  233.24 114.14 90 bottom
R20819  *100_1%_2  [R0201]  232.05 137.89 180 bottom
R20820  *100_1%_2  [R0201]  233.19 139.28 180 bottom
R20821  *Short_0603  [S0603]  271.67 105.88 180 top
R20822  *Short_0603  [S0603]  218.08 139.03 90 bottom
R20823  *Short_0603  [S0603]  230.27 125.67 0 bottom
R20824  *0_5%_6  [R0603]  219.91 139.84 90 bottom
R20825  1K_1%_4  [R0402]  330.5 54.96 90 bottom
R20826  *1K_1%_4  [R0402]  330.5 56.73 270 bottom
R20827  *1K_1%_4  [R0402]  335.22 61.56 180 top
R20828  1K_1%_4  [R0402]  335.22 60.54 180 top
R20829  *0_5%_4  [R0402]  335.55 53.31 90 bottom
R20830  *Short_0402  [S0402]  336.57 53.31 90 bottom
R20831  *1K_1%_4  [R0402]  332.76 51.02 270 top
R20833  *1K_1%_4  [R0402]  330.75 49.11 90 top
R20834  *1K_1%_4  [R0402]  332.38 53.05 0 bottom
R20835  *1K_1%_4  [R0402]  331.62 58.16 180 bottom
R20836  1K_1%_4  [R0402]  332.76 49.11 90 top
R20837  1K_1%_4  [R0402]  331.74 51.02 270 top
R20838  1K_1%_4  [R0402]  330.75 51.02 270 top
R20839  1K_1%_4  [R0402]  332.38 54.07 180 bottom
R20840  1K_1%_4  [R0402]  331.64 59.15 0 bottom
R20841  100K_1%_4  [R0402]  335.3 50.38 90 top
R20842  100K_1%_4  [R0402]  334.03 50.38 270 top
R20844  100K_1%_4  [R0402]  349.91 57.75 270 bottom
R20845  10K_1%_2  [R0201]  341.78 59.53 0 bottom
R20846  10K_1%_2  [R0201]  341.78 60.52 0 bottom
R20847  10K_1%_2  [R0201]  341.78 58.51 0 bottom
R20848  499_1%_2  [R0201]  352.06 48.28 90 bottom
R20849  *0_5%_4  [R0402]  353.49 61.66 270 top
R20850  100_1%_2  [R0201]  341.78 56.99 0 top
R20852  3.32K_1%_4  [R0402]  338.98 64.99 90 bottom
R20853  3.32K_1%_4  [R0402]  337.83 69.6 180 bottom
R20854  2.2K_5%_4  [R0402]  337.84 64.99 270 bottom
R20855  2.2K_5%_4  [R0402]  336.7 64.99 270 bottom
R20857  100K_1%_4  [R0402]  344.19 61.43 90 top
R20858  100K_1%_4  [R0402]  343.17 61.43 90 top
R20859  2.2K_5%_4  [R0402]  346.35 61.43 90 top
R20860  2.2K_5%_4  [R0402]  347.37 61.43 90 top
R20861  10K_1%_2  [R0201]  351.18 61.43 270 bottom
R20862  10K_1%_2  [R0201]  349.4 61.43 90 bottom
R20863  10K_1%_2  [R0201]  352.19 57.75 90 bottom
R20864  100K_1%_4  [R0402]  351.05 57.75 270 bottom
R20865  100K_1%_4  [R0402]  341.78 59.91 0 top
R20866  100K_1%_4  [R0402]  345.33 61.43 270 top
R20867  1M_1%_4  [R0402]  359.68 57.24 180 top
R20868  1M_1%_4  [R0402]  341.78 60.93 0 top
R20881  SUB@10K_1%_2  [R0201]  39.26 52.09 270 bottom
R20887  100K_1%_4  [R0402]  190.77 69.94 270 top
R20889  10K_1%_2  [R0201]  197.23 55.06 0 bottom
R20890  *10K_1%_2  [R0201]  189.5 66.01 180 bottom
R20891  *10K_1%_2  [R0201]  189.63 63.52 90 bottom
R20892  100K_1%_4  [R0402]  182.93 69.94 270 top
R20893  100K_1%_4  [R0402]  193.95 56.1 0 bottom
R20894  4.7K_1%_4  [R0402]  186.46 70.32 270 top
R20895  4.7K_1%_4  [R0402]  185.14 70.02 270 top
R20896  4.7K_1%_4  [R0402]  184.02 69.94 270 top
R20897  *10K_1%_2  [R0201]  174.31 70.58 0 top
R20898  *0_5%_4  [R0402]  174.57 71.97 90 top
R20900  *2.2_1%_6  [R0603]  174.52 61.94 180 top
R20901  2.2_1%_6  [R0603]  187.83 66.77 90 bottom
R20902  33_1%_2  [R0201]  191.79 64.86 90 bottom
R20903  33_1%_2  [R0201]  183.66 64.74 90 bottom
R20904  33_1%_2  [R0201]  191.41 53.69 0 bottom
R20905  33_1%_2  [R0201]  177.69 69.94 270 top
R20912  DIS@1K_1%_4  [R0402]  332.91 80.26 90 bottom
R20913  *DIS@1K_1%_4  [R0402]  331.92 80.51 90 bottom
R20914  *DIS@1K_1%_4  [R0402]  332.96 78.3 270 bottom
R20915  DIS@1K_1%_4  [R0402]  331.95 78.3 270 bottom
R20916  *DIS@1K_1%_4  [R0402]  334.89 79.98 90 bottom
R20917  DIS@1K_1%_4  [R0402]  334.84 78.25 270 bottom
R20918  *DIS@0_5%_4  [R0402]  334.56 68.88 270 bottom
R20923  DIS@0_5%_4  [R0402]  339.03 74.97 270 bottom
R20924  DIS@100K_1%_4  [R0402]  335.25 68.77 270 top
R20925  DIS@100K_1%_4  [R0402]  334.26 68.77 90 top
R20929  DIS@1K_1%_4  [R0402]  333.24 67.89 270 top
R20930  *DIS@1K_1%_4  [R0402]  333.24 67.89 270 bottom
R20931  *DIS@1K_1%_4  [R0402]  333.24 69.71 90 top
R20932  DIS@1K_1%_4  [R0402]  333.24 69.71 90 bottom
R20934  *DIS@1K_1%_4  [R0402]  332 67.89 270 top
R20935  DIS@1K_1%_4  [R0402]  332 69.69 90 top
R20936  *DIS@1K_1%_4  [R0402]  330.73 67.89 270 top
R20938  DIS@1K_1%_4  [R0402]  330.73 69.69 90 top
R20939  OP@0_5%_4  [R0402]  350.54 80.86 0 bottom
R20940  *100K_1%_4  [R0402]  340.25 84.67 90 bottom
R20941  *100K_1%_4  [R0402]  339.24 84.67 270 bottom
R20942  *100K_1%_4  [R0402]  341.27 84.67 90 bottom
R20943  *100K_1%_4  [R0402]  342.29 84.67 270 bottom
R20944  DIS@0_5%_4  [R0402]  350.54 82.01 0 bottom
R20945  OP@10_1%_4  [R0402]  335.68 84.67 270 bottom
R20946  *Short_0805  [S0805]  337.74 79.34 90 top
R20947  DIS@1K_1%_4  [R0402]  337.21 84.67 270 bottom
R20948  DIS@10K_1%_2  [R0201]  338.22 84.67 270 bottom
R20949  *Short_0402  [S0402]  355.24 78.32 270 bottom
R20950  *Short_0402  [S0402]  350.79 78.32 270 bottom
R20951  OP@10_1%_4  [R0402]  343.94 91.86 180 bottom
R20952  *Short_0402  [S0402]  351.94 78.32 270 bottom
R20953  *Short_0402  [S0402]  353.08 78.32 270 bottom
R20954  *Short_0402  [S0402]  354.22 78.32 270 bottom
R20955  *Short_0603  [S0603]  358.03 81.37 0 bottom
R20956  DIS@1K_1%_4  [R0402]  348.13 93.56 0 bottom
R20957  DIS@10K_1%_2  [R0201]  350.03 93.56 180 bottom
R20959  OP@10_1%_4  [R0402]  322.35 74.39 180 top
R20960  DIS@10_1%_4  [R0402]  321.36 73.4 180 top
R20961  100K_1%_4  [R0402]  322.73 72.99 270 top
R20962  *100K_1%_4  [R0402]  347.11 89.37 270 bottom
R20963  10K_1%_2  [R0201]  345.97 89.37 270 bottom
R20964  10K_1%_2  [R0201]  353.33 91.02 0 bottom
R20965  *Short_0402  [S0402]  343.94 90.85 180 bottom
R20966  *100K_1%_4  [R0402]  236.11 167.35 90 top
R20967  100K_1%_4  [R0402]  346.1 93.56 0 bottom
R20968  *Short_0402  [S0402]  237.13 167.35 270 top
R20970  1M_1%_4  [R0402]  252.88 166.84 90 bottom
R20972  5.1M_5%_4  [R0402]  251.48 169.1 270 bottom
R20973  *Short_0603  [S0603]  253.13 164.18 180 top
R20974  *Short_0402  [S0402]  253.64 168.88 90 top
R20985  100K_1%_4  [R0402]  251.61 169.26 90 top
R20986  100K_1%_4  [R0402]  250.36 169.26 270 top
R20987  10K_1%_2  [R0201]  240.56 166.46 0 top
R20988  10K_1%_2  [R0201]  240.56 164.18 0 top
R20994  10K_1%_2  [R0201]  240.56 165.32 0 top
R21010  2.2K_5%_4  [R0402]  227.73 167.86 90 top
R21011  2.2K_5%_4  [R0402]  229 167.86 90 top
R21012  *150_1%_4  [R0402]  218.46 168.88 0 top
R21013  *150_1%_4  [R0402]  220.87 168.88 0 top
R21016  *150_1%_4  [R0402]  223.54 169 0 top
R21018  *150_1%_4  [R0402]  225.95 169 0 top
R21026  10K_1%_2  [R0201]  228.24 170.53 0 bottom
R21032  10K_1%_2  [R0201]  228.49 167.1 180 bottom
R21039  10K_1%_2  [R0201]  356 40.61 0 top
R21049  P_PB@33_1%_2  [R0201]  174.01 58.64 270 top
R21050  *M_KB@Short_0402  [S0402]  129.05 54.19 0 bottom
R21051  *M_KB@Short_0402  [S0402]  129.05 55.59 0 bottom
R21052  P_KB@4.7K_1%_4  [R0402]  268.12 47.84 270 top
R21053  P_KB@4.7K_1%_4  [R0402]  268.22 45.56 0 top
R21054  P_KB@0_5%_4  [R0402]  265.98 45.25 0 top
R21056  P_KB@0_5%_6  [R0603]  257.17 50.84 0 bottom
R21057  P_KB@931_1%_4  [R0402]  266.31 48.86 180 top
R21058  *P_KB@0_5%_4  [R0402]  268.5 49.9 0 top
R21059  P_KB@0_5%_4  [R0402]  266.34 49.9 180 top
R21060  P_KB@0_5%_4  [R0402]  268.5 50.87 0 top
R21061  *P_KB@0_5%_4  [R0402]  266.34 50.87 180 top
R21063  P_TP@10K_1%_2  [R0201]  139.31 56.46 90 bottom
R21064  P_TP@10K_1%_2  [R0201]  138.5 56.46 90 bottom
R21065  *0_5%_4  [R0402]  136.16 65.62 0 top
R21066  *Short_0603  [S0603]  138.58 61.31 0 bottom
R21067  *2.2K_5%_4  [R0402]  120.92 65.12 90 top
R21068  *2.2K_5%_4  [R0402]  124.35 65.12 270 top
R21076  100_1%_2  [R0201]  290.39 60.93 180 bottom
R21077  10K_1%_2  [R0201]  301.14 80.61 90 top
R21078  10K_1%_2  [R0201]  297.94 77.77 90 bottom
R21079  10K_1%_2  [R0201]  299.46 80.61 90 top
R21080  10K_1%_2  [R0201]  298.67 80.61 90 top
R21081  10K_1%_2  [R0201]  297.58 78.07 90 top
R21082  10K_1%_2  [R0201]  298.6 78.07 90 top
R21083  10K_1%_2  [R0201]  296.57 78.07 90 top
R21084  10K_1%_2  [R0201]  295.68 78.07 90 top
R21085  113_1%_4  [R0402]  301.52 46.7 90 top
R21086  1K_1%_4  [R0402]  301.85 57.52 270 bottom
R21087  1K_1%_4  [R0402]  302.53 46.7 90 top
R21088  10K_1%_2  [R0201]  317.77 59.76 0 bottom
R21089  10K_1%_2  [R0201]  320.06 57.12 0 bottom
R21090  10K_1%_2  [R0201]  294.53 78.07 90 top
R21092  *10K_1%_2  [R0201]  303.78 78.17 90 bottom
R21093  *10K_1%_2  [R0201]  300.88 77.87 90 bottom
R21095  22_1%_4  [R0402]  317.77 58.89 180 top
R21096  22_1%_4  [R0402]  326.03 58.64 180 bottom
R21098  1K_1%_4  [R0402]  314.97 51.4 270 bottom
R21099  10K_1%_2  [R0201]  312.77 49.01 270 top
R21100  33_1%_2  [R0201]  314.85 55.72 180 bottom
R21101  10K_1%_2  [R0201]  317.52 64.23 0 bottom
R21102  33_1%_2  [R0201]  317.52 49.88 90 top
R21103  33_1%_2  [R0201]  314.12 53.94 180 bottom
R21104  33_1%_2  [R0201]  319.55 49.88 90 top
R21105  *4.7K_1%_4  [R0402]  315.36 52.8 0 bottom
R21106  *Short_0402  [S0402]  312.69 46.7 90 top
R21107  *0_5%_4  [R0402]  308.63 46.7 90 top
R21108  470_1%_4  [R0402]  323.11 57.9 0 top
R21109  *210_1%_4  [R0402]  311.68 46.7 270 top
R21110  *210_1%_4  [R0402]  310.66 46.7 270 top
R21111  51_1%_2  [R0201]  309.65 47.08 90 top
R21112  *1M_1%_4  [R0402]  318.54 49.88 90 top
R21113  *Short_0402  [S0402]  324 59.02 180 top
R21114  30.1_1%_4  [R0402]  306.6 46.7 270 top
R21116  30.1_1%_4  [R0402]  307.61 46.7 270 top
R21118  *100_1%_2  [R0201]  311.93 48.99 270 top
R21119  *100_1%_2  [R0201]  310.99 48.99 270 top
R21120  *100_1%_2  [R0201]  310.05 48.99 270 top
R21121  *51_1%_2  [R0201]  309.16 48.99 270 top
R21124  1K_1%_4  [R0402]  320.06 57.25 0 top
R21125  *Short_0402  [S0402]  317.77 60.67 0 top
R21126  10K_1%_2  [R0201]  318.16 57.71 180 top
R21127  *Short_0402  [S0402]  314.19 45.61 180 top
R21128  10K_1%_2  [R0201]  318.28 58.13 90 bottom
R21129  *Short_0402  [S0402]  313.71 57.88 0 bottom
R21130  *10K_1%_2  [R0201]  323.74 59.15 180 bottom
R21131  *10K_1%_2  [R0201]  306.57 48.99 270 top
R21132  10K_1%_2  [R0201]  322.85 56.61 180 bottom
R21133  1K_1%_4  [R0402]  306.85 58.13 270 bottom
R21134  10K_1%_2  [R0201]  313.46 56.86 180 bottom
R21136  10K_1%_2  [R0201]  314.24 48.23 180 top
R21137  20K_1%_4  [R0402]  323.54 49.27 270 bottom
R21138  1K_1%_4  [R0402]  45.61 74.9 0 top
R21139  2.2K_5%_4  [R0402]  316.5 77.94 0 bottom
R21140  2.2K_5%_4  [R0402]  316.25 73.12 0 bottom
R21141  *Short_0402  [S0402]  312.19 57.12 270 bottom
R21142  20K_1%_4  [R0402]  324.89 52.92 0 bottom
R21143  2.2K_5%_4  [R0402]  310.41 80.61 90 top
R21144  2.2K_5%_4  [R0402]  312.06 78.27 90 top
R21146  2.2K_5%_4  [R0402]  313.63 78.1 90 top
R21147  2.2K_5%_4  [R0402]  316.5 76.8 0 bottom
R21148  *10K_1%_2  [R0201]  316.91 47.59 270 top
R21149  10K_1%_2  [R0201]  322.09 58.89 180 top
R21150  *0_5%_4  [R0402]  316.07 45.58 180 top
R21151  *10K_1%_2  [R0201]  319.81 61.05 180 top
R21152  *Short_0402  [S0402]  321.33 45.23 270 top
R21153  *10K_1%_2  [R0201]  319.81 60.67 180 bottom
R21156  *Short_0402  [S0402]  319.04 47.82 90 top
R21157  *0_5%_4  [R0402]  318.03 47.82 90 top
R21159  *0_5%_4  [R0402]  314.17 46.7 180 top
R21164  10K_1%_2  [R0201]  298.37 83.53 270 bottom
R21165  1K_1%_4  [R0402]  291.74 83.15 180 bottom
R21166  *Short_0402  [S0402]  291.74 84.29 0 bottom
R21170  4.99K_1%_4  [R0402]  296.57 80.36 270 bottom
R21171  100K_1%_4  [R0402]  291.74 86.58 0 bottom
R21172  4.7K_1%_4  [R0402]  314.47 81.75 270 top
R21173  *100K_1%_4  [R0402]  297.2 82.13 270 bottom
R21174  4.7K_1%_4  [R0402]  318.03 81.37 90 top
R21176  10K_1%_2  [R0201]  302.84 78.17 90 bottom
R21177  10K_1%_2  [R0201]  301.75 77.87 90 bottom
R21178  10K_1%_2  [R0201]  300.25 80.61 90 top
R21187  *10K_1%_2  [R0201]  302.69 73.98 0 bottom
R21188  *10K_1%_2  [R0201]  303.88 73.6 90 bottom
R21189  604_1%_4  [R0402]  303.55 46.7 90 top
R21190  30_1%_4  [R0402]  303.25 48.99 90 top
R21191  *Short_0402  [S0402]  304.57 49.11 90 top
R21192  *10K_1%_2  [R0201]  305.43 49.11 90 top
R21193  10K_1%_2  [R0201]  325.14 64.23 0 bottom
R21194  10K_1%_2  [R0201]  322.85 67.4 180 bottom
R21195  10K_1%_2  [R0201]  317.57 66.26 0 bottom
R21196  2.7K_1%_4  [R0402]  294.3 53.15 0 bottom
R21198  10K_1%_2  [R0201]  317.52 64.1 0 top
R21200  10K_1%_2  [R0201]  317.65 66.26 0 top
R21201  *10K_1%_2  [R0201]  317.52 65.37 0 bottom
R21202  *10K_1%_2  [R0201]  319.55 72.99 0 bottom
R21203  10K_1%_2  [R0201]  319.17 70.7 90 bottom
R21204  10K_1%_2  [R0201]  319.5 70.48 180 top
R21205  *10K_1%_2  [R0201]  317.52 70.7 0 top
R21207  *10K_1%_2  [R0201]  317.49 69.16 0 top
R21208  *Short_0402  [S0402]  319.68 66.64 0 bottom
R21209  *Short_0402  [S0402]  319.68 66.36 0 top
R21210  *10K_1%_2  [R0201]  317.52 71.7 0 top
R21211  *Short_0402  [S0402]  322.73 64.02 0 bottom
R21212  *10K_1%_2  [R0201]  317.39 71.72 0 bottom
R21213  *Short_0402  [S0402]  319.68 72.1 180 bottom
R21214  *10K_1%_2  [R0201]  317.39 69.69 0 bottom
R21215  *10K_1%_2  [R0201]  317.39 70.96 0 bottom
R21216  *10K_1%_2  [R0201]  319.55 72.1 0 top
R21217  10M_5%_4  [R0402]  317.52 53.97 270 top
R21218  1M_1%_4  [R0402]  287.93 54.63 90 top
R21219  *20K_1%_4  [R0402]  319.68 67.56 0 top
R21220  *4.7K_1%_4  [R0402]  319.43 74.13 0 top
R21221  499_1%_2  [R0201]  317.27 75.91 0 top
R21222  100K_1%_4  [R0402]  327.17 48.23 90 top
R21223  499_1%_2  [R0201]  319.43 73.24 0 top
R21224  499_1%_2  [R0201]  316.89 73.24 0 top
R21225  *4.7K_1%_4  [R0402]  317.55 67.56 0 top
R21226  499_1%_2  [R0201]  312.19 71.09 90 bottom
R21227  499_1%_2  [R0201]  318.41 73.24 180 top
R21228  499_1%_2  [R0201]  311.3 71.09 90 bottom
R21229  *20K_1%_4  [R0402]  317.27 74.13 180 top
R21230  *4.7K_1%_4  [R0402]  319.68 68.62 0 bottom
R21231  1M_1%_4  [R0402]  320.09 56.23 180 top
R21232  *1K_1%_4  [R0402]  322.85 60.04 180 bottom
R21233  *20K_1%_4  [R0402]  317.52 68.62 0 bottom
R21234  *1K_1%_4  [R0402]  322.85 61.05 0 bottom
R21235  *150K_1%_4  [R0402]  323.24 66.77 90 top
R21236  *4.7K_1%_4  [R0402]  307.03 80.36 90 top
R21238  *20K_1%_4  [R0402]  322.85 69.1 0 top
R21240  1K_1%_4  [R0402]  325.9 67.53 90 bottom
R21241  *20K_1%_4  [R0402]  322.22 66.77 270 top
R21242  *20K_1%_4  [R0402]  307.77 78.15 270 top
R21243  15_1%_4  [R0402]  327.68 62.07 90 bottom
R21244  *10K_1%_2  [R0201]  322.85 65.29 0 bottom
R21245  15_1%_4  [R0402]  321.43 70.5 270 top
R21246  15_1%_4  [R0402]  328.47 67.91 270 bottom
R21247  *4.7K_1%_4  [R0402]  322.85 68.14 180 top
R21248  *10K_1%_2  [R0201]  319.81 63.85 180 bottom
R21249  15_1%_4  [R0402]  322.4 70.48 270 top
R21250  15_1%_4  [R0402]  328.7 69.31 0 bottom
R21251  4.7K_1%_4  [R0402]  313.81 78.45 0 bottom
R21252  *4.7K_1%_4  [R0402]  310.87 76.7 0 bottom
R21253  1K_1%_4  [R0402]  328.82 62.07 270 bottom
R21254  *20K_1%_4  [R0402]  323.82 69.66 270 bottom
R21256  *10K_1%_2  [R0201]  317.14 67.66 0 bottom
R21258  *20K_1%_4  [R0402]  313.46 77.44 180 bottom
R21259  4.7K_1%_4  [R0402]  310.51 75.35 270 bottom
R21261  *100_1%_2  [R0201]  324.76 69.85 270 bottom
R21270  *20K_1%_4  [R0402]  327.17 65.62 270 bottom
R21271  *10K_1%_2  [R0201]  327.17 69.69 270 bottom
R21272  *1K_1%_4  [R0402]  315.36 48.99 180 bottom
R21274  4.7K_1%_4  [R0402]  316.63 75.66 0 bottom
R21276  *20K_1%_4  [R0402]  314.85 75.66 0 bottom
R21277  *4.7K_1%_4  [R0402]  328.19 65.62 90 bottom
R21279  *1K_1%_4  [R0402]  315.36 50 0 bottom
R21281  *49.9K_1%_4  [R0402]  303.42 80.43 180 bottom
R21283  10K_1%_2  [R0201]  310.1 71.24 90 bottom
R21284  10K_1%_2  [R0201]  304.79 78.25 270 bottom
R21285  *10K_1%_2  [R0201]  304.85 80.43 90 bottom
R21286  N-SUB@10K_1%_2  [R0201]  303.68 78.45 270 top
R21287  SUB@10K_1%_2  [R0201]  303.68 80.48 90 top
R21288  N-LOGO@10K_1%_2  [R0201]  304.82 78.32 270 top
R21289  LOGO@10K_1%_2  [R0201]  305.33 80.48 90 top
R21290  M_KB@10K_1%_2  [R0201]  305.99 73.93 270 bottom
R21291  P_KB@10K_1%_2  [R0201]  306.95 77.03 90 bottom
R21292  M_TP@10K_1%_2  [R0201]  300.55 79.85 180 bottom
R21293  P_TP@10K_1%_2  [R0201]  300.55 80.66 0 bottom
R21294  M_PB@10K_1%_2  [R0201]  298.47 82.36 0 top
R21295  P_PB@10K_1%_2  [R0201]  299.56 82.36 0 top
R21296  NVL@10K_1%_2  [R0201]  317.52 63.21 0 top
R21297  VL@10K_1%_2  [R0201]  319.68 63.21 0 top
R21298  Tobii@10K_1%_2  [R0201]  322.85 60.04 0 top
R21300  N-Macro@10K_1%_2  [R0201]  317.77 61.69 0 bottom
R21301  Macro@10K_1%_2  [R0201]  319.81 61.69 0 bottom
R21303  10K_1%_2  [R0201]  319.68 64.23 0 top
R21304  N-UCSI@10K_1%_2  [R0201]  305.86 78.22 270 bottom
R21305  UCSI@10K_1%_2  [R0201]  305.79 80.43 90 bottom
R21309  *10K_1%_2  [R0201]  328.06 72.1 270 bottom
R21311  10K_1%_2  [R0201]  328.06 73.14 90 bottom
R21312  *10K_1%_2  [R0201]  325.95 71.37 0 bottom
R21313  *10K_1%_2  [R0201]  319.55 67.66 180 bottom
R21316  10K_1%_2  [R0201]  319.43 65.24 90 bottom
R21317  10K_1%_2  [R0201]  314.12 49.42 180 top
R21318  *2.2K_5%_4  [R0402]  311.42 48.99 90 bottom
R21319  *2.2K_5%_4  [R0402]  313.46 48.99 90 bottom
R21324  *49.9K_1%_4  [R0402]  287.7 78.91 180 bottom
R21326  *49.9K_1%_4  [R0402]  288.03 77.56 180 bottom
R21327  *1K_1%_4  [R0402]  322.85 65.24 0 top
R21328  *1K_1%_4  [R0402]  319.68 69.69 180 bottom
R21329  *0_5%_6  [R0603]  307.36 67.91 180 bottom
R21330  *Short_0603  [S0603]  302.51 66.89 90 bottom
R21331  *Short_0603  [S0603]  306.85 65.73 270 bottom
R21332  *Short_0603  [S0603]  322.5 73.12 180 bottom
R21333  *Short_0603  [S0603]  316.12 74.39 180 bottom
R21334  *Short_0603  [S0603]  308.12 77.44 270 bottom
R21335  *Short_0603  [S0603]  299.49 77.82 270 bottom
R21336  *Short_0603  [S0603]  295.65 58.51 270 bottom
R21337  *Short_0603  [S0603]  306.73 52.95 0 bottom
R21338  *Short_0603  [S0603]  295.35 63.59 180 bottom
R21339  *Short_0603  [S0603]  299.05 62.5 90 bottom
R21340  *Short_0603  [S0603]  300.5 62.35 90 bottom
R21341  *Short_0603  [S0603]  304.41 61.69 270 bottom
R21342  *Short_0603  [S0603]  303.98 53.05 180 bottom
R21343  *Short_0603  [S0603]  313.2 61.31 90 bottom
R21344  *Short_0603  [S0603]  297.38 53.08 90 bottom
R21345  *Short_0603  [S0603]  297.61 63.82 270 bottom
R21346  *Short_0603  [S0603]  305.33 66.39 270 bottom
R21347  *Short_0603  [S0603]  286.02 76.95 180 top
R21348  *Short_0603  [S0603]  316.89 78.55 270 top
R21349  *Short_0603  [S0603]  288.44 78.43 90 top
R21350  *Short_0603  [S0603]  299.61 68.34 90 bottom
R21351  *Short_0603  [S0603]  315.36 78.58 270 top
R21352  *Short_0603  [S0603]  302.99 61.69 90 bottom
R21353  *Short_0603  [S0603]  305.3 58.51 90 bottom
R21354  *Short_0603  [S0603]  306.55 62.65 180 bottom
R21355  *Short_0402  [S0402]  300.6 57.32 270 bottom
R21356  *Short_0603  [S0603]  301.9 48.86 270 bottom
R21359  *Short_0402  [S0402]  317.77 60.67 0 bottom
R21360  30_1%_4  [R0402]  305.58 46.7 270 top
R21386  *Short_0402  [S0402]  210.59 64.63 270 bottom
R21387  240_1%_4  [R0402]  245.33 54.19 0 bottom
R21389  *10K_1%_2  [R0201]  214.4 54.58 90 bottom
R21390  *10K_1%_2  [R0201]  211.35 54.45 180 bottom
R21391  *10K_1%_2  [R0201]  232.18 53.05 90 bottom
R21392  10K_1%_2  [R0201]  213.51 54.19 90 bottom
R21393  10K_1%_2  [R0201]  212.36 54.32 90 bottom
R21394  10K_1%_2  [R0201]  233.19 53.05 90 bottom
R21395  240_1%_4  [R0402]  251.25 61.71 90 bottom
R21396  240_1%_4  [R0402]  255.21 53.92 270 bottom
R21397  240_1%_4  [R0402]  255.54 61.71 90 bottom
R21398  240_1%_4  [R0402]  252.37 61.71 90 bottom
R21399  240_1%_4  [R0402]  254.48 61.71 90 bottom
R21400  240_1%_4  [R0402]  253.49 61.71 90 bottom
R21401  240_1%_4  [R0402]  256.18 53.92 270 bottom
R21402  240_1%_4  [R0402]  256.64 61.74 90 bottom
R21403  240_1%_4  [R0402]  253.64 53.94 270 bottom
R21404  240_1%_4  [R0402]  252.6 53.94 270 bottom
R21405  1K_1%_4  [R0402]  236.88 53.28 180 bottom
R21406  2_1%_6  [R0603]  237.15 52.09 0 bottom
R21407  *0_5%_4  [R0402]  236.49 54.83 270 bottom
R21408  1K_1%_4  [R0402]  234.69 52.19 180 bottom
R21409  24.9_1%_4  [R0402]  241.32 52.09 180 bottom
R21410  *47K_1%_4  [R0402]  270.02 110.43 270 top
R21411  *47K_1%_4  [R0402]  270.71 108.35 90 top
R21412  *47K_1%_4  [R0402]  274.34 105.68 270 top
R21414  240_1%_4  [R0402]  245.08 64.63 0 bottom
R21416  *10K_1%_2  [R0201]  210.74 68.06 180 bottom
R21417  10K_1%_2  [R0201]  210.74 66.01 180 bottom
R21418  *10K_1%_2  [R0201]  232.56 66.77 270 bottom
R21419  10K_1%_2  [R0201]  210.74 69.05 0 bottom
R21420  *10K_1%_2  [R0201]  210.74 67.02 0 bottom
R21421  10K_1%_2  [R0201]  234.08 66.77 90 bottom
R21422  240_1%_4  [R0402]  256.18 66.62 270 bottom
R21423  240_1%_4  [R0402]  255.72 74.82 90 bottom
R21424  240_1%_4  [R0402]  252.37 74.82 270 bottom
R21425  240_1%_4  [R0402]  251.28 74.82 270 bottom
R21426  240_1%_4  [R0402]  255.14 66.64 270 bottom
R21427  240_1%_4  [R0402]  253.46 74.82 270 bottom
R21428  240_1%_4  [R0402]  253.61 66.62 270 bottom
R21429  240_1%_4  [R0402]  256.84 74.82 90 bottom
R21430  240_1%_4  [R0402]  252.52 66.62 270 bottom
R21431  240_1%_4  [R0402]  254.55 74.85 270 bottom
R21432  1K_1%_4  [R0402]  239.03 65.93 180 bottom
R21433  2_1%_6  [R0603]  239.14 68.34 0 bottom
R21434  *0_5%_4  [R0402]  239.03 67.05 180 bottom
R21435  1K_1%_4  [R0402]  236.06 66.29 90 bottom
R21436  24.9_1%_4  [R0402]  239.62 71.09 90 bottom
R21438  *1M_1%_4  [R0402]  44.34 49.88 90 top
R21439  *100K_1%_4  [R0402]  41.8 44.03 90 top
R21440  *0_5%_4  [R0402]  40.69 44.03 270 top
R21441  1K_1%_4  [R0402]  20.85 31.72 0 bottom
R21446  100K_1%_4  [R0402]  25.8 26 180 bottom
R21447  *Short_0402  [S0402]  15.26 14.7 270 top
R21449  *10K_1%_2  [R0201]  15.79 13.17 270 top
R21450  *10K_1%_2  [R0201]  15.08 13.17 90 top
R21453  22_1%_4  [R0402]  34.39 35.35 180 bottom
R21454  *Short_0402  [S0402]  32 35.75 270 bottom
R21456  200K_1%_4  [R0402]  34.92 27.09 270 bottom
R21457  100K_1%_4  [R0402]  33.32 29.68 270 bottom
R21458  2.2K_5%_4  [R0402]  23.74 23.49 0 top
R21459  2.2K_5%_4  [R0402]  23.57 25.67 0 top
R21462  *0_5%_4  [R0402]  27.33 32.33 180 bottom
R21465  *Short_0402  [S0402]  25.04 39.31 0 bottom
R21466  *0_5%_4  [R0402]  27.35 30.5 180 bottom
R21468  *Short_0402  [S0402]  28.98 28.41 180 bottom
R21469  *0_5%_4  [R0402]  22.73 15.76 135 top
R21470  *Short_0402  [S0402]  16.23 7.03 180 bottom
R21475  10K_1%_2  [R0201]  36.16 53.31 90 bottom
R21478  *10K_1%_2  [R0201]  36.98 53.31 270 bottom
R21481  *Short_0402  [S0402]  346.86 65.96 180 bottom
R21482  2.37K_1%_4  [R0402]  354.22 67.73 90 top
R21484  *10K_1%_2  [R0201]  345.54 73.91 0 bottom
R21486  *1K_1%_4  [R0402]  343.56 73.85 180 bottom
R21490  75_1%_8  [R0805]  366.72 67.33 180 bottom
R21491  75_1%_8  [R0805]  366.92 69.43 180 bottom
R21492  75_1%_8  [R0805]  366.92 75.15 180 bottom
R21494  *Short_0805  [S0805]  348.57 64.35 90 top
R21495  75_1%_8  [R0805]  366.92 72.1 180 bottom
R21502  10K_1%_2  [R0201]  158.64 106.9 0 top
R21503  *60.4_1%_4  [R0402]  182.65 135.73 90 bottom
R21504  *60.4_1%_4  [R0402]  182.77 125.44 180 bottom
R21505  *Short_0402  [S0402]  163.5 121.96 180 bottom
R21506  2.49K_1%_4  [R0402]  174.72 107.48 270 top
R21507  *Short_0402  [S0402]  133.37 115.03 0 top
R21508  *Short_0402  [S0402]  134.89 113.63 90 top
R21509  100K_1%_4  [R0402]  137.05 114.8 90 top
R21510  *60.4_1%_4  [R0402]  149.88 153 180 bottom
R21511  *60.4_1%_4  [R0402]  167.86 152.82 180 bottom
R21512  *60.4_1%_4  [R0402]  153.56 153 0 bottom
R21513  *60.4_1%_4  [R0402]  177.06 152.87 0 bottom
R21522  *60.4_1%_4  [R0402]  139.44 132.71 0 bottom
R21523  *60.4_1%_4  [R0402]  138.81 143.76 0 bottom
R21528  1K_1%_4  [R0402]  153.11 105.33 270 top
R21529  100K_1%_4  [R0402]  146.2 101.95 270 bottom
R21530  100K_1%_4  [R0402]  145.18 101.95 270 bottom
R21531  1K_1%_4  [R0402]  152.17 107.2 270 top
R21532  *100K_1%_4  [R0402]  150.34 108.09 0 bottom
R21533  *100K_1%_4  [R0402]  150.34 109.06 180 bottom
R21534  100K_1%_4  [R0402]  151.66 104.11 90 top
R21535  100K_1%_4  [R0402]  150.52 104.11 90 top
R21536  100K_1%_4  [R0402]  133.12 103.98 0 top
R21537  *100K_1%_4  [R0402]  126.89 95.72 90 top
R21538  *100K_1%_4  [R0402]  133.12 100.3 0 top
R21539  *100K_1%_4  [R0402]  133.12 104.99 180 top
R21540  100K_1%_4  [R0402]  127.88 95.72 270 top
R21541  100K_1%_4  [R0402]  133.12 101.31 180 top
R21542  *100K_1%_4  [R0402]  141.24 110.13 0 top
R21543  *100K_1%_4  [R0402]  143.05 104.06 90 top
R21544  *100K_1%_4  [R0402]  141.9 104.06 90 top
R21545  DIS@100K_1%_4  [R0402]  144.19 104.06 90 top
R21546  *100K_1%_4  [R0402]  145.56 99.56 180 bottom
R21547  GS@100K_1%_4  [R0402]  143.78 99.53 0 bottom
R21548  10K_1%_2  [R0201]  124.86 103.22 270 top
R21549  33_1%_2  [R0201]  125.39 101.74 0 top
R21550  33_1%_2  [R0201]  133.24 102.4 270 top
R21551  33_1%_2  [R0201]  133.09 105.96 180 top
R21552  10K_1%_2  [R0201]  125.88 103.22 90 top
R21553  100K_1%_4  [R0402]  143.02 110.13 0 top
R21554  100K_1%_4  [R0402]  143.05 106.09 90 top
R21555  100K_1%_4  [R0402]  141.9 106.09 90 top
R21556  OP@100K_1%_4  [R0402]  144.19 106.09 90 top
R21557  100K_1%_4  [R0402]  145.56 100.55 0 bottom
R21558  N-GS@100K_1%_4  [R0402]  143.78 100.55 180 bottom
R21559  10K_1%_2  [R0201]  128.93 95.72 90 top
R21560  10K_1%_2  [R0201]  137.05 116.55 90 top
R21561  10K_1%_2  [R0201]  139.49 112.82 180 top
R21562  10K_1%_2  [R0201]  131.72 119.85 0 bottom
R21563  100K_1%_4  [R0402]  133.88 118.84 0 top
R21564  100K_1%_4  [R0402]  142.44 102.4 180 top
R21565  100K_1%_4  [R0402]  131.21 116.17 90 bottom
R21566  100K_1%_4  [R0402]  133.88 119.85 0 top
R21567  100K_1%_4  [R0402]  132.23 116.17 90 bottom
R21568  100K_1%_4  [R0402]  138.42 110.13 180 top
R21569  2K_1%_4  [R0402]  148.61 101.95 90 bottom
R21570  2K_1%_4  [R0402]  150.9 101.95 90 bottom
R21571  2K_1%_4  [R0402]  150.26 106.01 270 bottom
R21572  2K_1%_4  [R0402]  151.28 106.01 270 bottom
R21573  10K_1%_2  [R0201]  130.2 115.66 0 top
R21574  *Short_0402  [S0402]  135.4 119.22 270 top
R21575  *100K_1%_4  [R0402]  136.67 117.26 0 bottom
R21576  10K_1%_2  [R0201]  139.21 118.33 0 bottom
R21577  100K_1%_4  [R0402]  139.09 118.41 180 top
R21578  *100K_1%_4  [R0402]  132.61 112.23 180 bottom
R21579  *100K_1%_4  [R0402]  139.09 119.4 180 top
R21580  *0_5%_4  [R0402]  138.07 114.8 90 top
R21581  100K_1%_4  [R0402]  139.31 119.68 180 bottom
R21582  *0_5%_4  [R0402]  134.89 115.15 0 bottom
R21583  *10K_1%_2  [R0201]  154.1 107.08 90 top
R21584  *10K_1%_2  [R0201]  153.13 107.08 90 top
R21585  10K_1%_2  [R0201]  155.06 107.08 90 top
R21586  *10K_1%_2  [R0201]  156.36 107.43 90 top
R21587  10K_1%_2  [R0201]  128.8 115.92 90 top
R21588  10K_1%_2  [R0201]  139.09 117.44 0 top
R21589  10K_1%_2  [R0201]  139.09 116.17 0 top
R21590  10K_1%_2  [R0201]  137.56 113.45 0 top
R21591  10K_1%_2  [R0201]  136.42 119.09 270 top
R21592  10K_1%_2  [R0201]  135.02 111.98 0 bottom
R21593  100K_1%_4  [R0402]  126.13 116.3 0 top
R21594  10K_1%_2  [R0201]  139.09 114.9 90 top
R21595  10K_1%_2  [R0201]  135.66 113.5 0 bottom
R21596  10K_1%_2  [R0201]  135.4 121.25 180 bottom
R21597  10K_1%_2  [R0201]  138.7 116.17 0 bottom
R21598  10K_1%_2  [R0201]  139.09 120.36 0 top
R21599  2K_1%_4  [R0402]  147.47 101.95 90 bottom
R21600  2K_1%_4  [R0402]  149.88 101.95 90 bottom
R21601  10K_1%_2  [R0201]  134.13 110.58 270 top
R21602  *10K_1%_2  [R0201]  135.91 113.63 90 top
R21603  *Short_0402  [S0402]  135.91 110.2 180 top
R21604  40.2_1%_4  [R0402]  183.03 138.35 270 bottom
R21605  40.2_1%_4  [R0402]  181.88 140.25 270 bottom
R21606  60.4_1%_4  [R0402]  181.86 138.35 270 bottom
R21608  *10K_1%_2  [R0201]  127.66 116.3 180 top
R21609  10K_1%_2  [R0201]  157.32 107.43 270 top
R21610  *10K_1%_2  [R0201]  124.48 118.84 90 bottom
R21611  1K_1%_4  [R0402]  117.75 120.11 0 bottom
R21612  *1.21K_1%_4  [R0402]  115.72 120.11 180 bottom
R21613  60@100K_1%_4  [R0402]  119.78 120.11 180 bottom
R21614  *60@12.1K_1%_4  [R0402]  126.39 111.6 90 top
R21615  *60@0_5%_4  [R0402]  125.37 111.6 270 top
R21616  10K_1%_2  [R0201]  122.83 117.57 180 bottom
R21617  10K_1%_2  [R0201]  120.8 111.34 180 bottom
R21618  10K_1%_2  [R0201]  122.83 111.98 90 bottom
R21619  10K_1%_2  [R0201]  146.2 110.07 0 top
R21620  10K_1%_2  [R0201]  149.37 105.88 270 bottom
R21673  *Short_0402  [S0402]  21.23 39.21 0 top
R21674  *Short_0402  [S0402]  21.23 40.22 0 top
R21675  *Short_0402  [S0402]  21.36 37.94 0 top
R21676  *Short_0402  [S0402]  21.36 36.92 0 top
R21677  *Short_0402  [S0402]  21.36 42.51 0 top
R21678  *Short_0402  [S0402]  21.36 41.49 0 top
R21679  *4.99K_1%_4  [R0402]  27.22 45.53 270 bottom
R21680  *Short_0402  [S0402]  21.36 48.23 0 top
R21681  *Short_0402  [S0402]  21.36 49.24 0 top
R21682  *Short_0402  [S0402]  21.36 47.08 0 top
R21683  *Short_0402  [S0402]  21.36 46.07 0 top
R21684  *Short_0402  [S0402]  21.36 51.4 0 top
R21685  *4.7K_1%_4  [R0402]  26.66 48.4 180 bottom
R21686  *0_5%_4  [R0402]  29.41 45.64 90 bottom
R21687  *0_5%_4  [R0402]  28.37 45.64 90 bottom
R21688  *Short_0402  [S0402]  21.36 50.38 0 top
R21689  *0_5%_4  [R0402]  29.36 53.94 90 top
R21690  *0_5%_4  [R0402]  28.21 53.94 90 top
R21691  *0_5%_4  [R0402]  26.87 43.68 270 top
R21692  *0_5%_4  [R0402]  25.78 43.68 270 top
R21693  *0_5%_4  [R0402]  27.07 53.94 90 top
R21694  *0_5%_4  [R0402]  25.93 53.94 90 top
R21695  *4.7K_1%_4  [R0402]  26.31 49.88 270 bottom
R21696  *Short_0402  [S0402]  28.08 75.4 0 top
R21697  *Short_0402  [S0402]  366.42 59.91 180 top
R21698  *Short_0402  [S0402]  28.08 74.39 0 top
R21699  *Short_0402  [S0402]  366.42 58.89 180 top
R21700  *Short_0402  [S0402]  366.42 60.95 180 top
R21701  *Short_0402  [S0402]  366.42 61.94 180 top
R21702  20K_1%_4  [R0402]  362.22 54.32 0 top
R21703  39K_1%_4  [R0402]  364 54.32 0 top
R21704  *Short_0402  [S0402]  366.42 56.86 180 top
R21705  100K_1%_4  [R0402]  363.11 49.24 270 bottom
R21706  *Short_0402  [S0402]  366.42 57.85 180 top
R21707  10K_1%_2  [R0201]  364.13 49.24 270 bottom
R21708  10K_1%_2  [R0201]  365.15 49.24 270 bottom
R21709  4.7K_1%_4  [R0402]  62.38 52.67 180 top
R21710  *4.7K_1%_4  [R0402]  60.09 52.67 180 top
R21713  *Short_0402  [S0402]  52.85 60.29 90 bottom
R21714  Debug@0_5%_4  [R0402]  54.4 58.89 0 bottom
R21715  Debug@0_5%_4  [R0402]  52.85 56.89 0 bottom
R21716  Debug@0_5%_4  [R0402]  45.92 51.93 90 top
R21717  Debug@0_5%_4  [R0402]  51.3 51.86 270 top
R21718  Debug@0_5%_4  [R0402]  60.4 54.75 90 bottom
R21719  Debug@0_5%_4  [R0402]  60.37 56.61 270 bottom
R21720  *Short_0805  [S0805]  49.3 53.92 0 top
R21725  *Short_0805  [S0805]  59.9 26.48 0 top
R21726  *Short_0402  [S0402]  59.35 22.98 90 top
R21728  *Short_0402  [S0402]  61.87 23.71 90 top
R21729  *Short_0402  [S0402]  62.89 23.71 90 top
R21730  *Short_0402  [S0402]  58.34 22.98 90 top
R21731  *Short_0402  [S0402]  65.43 23.71 90 top
R21732  *Short_0402  [S0402]  66.44 23.71 90 top
R21733  *Short_0402  [S0402]  71.95 23.41 180 bottom
R21734  *10K_1%_2  [R0201]  71.95 22.29 180 bottom
R21735  SSD@0_5%_2  [R0201]  69.84 26.15 180 top
R21736  SSD@0_5%_2  [R0201]  69.84 26.97 180 top
R21737  *Short_0402  [S0402]  73.5 23.05 270 bottom
R21738  4.7K_1%_4  [R0402]  68.96 22.57 270 bottom
R21739  *0_5%_4  [R0402]  67.84 22.57 270 bottom
R21740  4.7K_1%_4  [R0402]  61.74 39.64 270 top
R21741  *4.7K_1%_4  [R0402]  65.96 35.17 180 top
R21742  *4.7K_1%_4  [R0402]  66.19 35.09 0 bottom
R21743  *4.7K_1%_4  [R0402]  64.33 39.23 270 top
R21744  *4.7K_1%_4  [R0402]  65.4 39.23 90 top
R21745  *4.7K_1%_4  [R0402]  60.52 29.07 90 top
R21746  4.7K_1%_4  [R0402]  60.52 29.07 270 bottom
R21747  *Short_0402  [S0402]  57.07 39.01 180 bottom
R21748  *SATA@4.7K_1%_4  [R0402]  58.67 29.56 90 top
R21749  *PCIE@4.7K_1%_4  [R0402]  59.05 29.18 0 bottom
R21750  *4.7K_1%_4  [R0402]  55.34 32.96 0 top
R21751  *4.7K_1%_4  [R0402]  55.34 32.96 180 bottom
R21752  *4.7K_1%_4  [R0402]  65.96 31.1 180 top
R21753  *4.7K_1%_4  [R0402]  66.19 31.03 0 bottom
R21754  *4.7K_1%_4  [R0402]  65.96 33.13 180 top
R21755  4.7K_1%_4  [R0402]  66.19 33.06 0 bottom
R21769  *Short_0402  [S0402]  67.28 46.93 180 bottom
R21788  *Short_0402  [S0402]  30.37 23.08 90 top
