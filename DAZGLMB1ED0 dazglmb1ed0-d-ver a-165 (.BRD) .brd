# Allegro board DAZGLMB1ED0 dazglmb1ed0-d-ver a-165 (.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCIE_TXP2_TBT_C: length 5.6
  TOP w0.081: U13113.A23 291.69,63.47 291.62,63.4 288.81,63.4 288.76,63.45 288.74,63.45
  TOP w0.14: 288.74,63.45 288.31,63.45 288.17,63.59 287.62,63.59 287.33,63.89 287.05,63.89 286.71,64.23 C94803.2
PCIE_TXP3_TBT: length 103.6
  TOP w0.079: U21.M23 349.97,48.03 349.97,46.77 349.26,46.07 v1(349.24,46.07)
  TOP w0.14: C95877.1 283.85,66.38 283.85,67.44 283.65,67.64 280.93,67.64 280.19,66.91 280.19,59.7 280.72,59.17 280.72,56.17 280.05,55.5 280.05,54.97 279.61,54.53 279.61,52.28 282.42,49.47 286.17,49.47 289.51,46.13 290.74,46.13 290.99,46.38 292.02,46.38 292.47,45.93 292.47,45.84 292.7,45.61 v1(292.79,45.61)
  IN4 w0.089: v1(292.79,45.61) 292.7,45.61 292.53,45.79 292.53,46.09 293.81,47.37 299.71,47.37 300.52,48.19 303.09,48.19 303.24,48.33 313.09,48.33 313.47,47.95 313.47,47.42 314,46.89 318.34,46.89 318.89,47.44 320.26,47.44 321,48.18 322.53,48.18 323.68,49.34 324.97,49.34 325.46,49.84 327.99,49.84 328.54,50.38 338.46,50.38 339.76,49.08 345.65,49.08 346.63,48.1 347.38,48.1 347.8,47.68 347.8,47.05 348.29,46.56 348.95,46.56 349.24,46.26 v1(349.24,46.07)
PCIE_TXP3_TBT_C: length 8.1
  TOP w0.081: 288.55,64.06 288.64,63.97 288.79,63.97 288.95,63.82 292.31,63.82 292.35,63.78 292.35,63.74 U13113.B23
  TOP w0.14: C95877.2 285.51,65.48 285.57,65.53 285.73,65.53 285.86,65.66 286.32,65.66 287.84,64.14 288.48,64.14 288.55,64.06
PCIE_TXP3_WLAN: length 251.7
  TOP w0.14: C94797.1 284.94,60.49 284.33,60.49 283.31,59.47 283.31,55.64 283.03,55.36 v1(282.75,55.36) ; CN2068.35 59.05,65.75 v1(58.54,65.24)
  IN5 w0.089: v1(58.54,65.24) 58.78,65.49 58.78,65.65 59,65.87 59.7,65.87 60.19,65.38 60.19,60.67 61.15,59.71 61.15,58.1 62.27,56.99 62.27,54.97 66.4,50.84 67.12,50.84 68.52,49.44 72.68,49.44 73.62,48.5 83.59,48.5 84.38,49.29 89.66,49.29 91.07,50.7 92.2,50.7 94.01,52.51 126.43,52.51 126.91,52.99 154.88,52.99 155.27,52.59 174,52.59 176.38,54.98 177.41,54.98 178.29,55.86 191.4,55.86 191.87,56.33 193.03,56.33 193.61,56.91 197.38,56.91 197.9,56.39 198.33,56.39 198.57,56.15 199,56.15 199.22,55.94 203.49,55.94 204.96,54.47 205.68,54.47 206.62,55.41 207.33,55.41 208.27,54.47 255.48,54.47 255.56,54.55 263.12,54.55 263.72,55.14 270.79,55.14 271.11,54.82 280.1,54.82 280.4,55.12 282.51,55.12 v1(282.75,55.36)
PCIE_TXP3_WLAN_C: length 7.9
  TOP w0.081: 289.67,61.82 289.67,61.82 289.77,61.82 290.01,62.07 291.94,62.07 291.98,62.1 292.42,62.1 U13113.C20
  TOP w0.14: C94797.2 286.33,60.6 286.42,60.5 288.35,60.5 289.67,61.82
PCIE_TXP4_LAN: length 70.3
  TOP w0.14: v1(285.31,61.21) 285.72,61.61 286.56,61.61 C94799.1 ; U13143.35 346.93,71.54 v1(346.86,71.47)
  IN5 w0.089: v1(285.31,61.21) 285.53,61.42 285.53,61.55 285.71,61.73 291.91,61.73 293.19,63.01 298.52,63.01 298.84,62.69 302.26,62.69 302.65,63.08 312.34,63.08 313.56,64.3 315.71,64.3 316.19,63.82 317.29,63.82 317.65,63.47 320.06,63.47 320.42,63.82 321.96,63.82 323.22,65.08 330.67,65.08 331.92,66.34 332.53,66.34 333.33,67.14 333.33,68 334,68.67 335.24,68.67 336.66,70.09 341.18,70.09 343.04,71.95 346.37,71.95 v1(346.86,71.47)
PCIE_TXP4_LAN_C: length 5.7
  TOP w0.081: 289.16,62.33 289.3,62.33 289.39,62.42 291.66,62.42 291.69,62.45 U13113.A21
  TOP w0.14: 289.16,62.33 288.04,61.22 287.45,61.22 287.31,61.36 287.07,61.36 286.99,61.44 286.99,61.59 C94799.2
PCIE_TXP4_TBT: length 111.7
  TOP w0.079: v1(351.2,47.01) 351.15,46.96 351.15,46.75 351.21,46.69 351.5,46.69 352.08,47.28 352.08,47.73 351.95,47.86 351.95,48.04 U21.H23
  TOP w0.14: v1(300.59,45.62) 300.84,45.62 300.98,45.47 300.98,45.38 301.12,45.24 301.12,45.14 301.03,45.04 289.33,45.04 285.92,48.45 282.16,48.45 278.82,51.79 278.82,56.29 277.95,57.17 277.95,58.36 278.85,59.27 278.85,61.04 279.05,61.25 279.05,67.67 280.04,68.66 283.75,68.66 284.96,67.45 287.15,67.45 287.45,67.15 287.45,66.82 287.37,66.74 C95878.1
  IN4 w0.089: v1(351.2,47.01) 351.33,47.01 351.4,46.94 351.4,46.81 351.04,46.46 351.04,46.15 349.87,44.97 341.4,44.97 337.94,48.43 330.33,48.43 329.49,47.59 325.12,47.59 322.09,44.56 310.88,44.56 309.18,46.26 301.37,46.26 301.12,46.01 301.12,45.84 301.02,45.74 301.02,45.57 300.96,45.51 300.7,45.51 v1(300.59,45.62)
PCIE_TXP4_TBT_C: length 6.5
  TOP w0.081: 289.16,64.6 289.17,64.59 289.24,64.59 289.56,64.27 291.71,64.27 291.82,64.38 292.19,64.38 292.27,64.29 292.27,64.23 292.22,64.18 U13113.B24
  TOP w0.14: 289.16,64.6 288.74,65.02 288.09,65.02 287.24,65.86 287.24,66.09 C95878.2
PCIE_WAKE#: length 355.3
  TOP w0.102: v1(316.63,58.06) 314.21,58.06 314.01,58.26 313.17,58.26 313.02,58.16 312.65,58.16 U13113.BC13
  TOP w0.14: R21126.2 317.71,57.71 317.37,58.06 v1(316.63,58.06) ; Q7886.1 338.77,61 339.05,61.28 v1(339.37,61.28) 339.84,60.81 R22029.1 ; v1(341.9,74.64) 342.03,74.64 342.56,75.18 343.38,75.18 343.44,75.24 Q7849.3 ; Q7891.3 49.4,51.34 49.01,50.95 v1(49.01,50.67) ; v1(60.09,49.47) Q7889.3 61.71,50.22 63.32,48.6 63.32,46.58 62.95,46.21 62.95,45.47 63.34,45.08 65.25,45.08 65.53,45.36 66.7,45.36 67.81,46.47 67.81,50.55 68.58,51.32 69.9,51.32 71.67,53.1 77.19,53.1 77.71,52.57 89.22,52.57 90.85,50.94 90.85,48.91 91.41,48.35 91.41,45.71 v1(92.2,44.92)
  IN1 w0.089: v1(316.63,58.06) 316.63,57.62 315.83,56.82 315.83,53.81 314.97,52.95 314.97,51.82 313.96,50.8 313.46,50.8 310.98,48.33 310.85,48.33 310.54,48.01 310.54,47.72 310.06,47.24 293.67,47.24 291.92,48.99 289.18,48.99 288.59,49.58 266.5,49.58 265.06,48.14 256.59,48.14 255.93,47.48 245.94,47.48 245.14,48.28 232.61,48.28 231.77,47.44 203.91,47.44 203.07,48.28 196.39,48.28 194.01,50.66 178.94,50.66 178.61,50.33 176.74,50.33 174.49,48.09 100.03,48.09 97.66,45.72 92.99,45.72 v1(92.2,44.92)
  IN2 w0.089: v1(339.37,61.28) 338.58,61.28 336.31,63.55 336.31,65.44 337.51,66.64 v1(337.51,66.87) 337.51,68.38 338.21,69.08 338.21,72.6 340.25,74.64 v1(341.9,74.64)
  IN5 w0.089: v1(337.51,66.87) 337.1,66.46 337.1,66.03 334.29,63.22 332.14,63.22 330.34,61.41 327.34,61.41 325.51,59.58 322.9,59.58 322.05,58.72 321.54,58.72 321.23,58.41 320.29,58.41 319.81,58.89 317.47,58.89 v1(316.63,58.06)
  BOTTOM w0.14: R22096.1 342.52,75.26 v1(341.9,74.64) ; v1(60.09,49.47) 60.07,49.45 58.64,49.45 57.04,51.05 52.37,51.05 51.96,51.45 49.25,51.45 49.01,51.22 v1(49.01,50.67)
PCIE_WAKE#_TBT: length 13.9
  TOP w0.079: U21.W1 346.83,58.85 v1(346.8,58.87)
  TOP w0.14: Q7886.3 339.36,60.29 339.63,60.03 R22029.2 340.13,59.9 340.13,59.02 R22031.2 339.9,59 v1(339.29,59)
  IN4 w0.089: v1(346.8,58.87) 346.46,58.87 345.51,57.93 342.11,57.93 340.76,59.27 339.57,59.27 v1(339.29,59)
PCIECOMP_N: length 2.8
  TOP w0.127: v1(290.52,60.16) 291.1,60.75 291.45,60.75 291.61,60.91 U13113.B18
  BOTTOM w0.254: R21076.2 290.17,60.52 v1(290.52,60.16)
PCIECOMP_P: length 2.8
  TOP w0.127: U13113.C17 292.55,60.81 292.32,60.57 291.63,60.57 291.19,60.13 v1(291.19,60.1)
  BOTTOM w0.254: v1(291.19,60.1) 291.19,60.31 290.62,60.88 R21076.1
PD#: length 38.2
  TOP w0.14: D8587.2 D8586.2 36.77,53.43 36.98,53.64 v1(36.98,54.07) ; U13108.2 33.39,29.66 33.68,29.38 34.16,29.38 34.24,29.3 C94966.1 34.82,29.3 35.04,29.51 35.56,29.51 v1(36.32,30.27)
  IN3 w0.079: v1(36.98,54.07) 37.51,54.07 38.58,53 38.58,52.01 40.1,50.49 40.1,47.84 38.67,46.41 38.67,44.43 39.42,43.68 39.42,40 39.2,39.78 39.2,38.28 38.89,37.97 38.89,35.66 38.58,35.35 38.37,35.35 38.12,35.09 38.12,34.28 38.27,34.13 38.27,33.52 37.96,33.2 37.96,32.51 37.96,30.74 37.49,30.27 v1(36.32,30.27)
  BOTTOM w0.14: v1(37.89,53.74) 37.56,54.07 v1(36.98,54.07) R21478.1 R21475.2
PEG_COMP: length 9.3
  TOP w0.127: U41.G2 229.28,104.98 v1(229.28,99.54) 229.28,98.76 228.15,97.63 228.01,97.63 v1(227.68,97.3)
  BOTTOM w0.127: v1(227.68,97.3) 227.53,97.45 R194.2
PEG_RXN0: length 98
  TOP w0.14: U41.E10 227.86,110.11 227.99,109.98 228.09,109.98 228.18,110.08 v1(228.18,110.69)
  BOTTOM w0.104: 226.47,106.77 226.47,106.79 226.49,106.8 226.49,107 226.26,107.23 226.26,109.55 226.7,110 228.23,110 228.47,110.24 228.47,110.52 228.29,110.69 v1(228.18,110.69)
  BOTTOM w0.14: C95018.2 155.25,107.91 155.25,107.21 155.99,106.48 155.99,106 157.39,104.6 157.39,103.33 158.02,102.69 158.02,102.19 167.03,93.18 168.77,93.18 172.98,88.98 193.13,88.98 196.09,91.93 198.18,91.93 201.03,94.77 205.42,94.77 205.76,94.43 209.24,94.43 210.18,95.37 216.3,95.37 v1(216.83,95.9) 217.37,95.37 217.6,95.37 226.45,104.22 226.45,105.88 226.47,105.91 226.47,106.77
PEG_RXN0_C: length 11.2
  TOP w0.14: v2(160.41,115.96) 160.64,115.96 160.76,116.08 U13114.BH26
  BOTTOM w0.102: 159.96,115.61 159.94,115.64 159.94,116.06 160.18,116.3 160.29,116.3 160.41,116.18 v2(160.41,115.96)
  BOTTOM w0.14: 159.96,115.61 159.96,115.15 158.54,113.73 158.54,111.88 155.98,109.31 155.47,109.31 155.3,109.14 155.3,108.9 C95018.1
PEG_RXN1: length 95.3
  TOP w0.14: v1(227.53,110.69) 227.53,110.76 U41.E11
  BOTTOM w0.102: 225.72,106.26 225.7,106.29 225.7,106.35 225.74,106.39
  BOTTOM w0.104: v1(227.53,110.69) 227.42,110.69 227.3,110.81 227.3,111.14 227.09,111.35 226,111.35 225.59,110.95 225.59,109.89 225.74,109.74 225.74,106.39
  BOTTOM w0.14: C95019.2 156.95,108.08 156.95,106.06 158.15,104.86 158.15,103.72 158.77,103.1 158.77,102.44 167.33,93.89 169.07,93.89 173.27,89.69 192.84,89.69 198.69,95.54 206.34,95.54 206.66,95.22 208.73,95.22 209.6,96.08 212.8,96.08 213.76,97.04 214.55,97.04 v1(215.13,97.63) 215.64,97.12 218.08,97.12 225.7,104.74 225.7,105.88 225.72,105.91 225.72,106.26
PEG_RXN1_C: length 11.8
  TOP w0.14: U13114.BE26 160.41,118.06 v2(160.41,118.06)
  BOTTOM w0.102: 160.33,114.2 160.35,114.22 160.35,114.27 160.38,114.3 160.99,114.91 160.99,117.62 160.74,117.87 160.6,117.87 v2(160.41,118.06)
  BOTTOM w0.14: C95019.1 156.99,108.98 156.99,109.27 159.35,111.63 159.35,113.23 160.33,114.2
PEG_RXN2: length 94.1
  TOP w0.14: v1(228.18,112.27) 228.18,111.77 228.1,111.69 227.93,111.69 227.86,111.77 U41.E12
  BOTTOM w0.102: 224.84,106.14 224.84,106.15 224.87,106.18 224.87,106.32
  BOTTOM w0.104: v1(228.18,112.27) 228.36,112.27 228.43,112.19 228.43,111.91 228.33,111.8 225.87,111.8 225.14,111.07 225.14,107.14 224.87,106.87 224.87,106.32
  BOTTOM w0.14: C95010.2 158.35,106.93 158.25,106.83 158.25,105.97 159.56,104.65 159.56,102.66 167.62,94.6 169.36,94.6 173.57,90.4 192.55,90.4 199.17,97.02 205.86,97.02 206.92,95.97 208.36,95.97 209.24,96.84 212.37,96.84 214.07,98.54 216.15,98.54 v1(216.76,99.15) 217.24,98.67 218.36,98.67 223.11,103.42 223.11,104.06 224.11,105.06 224.84,105.78 224.84,106.14
PEG_RXN2_C: length 12.3
  TOP w0.14: v2(161.81,116.66) 161.58,116.66 161.46,116.78 U13114.BG27
  BOTTOM w0.104: 161.44,114.52 161.52,114.6 161.52,115.92 161.4,116.04 161.4,116.87 161.53,117.01 161.67,117.01 161.81,116.87 v2(161.81,116.66)
  BOTTOM w0.14: 161.44,114.52 161.31,114.39 161.31,113.53 160.24,112.46 160.24,111.42 158.33,109.5 158.33,107.65 C95010.1
PEG_RXN3: length 93
  TOP w0.14: v1(227.53,112.27) 227.53,112.33 U41.E13
  BOTTOM w0.104: v1(227.53,112.27) 227.27,112.53 227.27,112.66 227.01,112.92 225.71,112.92 225.53,112.74 223.92,112.74
  BOTTOM w0.14: 223.92,112.74 223.59,112.74 222.46,111.61 222.46,109.33 222.53,109.25 222.53,109.15 222.74,108.95 222.74,108.69 222.93,108.5 222.93,108.07 223.03,107.97 223.03,107.54 223.93,106.64 223.93,105.89 222.4,104.36 222.4,104.01 218.39,99.99 215.82,99.99 v1(215.26,100.55) 214.7,99.99 214.43,99.99 212.04,97.6 208.88,97.6 207.96,96.68 207.42,96.68 206.09,98.01 205.45,98.01 204.97,98.49 203,98.49 202.39,97.88 199.02,97.88 192.25,91.11 173.86,91.11 169.66,95.31 167.91,95.31 160.29,102.93 160.29,104.93 159.63,105.59 159.63,105.68 C95027.1
PEG_RXN3_C: length 12.3
  TOP w0.14: U13114.BH29 162.86,116.14 162.68,115.96 v2(162.51,115.96)
  BOTTOM w0.104: v2(162.51,115.96) 162.51,116.17 162.38,116.3 162.3,116.3 162.06,116.06 162.06,114.56 162.07,114.54 162.07,114.52
  BOTTOM w0.14: 162.07,114.52 162.07,112.92 160.95,111.8 160.95,111.11 159.54,109.7 159.54,106.68 C95027.2
PEG_RXN4: length 91.5
  TOP w0.14: v1(228.18,113.84) 228.18,113.42 228.11,113.34 227.96,113.34 U41.E14
  BOTTOM w0.104: v1(228.18,113.84) 228.38,113.84 228.43,113.8 228.43,113.53 228.3,113.41 225.87,113.41 225.44,113.84 224.22,113.84 223.99,113.61 223.92,113.61
  BOTTOM w0.14: C95029.1 161.09,109.21 160.89,109.02 160.89,108.26 160.78,108.15 160.78,107.24 161.67,106.36 161.67,103.78 162.07,103.37 162.07,102.17 168.21,96.02 169.95,96.02 174.15,91.82 191.96,91.82 198.73,98.59 200.72,98.59 207.24,105.11 208.77,105.11 v1(209.34,105.68) 209.91,105.12 211.65,105.12 212.63,106.09 212.63,108.37 212.91,108.66 212.91,109.37 215.77,112.23 221.48,112.23 222.85,113.61 223.92,113.61
PEG_RXN4_C: length 11.1
  TOP w0.14: v2(162.51,118.76) U13114.BE29
  BOTTOM w0.102: v2(162.51,118.76) 162.69,118.58 162.96,118.58 163.27,118.28 163.27,117.63 163.1,117.46 163.1,115.18 163.1,115.18 163.1,114.91 162.83,114.65 162.83,114.37 162.87,114.34 162.87,114.32
  BOTTOM w0.14: C95029.2 161.06,109.87 161.06,110.2 161.67,110.81 161.67,111.37 162.87,112.57 162.87,114.32
PEG_RXN5: length 85.8
  TOP w0.14: U41.E15 227.53,113.91 v1(227.53,113.84)
  BOTTOM w0.102: 223.92,114.43 223.93,114.43 223.97,114.4 224.3,114.4 224.37,114.33 224.58,114.33 224.58,114.33 224.61,114.33
  BOTTOM w0.104: 224.61,114.33 225.46,114.33 225.63,114.5 227.09,114.5 227.26,114.33 227.26,114 227.42,113.84 v1(227.53,113.84)
  BOTTOM w0.14: C95031.1 161.96,107.37 161.96,107.11 162.39,106.68 162.39,104.06 162.78,103.67 162.78,102.46 168.5,96.73 170.25,96.73 174.45,92.53 191.66,92.53 198.44,99.31 200.43,99.31 207.31,106.19 208.72,106.19 209.08,106.54 210.8,106.54 210.99,106.74 211.34,106.74 211.91,107.31 211.91,109.38 215.48,112.95 220.45,112.95 221.93,114.43 223.92,114.43
PEG_RXN5_C: length 11.1
  TOP w0.14: U13114.BG30 163.56,116.82 163.72,116.66 v2(163.91,116.66)
  BOTTOM w0.104: v2(163.91,116.66) 163.91,116.92 163.85,116.98 163.63,116.98 163.51,116.86 163.51,114.96 163.55,114.92
  BOTTOM w0.14: C95031.2 162.15,108.03 161.9,108.28 161.9,108.51 162.47,109.07 162.47,109.43 162.88,109.85 162.88,110.74 163.66,111.51 163.66,114.8 163.55,114.92
PEG_RXN6: length 85.2
  TOP w0.14: v1(228.18,115.42) 228.18,114.91 228.11,114.83 227.98,114.83 227.86,114.96 U41.E16
  BOTTOM w0.102: 225.44,115.39 223.98,115.39 223.95,115.42 223.92,115.42
  BOTTOM w0.104: 225.44,115.39 225.85,114.98 228.31,114.98 228.44,115.11 228.44,115.31 228.33,115.42 v1(228.18,115.42)
  BOTTOM w0.14: 223.92,115.42 221.77,115.42 220.03,113.68 215.2,113.68 208.43,106.9 206.85,106.9 199.97,100.02 198.01,100.02 191.24,93.24 174.74,93.24 170.54,97.44 168.8,97.44 163.6,102.65 163.6,106.9 163.28,107.22 163.28,107.61 163.49,107.82 C95034.1
PEG_RXN6_C: length 9.8
  TOP w0.14: v2(164.61,115.96) 164.81,115.96 164.96,116.11 U13114.BH32
  BOTTOM w0.104: v2(164.61,115.96) 164.61,116.2 164.52,116.29 164.37,116.29 164.18,116.1 164.18,115.04 164.23,115
  BOTTOM w0.14: C95034.2 163.42,108.52 163.42,109.14 163.6,109.31 163.6,110.43 164.37,111.21 164.37,114.86 164.23,115
PEG_RXN7: length 84.6
  TOP w0.14: v1(227.53,115.42) 227.53,115.48 U41.E17
  BOTTOM w0.104: 224.11,116.09 224.13,116.07 224.13,116.01 224.27,115.87 225.36,115.87 225.61,116.12 226.99,116.12 227.28,115.83 227.28,115.51 227.37,115.42 v1(227.53,115.42)
  BOTTOM w0.14: 224.11,116.09 224.01,116.19 223.65,116.19 223.41,116.42 221.76,116.42 219.73,114.39 214.91,114.39 208.13,107.61 206.56,107.61 200.42,101.48 198.47,101.48 190.95,93.95 175.04,93.95 170.84,98.16 169.09,98.16 164.81,102.44 164.81,107.06 164.43,107.43 164.43,108.7 164.71,108.98 164.71,109.49 C95036.1
PEG_RXN7_C: length 9.8
  TOP w0.14: v2(164.61,118.76) U13114.BE32
  BOTTOM w0.102: 165.09,114.14 165.06,114.17 165.06,114.71 165.2,114.85 165.2,118.36 164.96,118.59 164.78,118.59 v2(164.61,118.76)
  BOTTOM w0.14: C95036.2 164.69,110.43 164.69,110.51 165.09,110.91 165.09,114.14
PEG_RXN8: length 81.8
  TOP w0.14: U41.F18 228.18,116.27 v1(228.18,116.21)
  BOTTOM w0.104: v1(228.18,116.21) 227.95,116.44 227.95,116.61 227.69,116.86 225.46,116.86 225.26,117.06 223.92,117.06 223.92,117.06
  BOTTOM w0.14: C95038.1 165.58,107.94 165.34,107.7 165.34,107.53 165.52,107.35 165.52,106.52 166.14,105.91 166.14,102.12 169.39,98.87 171.13,98.87 175.33,94.67 190.65,94.67 198.17,102.19 200.13,102.19 206.26,108.32 207.8,108.32 214.59,115.12 219.44,115.12 221.46,117.14 223.71,117.14 223.79,117.06 223.92,117.06
PEG_RXN8_C: length 10.1
  TOP w0.14: U13114.BG33 165.66,116.83 165.82,116.66 v2(166.01,116.66)
  BOTTOM w0.104: 165.84,114.52 165.84,114.69 165.61,114.92 165.61,116.86 165.75,117 165.89,117 166.01,116.88 v2(166.01,116.66)
  BOTTOM w0.14: 165.84,114.52 165.84,109.4 165.46,109.02 165.46,108.64 C95038.2
PEG_RXN9: length 78.7
  TOP w0.14: U41.D19 227.21,117.27 227.08,117.14 226.94,117.14 226.88,117.2 v1(226.88,117.78)
  BOTTOM w0.104: v1(226.88,117.78) 227.01,117.78 227.15,117.64 227.15,117.46 227.01,117.32 225.92,117.32 225.77,117.47 224.27,117.47 223.51,118.23 223.19,118.23
  BOTTOM w0.14: C95040.1 166.53,106.61 166.53,106.52 166.85,106.2 166.85,103.83 170.26,100.42 170.58,100.42 175.63,95.38 190.36,95.38 197.88,102.9 199.83,102.9 205.97,109.03 207.5,109.03 214.31,115.84 219.15,115.84 221.53,118.23 223.19,118.23
PEG_RXN9_C: length 10.4
  TOP w0.14: U13114.BH35 167.06,116.08 166.94,115.96 v2(166.71,115.96)
  BOTTOM w0.104: v2(166.71,115.96) 166.71,116.18 166.59,116.3 166.48,116.3 166.26,116.08 166.26,115.03 166.55,114.75 166.55,114.63 166.56,114.61 166.56,114.58 166.61,114.53 166.61,114.52
  BOTTOM w0.14: C95040.2 166.61,107.62 166.61,114.52
PEG_RXN10: length 80.3
  TOP w0.14: U41.F20 228.83,117.85 v1(228.83,117.78)
  BOTTOM w0.102: 223.16,118.96 223.18,118.96 223.22,118.93 223.95,118.93 224.32,118.56 224.81,118.56
  BOTTOM w0.104: 224.81,118.56 224.93,118.56 225.08,118.42 228.32,118.42 228.57,118.16 228.57,117.89 228.69,117.78 v1(228.83,117.78)
  BOTTOM w0.14: C95042.1 167.6,108.41 167.6,107.16 168.14,106.62 168.14,104.25 168.44,103.94 168.44,103.46 170.31,101.59 170.58,101.59 176.09,96.09 190.06,96.09 199.15,105.17 201.1,105.17 205.7,109.77 207.23,109.77 213.29,115.83 213.29,116.61 213.75,117.07 219.31,117.07 221.2,118.96 223.16,118.96
PEG_RXN10_C: length 11
  TOP w0.14: v2(166.71,118.76) U13114.BE35
  BOTTOM w0.104: 167.21,114.52 167.21,114.53 167.17,114.58 167.17,114.66 167.3,114.8 167.3,118.37 167.06,118.61 166.86,118.61 v2(166.71,118.76)
  BOTTOM w0.14: 167.21,114.52 167.21,114.07 167.9,113.39 167.9,109.77 167.66,109.53 167.66,109.39 C95042.2
PEG_RXN11: length 78.7
  TOP w0.14: v1(226.88,119.35) 226.88,118.88 227.01,118.76 227.14,118.76 227.21,118.82 U41.D21
  BOTTOM w0.104: v1(226.88,119.35) 227.04,119.35 227.14,119.25 227.14,119.02 227.01,118.89 226.02,118.89 225.6,119.32 224.33,119.32 224,119.65 223.97,119.65 223.92,119.7
  BOTTOM w0.14: C95044.1 168.81,107.31 168.7,107.2 168.7,107.06 168.85,106.91 168.85,104.54 169.31,104.08 169.31,103.59 170.6,102.3 170.87,102.3 176.38,96.8 189.77,96.8 198.85,105.88 200.81,105.88 201.12,106.2 201.12,106.4 200.58,106.94 200.58,107.36 201.03,107.81 201.45,107.81 201.99,107.27 202.19,107.27 205.43,110.51 206.93,110.51 212.58,116.15 212.58,117.04 213.37,117.83 219.01,117.83 220.87,119.7 223.92,119.7
PEG_RXN11_C: length 11
  TOP w0.14: v2(168.11,116.66) 167.9,116.66 167.76,116.81 U13114.BG36
  BOTTOM w0.104: 168.02,114.55 168.02,114.56 167.72,114.86 167.72,116.85 167.85,116.98 168.02,116.98 168.11,116.89 v2(168.11,116.66)
  BOTTOM w0.14: C95044.2 168.78,107.99 168.78,108.5 168.61,108.67 168.61,113.72 168.02,114.32 168.02,114.55
PEG_RXN12: length 75.4
  TOP w0.14: U41.F22 228.35,119.75 228.18,119.91 v1(228.18,120.14)
  BOTTOM w0.104: v1(228.18,120.14) 228.18,119.98 228.07,119.86 227.9,119.86 227.75,120.01 225.67,120.01 225.19,120.49 224.13,120.49 224.08,120.45 223.98,120.45 223.93,120.49 223.92,120.49
  BOTTOM w0.14: 223.92,120.49 220.59,120.49 219.16,119.05 213.59,119.05 211.87,117.34 211.87,116.46 206.65,111.24 205.16,111.24 203.24,109.33 201.29,109.33 189.47,97.51 176.68,97.51 170.17,104.02 170.17,107.19 170.29,107.31 C95046.1
PEG_RXN12_C: length 10.8
  TOP w0.14: v2(168.81,115.96) 168.97,115.96 169.16,116.15 U13114.BH38
  BOTTOM w0.102: 168.41,115.15 168.41,114.99 169.26,114.14 169.31,114.14 169.33,114.12
  BOTTOM w0.104: v2(168.81,115.96) 168.81,116.06 168.68,116.2 168.5,116.2 168.41,116.11 168.41,115.15
  BOTTOM w0.14: C95046.2 170.36,107.76 170.2,107.92 170.2,108.3 169.7,108.79 169.7,109.4 169.32,109.78 169.32,112.75 169.69,113.12 169.69,113.76 169.33,114.12
PEG_RXN13: length 75.7
  TOP w0.14: U41.D23 227.21,120.42 227.11,120.33 227,120.33 226.88,120.45 v1(226.88,120.93)
  BOTTOM w0.102: 223.84,121.23 224,121.23 224.29,120.94 225.47,120.94 225.95,120.47 227.02,120.47 227.14,120.58 227.14,120.83 227.04,120.93 v1(226.88,120.93)
  BOTTOM w0.14: 223.84,121.23 220.26,121.23 219.34,120.3 213.83,120.3 211.16,117.63 211.16,116.76 206.4,112.01 204.92,112.01 202.95,110.04 200.99,110.04 189.18,98.22 176.97,98.22 171.56,103.63 171.56,106.51 171.46,106.61 171.46,106.75 171.22,107 171.22,108.26 170.92,108.55 170.92,108.87 171.14,109.09 C95050.1
PEG_RXN13_C: length 10.8
  TOP w0.14: U13114.BE38 v2(168.81,118.76)
  BOTTOM w0.104: v2(168.81,118.76) 168.98,118.59 169.15,118.59 169.41,118.33 169.41,115.09 169.49,115.01
  BOTTOM w0.14: C95050.2 171.07,109.76 171.07,110 170.56,110.5 170.56,113.94 169.49,115.01
PEG_RXN14: length 72.9
  TOP w0.14: U41.F24 228.35,121.32 228.18,121.49 v1(228.18,121.72)
  BOTTOM w0.102: v1(228.18,121.72) 228.18,121.42 228.11,121.35 227.97,121.35 227.69,121.63 225.7,121.63 225.32,122.01 224.08,122.01 224,122.09 224,122.13 223.98,122.15
  BOTTOM w0.14: 223.98,122.15 223.9,122.23 220.02,122.23 218.81,121.02 213.54,121.02 210.45,117.93 210.45,117.17 206.04,112.77 204.67,112.77 202.65,110.75 200.7,110.75 188.88,98.93 177.28,98.93 174.07,102.14 174.07,102.97 172.36,104.69 172.36,106.72 172.17,106.91 172.17,107.05 C95052.1
PEG_RXN14_C: length 12
  TOP w0.14: U13114.BG39 169.86,116.86 170.06,116.66 v2(170.21,116.66)
  BOTTOM w0.104: v2(170.21,116.66) 170.21,116.92 170.15,116.98 169.93,116.98 169.83,116.88 169.83,115.7 170.44,115.08 170.52,115.08 170.59,115
  BOTTOM w0.14: C95052.2 172.21,107.99 172.21,109.34 172.01,109.54 172.01,112.33 171.61,112.73 171.61,112.89 171.98,113.25 171.98,113.88 171.22,114.64 170.95,114.64 170.59,115
PEG_RXN15: length 74.3
  TOP w0.14: U41.D25 227.21,121.97 227.14,121.9 227,121.9 226.88,122.03 v1(226.88,122.5)
  BOTTOM w0.102: v1(226.88,122.5) 227.02,122.5 227.15,122.38 227.15,122.22 227.02,122.09 225.88,122.09 225.42,122.55 224.51,122.55 224.37,122.68 224.37,122.73 224.36,122.74
  BOTTOM w0.14: 224.36,122.74 224.07,123.03 219.55,123.03 218.29,121.77 217.43,121.77 216.95,122.25 212.61,122.25 209.74,119.38 209.74,117.5 205.9,113.67 204.57,113.67 202.36,111.46 199.4,111.46 198.98,111.04 198.98,110.62 199.17,110.43 199.17,110.23 198.87,109.93 198.68,109.93 198.48,110.13 198.06,110.13 197.61,109.67 197.61,109.25 197.81,109.06 197.81,108.86 197.51,108.57 197.31,108.57 197.12,108.76 196.7,108.76 196.24,108.31 196.24,107.89 196.44,107.69 196.44,107.5 196.14,107.2 195.94,107.2 195.75,107.39 195.33,107.39 194.84,106.9 194.84,105.89 188.59,99.64 177.58,99.64 174.8,102.43 174.8,103.27 173.3,104.77 173.3,105.81 173.4,105.91 C95056.1
PEG_RXN15_C: length 12.1
  TOP w0.14: v2(170.91,116.66) U13114.BG41
  BOTTOM w0.102: 171.85,115.15 171.85,115.18 171.82,115.21 171.82,116.08 171.36,116.53 171.04,116.53 v2(170.91,116.66)
  BOTTOM w0.14: 171.85,115.15 171.85,115.07 172.74,114.19 172.74,109.82 172.93,109.63 172.93,108.49 173.25,108.17 173.25,106.69 C95056.2
PEG_RXP0: length 98
  TOP w0.14: U41.F10 228.83,110.62 v1(228.83,110.69)
  BOTTOM w0.104: 226.72,106.77 226.72,107.07 226.46,107.32 226.46,109.47 226.79,109.79 228.31,109.79 228.67,110.15 228.67,110.53 v1(228.83,110.69)
  BOTTOM w0.14: 226.72,106.77 226.72,104.11 217.71,95.1 217.3,95.1 v1(216.83,94.63) 216.36,95.1 210.29,95.1 209.35,94.16 205.65,94.16 205.31,94.5 201.14,94.5 198.29,91.66 196.2,91.66 193.25,88.71 172.87,88.71 168.66,92.91 166.92,92.91 157.75,102.08 157.75,102.58 157.12,103.22 157.12,104.49 155.72,105.89 155.72,106.37 154.99,107.1 154.99,108 C95017.2
PEG_RXP0_C: length 11.2
  TOP w0.14: v2(160.41,116.66) 160.76,117.01 U13114.BG26
  BOTTOM w0.102: v2(160.41,116.66) 160.25,116.5 160.09,116.5 159.74,116.15 159.74,115.65 159.7,115.61
  BOTTOM w0.14: 159.7,115.61 159.7,115.27 158.27,113.84 158.27,111.99 155.87,109.58 155.36,109.58 155.03,109.25 155.03,108.9 C95017.1
PEG_RXP1: length 95.3
  TOP w0.14: U41.D11 226.88,110.76 v1(226.88,110.69)
  BOTTOM w0.102: 225.95,106.28 225.95,106.28 225.95,106.77
  BOTTOM w0.104: 225.95,106.28 225.97,106.26 ; v1(226.88,110.69) 227.1,110.91 227.1,111.05 227.01,111.14 226.08,111.14 225.8,110.86 225.8,109.97 225.95,109.83 225.95,106.77
  BOTTOM w0.14: C95006.2 156.68,108.08 156.68,105.94 157.88,104.74 157.88,103.61 158.5,102.99 158.5,102.33 167.21,93.62 168.96,93.62 173.16,89.42 192.95,89.42 198.8,95.27 206.22,95.27 206.55,94.95 208.84,94.95 209.71,95.81 212.91,95.81 213.87,96.78 214.71,96.78 v1(215.13,96.36) 215.63,96.85 218.19,96.85 225.97,104.63 225.97,106.26
PEG_RXP1_C: length 11.9
  TOP w0.14: v2(160.41,117.36) 160.6,117.36 160.76,117.52 U13114.BF26
  BOTTOM w0.102: 160.14,114.39 160.16,114.41 160.2,114.41 160.24,114.44 160.79,115 160.79,117.54 160.66,117.67 160.52,117.67 160.41,117.56 v2(160.41,117.36)
  BOTTOM w0.14: C95006.1 156.73,109.07 156.73,109.38 159.09,111.74 159.09,113.34 160.14,114.39
PEG_RXP2: length 94.1
  TOP w0.14: v1(228.83,112.27) 228.83,112.2 U41.F12
  BOTTOM w0.102: 225.07,106.32 225.07,106.29 225.07,106.29 225.07,106.23 225.07,106.23 225.07,106.1 225.08,106.09 225.08,106.08
  BOTTOM w0.104: 225.07,106.32 225.07,106.78 225.34,107.05 225.34,110.99 225.95,111.6 228.42,111.6 228.64,111.82 228.64,112.07 v1(228.83,112.27)
  BOTTOM w0.14: 225.08,106.08 225.08,105.99 225.1,105.96 225.1,105.67 223.38,103.95 223.38,103.31 218.47,98.4 217.28,98.4 v1(216.76,97.88) 216.36,98.28 214.18,98.28 212.48,96.57 209.35,96.57 208.47,95.7 206.81,95.7 205.75,96.75 199.28,96.75 192.66,90.13 173.45,90.13 169.25,94.33 167.51,94.33 159.3,102.55 159.3,104.54 157.98,105.86 157.98,106.78 C95020.2
PEG_RXP2_C: length 12.3
  TOP w0.14: v2(161.81,117.36) U13114.BF27
  BOTTOM w0.104: v2(161.81,117.36) 161.66,117.21 161.45,117.21 161.2,116.96 161.2,115.95 161.31,115.84 161.31,114.77 161.25,114.71
  BOTTOM w0.14: C95020.1 158.06,107.61 158.06,109.61 159.98,111.53 159.98,112.57 161.04,113.64 161.04,114.5 161.25,114.71
PEG_RXP3: length 93
  TOP w0.14: U41.D13 226.88,112.33 v1(226.88,112.27)
  BOTTOM w0.104: 223.92,112.48 223.93,112.48 223.98,112.52 224.01,112.52 224.03,112.54 225.62,112.54 225.8,112.72 226.92,112.72 227.07,112.57 227.07,112.45 v1(226.88,112.27)
  BOTTOM w0.14: 223.92,112.48 223.7,112.48 222.73,111.5 222.73,109.44 222.8,109.36 222.8,109.26 223.01,109.06 223.01,108.8 223.2,108.61 223.2,108.18 223.3,108.08 223.3,107.65 224.2,106.75 224.2,105.78 222.67,104.25 222.67,103.9 218.5,99.72 215.7,99.72 v1(215.26,99.28) 214.82,99.72 214.54,99.72 212.15,97.34 208.99,97.34 208.07,96.41 207.31,96.41 205.98,97.74 205.34,97.74 204.86,98.23 203.11,98.23 202.5,97.62 199.14,97.62 192.36,90.84 173.75,90.84 169.55,95.04 167.8,95.04 160.03,102.82 160.03,104.82 159.37,105.48 159.37,105.65 C95026.1
PEG_RXP3_C: length 12.3
  TOP w0.14: v2(162.51,116.66) U13114.BG29
  BOTTOM w0.104: 161.81,114.52 161.81,114.53 161.85,114.58 161.85,114.61 161.85,114.62 161.85,116.14 162.22,116.51 162.36,116.51 v2(162.51,116.66)
  BOTTOM w0.14: C95026.2 159.28,106.54 159.28,109.81 160.69,111.22 160.69,111.91 161.81,113.03 161.81,114.52
PEG_RXP4: length 91.5
  TOP w0.14: v1(228.83,113.84) 228.83,113.77 U41.F14
  BOTTOM w0.104: v1(228.83,113.84) 228.63,113.64 228.63,113.45 228.39,113.2 225.79,113.2 225.36,113.63 224.3,113.63 224.07,113.4 224.03,113.4 224.01,113.38 223.98,113.38 223.93,113.34 223.92,113.34
  BOTTOM w0.14: C95028.1 160.62,109.09 160.62,108.37 160.52,108.26 160.52,107.13 161.4,106.24 161.4,103.66 161.8,103.26 161.8,102.06 168.1,95.76 169.84,95.76 174.04,91.55 192.07,91.55 198.84,98.33 200.83,98.33 207.35,104.84 208.91,104.84 v1(209.34,104.41) 209.78,104.85 211.76,104.85 212.89,105.98 212.89,108.26 213.18,108.55 213.18,109.26 215.88,111.97 221.59,111.97 222.96,113.34 223.92,113.34
PEG_RXP4_C: length 11.1
  TOP w0.14: v2(162.51,118.06) 162.72,118.06 162.86,117.92 U13114.BF29
  BOTTOM w0.102: 162.6,114.26 162.6,114.34 162.63,114.37 162.63,114.73 162.89,114.99 162.89,115.18 162.89,115.18 162.89,116.37 162.89,116.37 162.89,117.54 163.06,117.71 163.06,118.19 162.88,118.38 162.61,118.38 162.51,118.28 v2(162.51,118.06)
  BOTTOM w0.14: 162.6,114.26 162.6,112.68 161.4,111.48 161.4,110.92 160.79,110.31 160.79,109.95 160.51,109.67 C95028.2
PEG_RXP5: length 85.8
  TOP w0.14: v1(226.88,113.84) 226.88,113.91 U41.D15
  BOTTOM w0.102: 223.92,114.16 223.95,114.16 223.98,114.2 224.22,114.2 224.29,114.13 224.61,114.13
  BOTTOM w0.104: v1(226.88,113.84) 226.88,113.84 227.05,114.01 227.05,114.25 227.01,114.29 225.71,114.29 225.54,114.13 224.61,114.13
  BOTTOM w0.14: C95030.1 161.69,107.26 161.69,107 162.12,106.57 162.12,103.95 162.51,103.56 162.51,102.35 168.39,96.47 170.14,96.47 174.34,92.26 191.77,92.26 198.55,99.04 200.54,99.04 207.42,105.92 208.83,105.92 209.19,106.28 210.91,106.28 211.11,106.47 211.45,106.47 212.18,107.2 212.18,109.27 215.59,112.68 220.56,112.68 222.04,114.16 223.92,114.16
PEG_RXP5_C: length 11.1
  TOP w0.14: v2(163.91,117.36) U13114.BF30
  BOTTOM w0.104: 163.38,114.75 163.37,114.76 163.37,114.78 163.3,114.85 163.3,116.94 163.55,117.19 163.74,117.19 v2(163.91,117.36)
  BOTTOM w0.14: C95030.2 161.39,108.03 161.63,108.28 161.63,108.62 162.2,109.18 162.2,109.54 162.62,109.96 162.62,110.85 163.39,111.62 163.39,114.73 163.38,114.75
PEG_RXP6: length 85.2
  TOP w0.14: v1(228.83,115.42) 228.83,115.35 U41.F16
  BOTTOM w0.102: 225.35,115.19 225.35,115.19 223.98,115.19 223.95,115.15 223.92,115.15
  BOTTOM w0.104: 225.35,115.19 225.76,114.77 228.39,114.77 228.65,115.03 228.65,115.23 v1(228.83,115.42)
  BOTTOM w0.14: C95032.1 163.01,107.72 163.01,107.11 163.33,106.79 163.33,102.54 168.69,97.18 170.43,97.18 174.63,92.98 191.35,92.98 198.12,99.75 200.08,99.75 206.96,106.63 208.54,106.63 215.31,113.41 220.14,113.41 221.89,115.15 223.92,115.15
PEG_RXP6_C: length 9.8
  TOP w0.14: v2(164.61,116.66) U13114.BG32
  BOTTOM w0.104: 164.06,114.83 164.05,114.84 164.05,114.86 164,114.91 164,114.93 163.98,114.96 163.98,116.19 164.28,116.5 164.44,116.5 v2(164.61,116.66)
  BOTTOM w0.14: C95032.2 163.16,108.52 163.16,109.25 163.33,109.42 163.33,110.54 164.1,111.32 164.1,114.78 164.06,114.83
PEG_RXP7: length 84.5
  TOP w0.14: v1(226.88,115.42) 226.88,115.48 U41.D17
  BOTTOM w0.104: 223.92,115.9 224.16,115.66 225.45,115.66 225.7,115.92 226.9,115.92 227.07,115.74 227.07,115.61 v1(226.88,115.42)
  BOTTOM w0.14: 223.92,115.9 223.89,115.92 223.54,115.92 223.3,116.16 221.87,116.16 219.84,114.12 215.02,114.12 208.24,107.34 206.67,107.34 200.53,101.21 198.58,101.21 191.06,93.69 174.93,93.69 170.73,97.89 168.98,97.89 164.54,102.33 164.54,106.95 164.17,107.32 164.17,108.81 164.45,109.09 164.45,109.46 C95035.1
PEG_RXP7_C: length 9.8
  TOP w0.14: U13114.BF32 164.96,117.9 164.8,118.06 v2(164.61,118.06)
  BOTTOM w0.102: 164.82,114.11 164.82,114.76 164.99,114.93 164.99,118.27 164.88,118.38 164.67,118.38 164.61,118.33 v2(164.61,118.06)
  BOTTOM w0.14: C95035.2 164.42,110.41 164.42,110.62 164.82,111.02 164.82,114.11
PEG_RXP8: length 81.8
  TOP w0.14: v1(227.53,116.21) 227.53,116.27 U41.E18
  BOTTOM w0.104: 223.99,116.79 224.05,116.85 225.18,116.85 225.37,116.66 227.61,116.66 227.74,116.52 227.74,116.36 227.59,116.21 v1(227.53,116.21)
  BOTTOM w0.14: C95037.1 165.07,107.82 165.07,107.42 165.25,107.24 165.25,106.41 165.87,105.8 165.87,102.01 169.28,98.6 171.02,98.6 175.22,94.4 190.76,94.4 198.28,101.92 200.24,101.92 206.37,108.06 207.91,108.06 214.7,114.85 219.55,114.85 221.57,116.87 223.6,116.87 223.68,116.79 223.99,116.79
PEG_RXP8_C: length 10.2
  TOP w0.14: v2(166.01,117.36) U13114.BF33
  BOTTOM w0.104: 165.57,114.55 165.57,114.66 165.4,114.83 165.4,116.94 165.66,117.2 165.85,117.2 v2(166.01,117.36)
  BOTTOM w0.14: 165.57,114.55 165.57,109.51 165.2,109.14 165.2,108.65 C95037.2
PEG_RXP9: length 78.7
  TOP w0.14: v1(227.53,117.78) 227.53,117.71 U41.E19
  BOTTOM w0.104: v1(227.53,117.78) 227.36,117.6 227.36,117.38 227.09,117.11 225.84,117.11 225.69,117.27 224.19,117.27 223.45,118 223.21,118 223.17,117.96
  BOTTOM w0.14: C95039.1 166.26,106.75 166.26,106.41 166.58,106.09 166.58,103.72 170.15,100.16 170.47,100.16 175.52,95.11 190.47,95.11 197.99,102.63 199.94,102.63 206.08,108.77 207.61,108.77 214.42,115.57 219.26,115.57 221.64,117.96 223.17,117.96
PEG_RXP9_C: length 10.4
  TOP w0.14: v2(166.71,116.66) U13114.BG35
  BOTTOM w0.104: 166.34,114.52 166.34,114.66 166.06,114.94 166.06,116.17 166.39,116.5 166.55,116.5 v2(166.71,116.66)
  BOTTOM w0.14: 166.34,114.52 166.34,107.63 C95039.2
PEG_RXP10: length 80.3
  TOP w0.14: U41.E20 228.18,117.85 v1(228.18,117.78)
  BOTTOM w0.102: 223.16,118.7 223.18,118.7 223.22,118.73 223.87,118.73 224.24,118.36 224.72,118.36 224.73,118.36 224.78,118.36 224.79,118.36 224.81,118.36
  BOTTOM w0.104: v1(228.18,117.78) 228.26,117.78 228.37,117.89 228.37,118.08 228.23,118.22 224.99,118.22 224.85,118.36 224.81,118.36
  BOTTOM w0.14: C95041.1 167.33,108.5 167.33,107.05 167.87,106.51 167.87,104.14 168.17,103.83 168.17,103.35 170.2,101.33 170.47,101.33 175.98,95.82 190.17,95.82 199.26,104.91 201.21,104.91 205.81,109.5 207.34,109.5 213.56,115.72 213.56,116.5 213.86,116.81 219.42,116.81 221.31,118.7 223.16,118.7
PEG_RXP10_C: length 11
  TOP w0.14: v2(166.71,118.06) 166.91,118.06 167.06,117.92 U13114.BF35
  BOTTOM w0.104: 166.95,114.52 166.95,114.56 166.96,114.58 166.96,114.75 167.1,114.88 167.1,118.28 166.97,118.41 166.85,118.41 166.71,118.26 v2(166.71,118.06)
  BOTTOM w0.14: C95041.2 167.39,109.42 167.39,109.64 167.63,109.88 167.63,113.28 166.95,113.96 166.95,114.52
PEG_RXP11: length 78.7
  TOP w0.14: U41.E21 227.53,119.28 v1(227.53,119.35)
  BOTTOM w0.104: v1(227.53,119.35) 227.34,119.17 227.34,118.94 227.09,118.69 225.94,118.69 225.51,119.11 224.24,119.11 223.93,119.43 223.75,119.43
  BOTTOM w0.14: 223.75,119.43 220.98,119.43 219.12,117.57 213.48,117.57 212.85,116.93 212.85,116.04 207.04,110.24 205.54,110.24 202.3,107 201.88,107 201.34,107.54 201.14,107.54 200.84,107.25 200.84,107.05 201.39,106.51 201.39,106.09 200.92,105.62 198.96,105.62 189.88,96.53 176.27,96.53 170.76,102.04 170.49,102.04 169.04,103.48 169.04,103.97 168.58,104.43 168.58,106.8 168.43,106.95 168.43,107.12 C95043.1
PEG_RXP11_C: length 11
  TOP w0.14: U13114.BF36 v2(168.11,117.36)
  BOTTOM w0.104: v2(168.11,117.36) 167.94,117.19 167.76,117.19 167.51,116.94 167.51,114.77 167.77,114.51 167.77,114.48
  BOTTOM w0.14: 167.77,114.48 167.77,114.16 168.35,113.58 168.35,108.55 168.51,108.39 168.51,108.03 C95043.2
PEG_RXP12: length 75.5
  TOP w0.14: v1(228.18,119.35) 228.18,119.42 U41.E22
  BOTTOM w0.104: 223.92,120.22 224.15,120.22 224.21,120.28 225.11,120.28 225.59,119.81 227.67,119.81 228.12,119.35 v1(228.18,119.35)
  BOTTOM w0.14: C95045.1 169.9,107.15 169.9,103.9 176.57,97.24 189.58,97.24 201.4,109.06 203.35,109.06 205.27,110.98 206.76,110.98 212.14,116.35 212.14,117.23 213.7,118.79 219.27,118.79 220.7,120.22 223.92,120.22
PEG_RXP12_C: length 10.8
  TOP w0.14: v2(168.81,116.66) U13114.BG38
  BOTTOM w0.102: 169.14,113.94 169.12,113.95 169.12,114 168.21,114.91 168.21,115.15
  BOTTOM w0.104: v2(168.81,116.66) 168.55,116.4 168.42,116.4 168.21,116.19 168.21,115.15
  BOTTOM w0.14: 169.14,113.94 169.43,113.65 169.43,113.23 169.06,112.87 169.06,109.67 169.44,109.29 169.44,108.68 169.93,108.19 169.93,107.95 C95045.2
PEG_RXP13: length 75.7
  TOP w0.14: U41.E23 227.53,120.86 v1(227.53,120.93)
  BOTTOM w0.102: v1(227.53,120.93) 227.34,120.74 227.34,120.5 227.11,120.26 225.86,120.26 225.39,120.74 224.2,120.74 223.98,120.96 223.92,120.96
  BOTTOM w0.14: C95049.1 170.66,108.96 170.66,108.44 170.95,108.15 170.95,106.89 171.2,106.64 171.2,106.5 171.3,106.4 171.3,103.52 176.86,97.95 189.29,97.95 201.1,109.77 203.06,109.77 205.03,111.74 206.51,111.74 211.42,116.65 211.42,117.52 213.94,120.04 219.45,120.04 220.37,120.96 223.92,120.96
PEG_RXP13_C: length 10.8
  TOP w0.14: v2(168.81,118.06) 169.05,118.06 169.16,117.95 U13114.BF38
  BOTTOM w0.104: v2(168.81,118.06) 168.81,118.31 168.88,118.39 169.07,118.39 169.21,118.24 169.21,114.94 169.27,114.88 169.27,114.86 169.27,114.85
  BOTTOM w0.14: 169.27,114.85 170.3,113.83 170.3,110.39 170.8,109.89 170.8,109.81 C95049.2
PEG_RXP14: length 73
  TOP w0.14: U41.E24 228.18,121 v1(228.18,120.93)
  BOTTOM w0.102: 223.79,121.96 223.81,121.94 223.86,121.94 223.93,121.87 223.99,121.81 225.23,121.81 225.61,121.43 227.61,121.43 228.11,120.93 v1(228.18,120.93)
  BOTTOM w0.14: C95051.1 171.91,107.07 171.91,106.8 172.09,106.61 172.09,104.58 173.81,102.86 173.81,102.03 177.17,98.67 188.99,98.67 200.81,110.48 202.76,110.48 204.78,112.5 206.15,112.5 210.71,117.06 210.71,117.82 213.65,120.75 218.92,120.75 220.13,121.96 223.79,121.96
PEG_RXP14_C: length 12
  TOP w0.14: v2(170.21,117.36) U13114.BF39
  BOTTOM w0.102: 171.09,114.4 171.09,114.39
  BOTTOM w0.104: v2(170.21,117.36) 170.04,117.19 169.84,117.19 169.62,116.97 169.62,115.61 170.41,114.82 170.43,114.82
  BOTTOM w0.14: 171.09,114.4 170.85,114.4 170.43,114.82 ; 171.09,114.39 171.71,113.77 171.71,113.36 171.34,113 171.34,112.61 171.74,112.21 171.74,109.42 171.94,109.23 171.94,108.03 C95051.2
PEG_RXP15: length 74.3
  TOP w0.14: v1(227.53,122.5) 227.53,122.43 U41.E25
  BOTTOM w0.102: 224.17,122.55 224.18,122.54 224.23,122.54 224.42,122.34 225.33,122.34 225.79,121.89 227.1,121.89 227.35,122.13 227.35,122.32 v1(227.53,122.5)
  BOTTOM w0.14: C95055.1 173.03,105.7 173.03,104.66 174.53,103.16 174.53,102.32 177.47,99.38 188.7,99.38 195.1,105.78 195.1,106.79 195.44,107.13 195.64,107.13 195.83,106.93 196.25,106.93 196.71,107.39 196.71,107.8 196.51,108 196.51,108.2 196.81,108.49 197.01,108.49 197.2,108.3 197.62,108.3 198.07,108.75 198.07,109.17 197.88,109.36 197.88,109.56 198.17,109.86 198.37,109.86 198.57,109.67 198.99,109.67 199.44,110.12 199.44,110.54 199.24,110.73 199.24,110.93 199.51,111.19 202.47,111.19 204.68,113.4 206.01,113.4 210,117.39 210,119.27 212.72,121.99 216.84,121.99 217.32,121.5 218.41,121.5 219.66,122.76 223.96,122.76 224.17,122.55
PEG_RXP15_C: length 12.1
  TOP w0.14: U13114.BH41 171.31,116.26 171.31,116.11 171.16,115.96 v2(170.91,115.96)
  BOTTOM w0.102: 171.62,114.93 171.58,114.96 171.58,115.18 171.62,115.21 171.62,115.99 171.28,116.33 171.09,116.33 170.91,116.14 v2(170.91,115.96)
  BOTTOM w0.14: 171.62,114.93 172.47,114.08 172.47,109.71 172.66,109.52 172.66,108.38 172.98,108.06 172.98,106.53 C95055.2
PEG_TXN0: length 80.4
  TOP w0.14: v1(160.88,105.45) 160.66,105.45 160.29,105.82 160.29,106.37 160.81,106.89 160.81,107.77 160.62,107.96 160.62,111.17 161.82,112.36 161.82,112.87 162.05,113.1 162.05,113.76 161.79,114.02 161.79,114.41 161.46,114.74 U13114.BK27 ; v1(209.39,101.97) 209.49,102.08 209.49,102.48 210.21,103.19 212.24,103.19 213.32,104.27 213.32,109.61 213.65,109.94 213.88,109.94 C94278.1
  IN4 w0.089: v1(209.39,101.97) 209.59,102.18 209.59,102.3 209.42,102.47 204.11,102.47 200.72,99.08 197.2,99.08 194.07,95.95 175.36,95.95 172.59,98.72 166.13,98.72 161.5,103.34 160.72,103.34 160.08,103.99 160.08,105.08 160.24,105.25 160.68,105.25 v1(160.88,105.45)
PEG_TXN1: length 77.5
  TOP w0.14: C94276.1 214.04,111.5 213.88,111.33 213.37,111.33 212.61,110.57 212.61,106.63 211.01,105.03 208.49,105.03 208.1,104.64 208.1,104.06 v1(207.84,103.8) ; v1(162.14,110.81) 162.02,110.7 161.88,110.7 161.74,110.84 161.74,111.3 162.53,112.09 162.53,113.7 162.79,113.95 162.79,114.14 U13114.BL29
  IN4 w0.089: v1(207.84,103.8) 207.99,103.8 208.13,103.94 208.13,104.21 207.96,104.39 205.23,104.39 200.61,99.76 196.95,99.76 193.7,96.51 175.59,96.51 172.82,99.28 171.23,99.28 170.51,100 165.79,100 161.4,104.4 161.4,110.29 161.63,110.52 162.06,110.52 162.14,110.6 v1(162.14,110.81)
PEG_TXN2: length 76.5
  TOP w0.14: v1(210.13,105.6) 210.37,105.85 210.37,106.12 210.99,106.74 211.24,106.74 211.86,107.36 211.86,111.21 213.01,112.37 215.07,112.37 C94274.1 ; U13114.BM30 163.24,113.19 163.24,110.86 162.96,110.58 162.96,109.92 162.38,109.34 162.38,105.83 162.53,105.68 162.68,105.68 v1(162.86,105.86)
  IN4 w0.089: v1(210.13,105.6) 210.33,105.8 210.33,105.91 210.2,106.04 209.82,106.04 209.12,105.34 205.21,105.34 200.26,100.38 196.63,100.38 193.32,97.07 175.83,97.07 173.05,99.84 171.48,99.84 170.56,100.76 165.82,100.76 162.08,104.5 162.08,105.24 162.52,105.67 162.67,105.67 v1(162.86,105.86)
PEG_TXN3: length 76
  TOP w0.14: U13114.BK30 163.56,114.68 163.91,114.33 163.91,114.08 164.15,113.83 164.15,113.04 163.93,112.82 163.93,109.8 163.6,109.47 163.6,106.08 163.77,105.91 163.89,105.91 v1(164.08,106.1) ; C94272.1 215.16,113.99 212.98,113.99 210.71,111.72 210.71,107.79 v1(210.59,107.66)
  IN4 w0.089: v1(210.59,107.66) 210.84,107.41 210.84,107.01 210.61,106.78 209.36,106.78 208.7,106.13 204.86,106.13 199.98,101.25 196.22,101.25 192.76,97.8 176.13,97.8 173.36,100.57 171.83,100.57 170.84,101.57 166.05,101.57 164.74,102.88 164.74,105.6 164.5,105.83 164.34,105.83 v1(164.08,106.1)
PEG_TXN4: length 79.1
  TOP w0.14: v1(165.35,104.97) 165.35,104.9 165.18,104.73 165.01,104.73 164.84,104.9 164.84,108.7 164.64,108.91 164.64,113.67 164.82,113.86 165.17,113.86 165.32,114.01 165.32,114.37 165.25,114.44 165.02,114.44 164.96,114.38 U13114.BL32 ; v1(215.36,116.3) 214.97,115.91 214.97,115.72 215.1,115.59 215.24,115.59 C94270.1
  IN4 w0.089: v1(215.36,116.3) 215.22,116.3 215.05,116.48 215.05,116.77 214.89,116.92 213.77,116.92 213.47,116.62 213.47,112.6 208.12,107.25 204.22,107.25 199.43,102.45 195.75,102.45 192.21,98.92 176.59,98.92 173.82,101.7 172.48,101.7 171.34,102.84 169.82,102.84 168.3,104.36 168.3,106.38 167.7,106.97 166.84,106.97 166.02,106.15 166.02,104.99 165.71,104.67 165.57,104.67 165.35,104.89 v1(165.35,104.97)
PEG_TXN5: length 74.2
  TOP w0.14: C94268.1 217.32,115.76 217.32,116.2 v1(217.42,116.3) ; v1(167.4,105.74) 167.17,105.5 166.87,105.5 166.64,105.73 166.64,108.68 165.29,110.03 165.29,113.39 165.41,113.51 U13114.BM33
  IN4 w0.089: v1(217.42,116.3) 217.29,116.17 217.29,115.29 208.51,106.52 204.6,106.52 199.73,101.65 195.97,101.65 192.52,98.19 176.29,98.19 173.52,100.97 172.01,100.97 170.94,102.03 167.84,102.03 166.6,103.27 166.6,105.1 167.03,105.52 167.19,105.52 v1(167.4,105.74)
PEG_TXN6: length 75.6
  TOP w0.14: U13114.BK33 165.66,114.69 166.01,114.34 166.01,114 166.25,113.76 166.25,113.22 165.98,112.95 165.98,112.38 165.9,112.3 165.9,110.57 168.56,107.9 168.56,105.97 168.78,105.76 169.25,105.76 v1(169.44,105.95) ; C94266.1 215.44,118.03 v1(215.71,118.3)
  IN4 w0.089: v1(215.71,118.3) 215.55,118.15 215.55,117.58 215.29,117.32 213.78,117.32 213.59,117.5 213.59,118.15 213.51,118.24 213.24,118.24 213.15,118.15 213.15,117.5 213.07,117.43 213.07,112.76 207.95,107.64 203.95,107.64 201.3,104.99 197.73,104.99 192.05,99.32 176.78,99.32 174.01,102.09 172.72,102.09 171.5,103.32 169.92,103.32 168.75,104.49 168.75,105.45 169.05,105.75 169.24,105.75 v1(169.44,105.95)
PEG_TXN7: length 75.7
  TOP w0.14: v1(217.75,118.32) 217.64,118.32 217.54,118.22 217.54,118.05 217.82,117.77 218.06,117.77 C94264.1 ; v1(167.13,110.05) 167.1,110.05 166.68,110.48 166.68,110.8 166.39,111.09 166.39,113.03 166.47,113.11 166.47,113.76 166.92,114.21 U13114.BL35
  IN4 w0.089: v1(167.13,110.05) 167.13,110.23 167.02,110.33 166.75,110.33 166.52,110.09 166.52,109.31 168.13,107.7 169.14,107.7 170.2,106.65 170.2,104.34 170.49,104.06 171.9,104.06 172.33,103.63 173.5,103.63 176.47,100.66 180.86,100.66 181.47,100.04 191.75,100.04 200.23,108.53 207.66,108.53 212.07,112.94 212.07,118.27 212.93,119.13 213.89,119.13 214.06,118.96 216.67,118.96 216.92,118.71 217.32,118.71 217.47,118.56 217.47,118.43 217.58,118.32 v1(217.75,118.32)
PEG_TXN8: length 71.9
  TOP w0.14: v1(167.1,112.03) 167.23,111.91 167.53,111.91 167.71,112.08 167.71,112.49 167.53,112.67 167.53,113.28 U13114.BM36 ; C94262.1 218.26,119.23 218.14,119.11 217.85,119.11 217.69,119.28 v1(217.69,119.56)
  IN4 w0.089: v1(167.1,112.03) 167.35,112.28 168.39,112.28 169.02,111.66 169.02,109.37 171.56,106.83 171.56,106.04 172.89,104.71 175.02,104.71 176.3,105.99 177.34,105.99 181.35,110 197.2,110 197.59,109.61 207.1,109.61 210.99,113.49 210.99,118.99 212.7,120.7 217.37,120.7 218.29,119.78 218.29,119.35 218.08,119.13 217.77,119.13 217.62,119.28 217.62,119.49 v1(217.69,119.56)
PEG_TXN9: length 73
  TOP w0.14: v1(170.71,105.79) 170.51,105.59 170.26,105.59 170.19,105.67 170.19,108.43 168.35,110.27 168.35,113.81 168.12,114.04 168.12,114.49 167.76,114.85 U13114.BK36 ; C94260.1 218.18,120.31 217.59,120.31 217.3,120.03 215.38,120.03 215.3,119.95 215.3,119.79 v1(215.54,119.55)
  IN4 w0.089: v1(170.71,105.79) 170.96,105.54 171.3,105.54 172.66,104.19 174.09,104.19 177.05,101.22 181.19,101.22 181.57,100.84 189.41,100.84 197.67,109.11 207.35,109.11 211.43,113.19 211.43,118.53 213.18,120.28 214.86,120.28 215.21,119.93 215.21,119.68 215.34,119.55 v1(215.54,119.55)
PEG_TXN10: length 67.3
  TOP w0.14: v1(169.83,110.57) 169.57,110.3 169.32,110.3 169.16,110.47 169.16,111.95 168.83,112.28 168.83,113.66 169.16,113.99 U13114.BL38 ; C94258.1 216.97,121.71 216.64,121.39 216.31,121.39 215.93,121 213.45,121 213.39,121.07 213.39,121.24 213.66,121.51 v1(213.7,121.51)
  IN4 w0.089: v1(169.83,110.57) 169.91,110.57 170.1,110.38 170.1,110.22 170.66,109.66 170.66,109.11 172.32,107.44 172.32,106.33 173.21,105.44 174.6,105.44 175.93,106.77 176.97,106.77 180.95,110.75 197.73,110.75 198.14,110.33 206.8,110.33 210.26,113.8 210.26,119.64 212.3,121.67 212.58,121.67 212.8,121.89 213.31,121.89 v1(213.7,121.51)
PEG_TXN11: length 66.8
  TOP w0.14: v1(169.82,112.54) 169.57,112.8 169.57,113.4 169.67,113.51 U13114.BM39 ; v1(215.74,121.51) 215.67,121.51 215.43,121.74 215.43,122.13 216.35,123.04 216.75,123.04 216.97,122.83 C94256.1
  IN4 w0.089: v1(215.74,121.51) 215.58,121.51 215.3,121.79 215.3,122.43 214.97,122.76 212.5,122.76 209.7,119.97 209.7,114.03 206.57,110.9 198.54,110.9 198.07,111.36 179.92,111.36 177.01,108.44 176.3,108.44 174.83,106.97 174.83,106.48 174.36,106 173.46,106 172.91,106.55 172.91,107.88 171.29,109.49 171.29,109.89 170.65,110.53 170.65,111.91 170.33,112.23 169.95,112.23 169.95,112.23 169.82,112.36 v1(169.82,112.54)
PEG_TXN12: length 66.6
  TOP w0.14: U13114.BK39 170.21,114.56 170.21,114.03 170.45,113.78 170.45,113 170.56,112.89 170.56,111.84 171.04,111.36 v1(171.04,111.36) ; v1(214.78,124.3) 214.95,124.12 217.76,124.12 217.92,123.96 218.15,123.96 C94254.1
  IN4 w0.089: v1(214.78,124.3) 214.48,124 212.89,124 209.14,120.26 209.14,114.26 206.33,111.46 198.8,111.46 198.3,111.95 179.73,111.95 176.78,109.01 176.07,109.01 174.27,107.2 174.27,106.71 174.12,106.56 173.71,106.56 173.48,106.8 173.48,108.2 171.93,109.74 171.93,110.76 171.63,111.06 171.34,111.06 v1(171.04,111.36)
PEG_TXN13: length 65.1
  TOP w0.14: v1(216.54,124.89) 216.54,125.15 216.69,125.3 217.83,125.3 217.98,125.15 C94252.1 ; v1(173.9,107.61) 173.9,107.71 173.73,107.88 172.48,107.88 171.56,108.8 171.56,112.26 170.67,113.15 170.67,113.85 170.97,114.15 171.2,114.15 U13114.BL41
  IN4 w0.089: v1(173.9,107.61) 174.15,107.87 174.37,107.87 175.91,109.4 176.61,109.4 179.58,112.37 198.45,112.37 198.97,111.85 206.17,111.85 208.68,114.36 208.68,120.36 213.49,125.16 216.27,125.16 v1(216.54,124.89)
PEG_TXN14: length 64.3
  TOP w0.14: v1(214.78,126.46) 215.07,126.75 215.07,127 215.29,127.22 218.18,127.22 219.44,125.96 219.52,125.96 C94250.1 ; v1(173.83,109.9) 173.83,109.88 173.59,109.63 173.05,109.63 172.61,110.07 172.61,110.96 172.54,111.04 172.54,112.46 171.85,113.15 171.85,113.4 U13114.BM42
  IN4 w0.089: v1(214.78,126.46) 215.12,126.12 215.12,126.02 214.99,125.89 213.19,125.89 207.96,120.66 207.96,114.67 205.87,112.58 199.37,112.58 198.79,113.16 179.34,113.16 176.37,110.19 175.43,110.19 174.74,109.49 174.13,109.49 173.83,109.79 v1(173.83,109.9)
PEG_TXN15: length 63.2
  TOP w0.14: v1(214.18,127.06) 214.04,127.2 214.04,127.33 214.43,127.72 218.47,127.72 218.84,127.35 219.38,127.35 C94248.1 ; v1(173.83,111.4) 173.64,111.21 173.51,111.21 173.25,111.47 173.25,112.59 172.61,113.22 172.61,113.69 172.3,114.01 172.3,114.57 U13114.BK42
  IN4 w0.089: v1(173.83,111.4) 174.09,111.15 174.84,111.15 175.24,110.75 176.05,110.75 179.13,113.83 206.23,113.83 206.8,114.4 206.8,116.86 207.39,117.45 207.39,122.49 212.4,127.49 213.47,127.49 213.89,127.06 v1(214.18,127.06)
PEG_TXP0: length 80.4
  TOP w0.14: v1(160.8,104.74) 160.42,104.74 160.32,104.84 160.32,105.42 160.03,105.71 160.03,106.48 160.55,107 160.55,107.66 160.36,107.85 160.36,111.28 161.55,112.47 161.55,112.98 161.78,113.21 161.78,113.65 161.52,113.91 161.52,114.15 U13114.BL27 ; v1(210.08,101.97) 210.04,101.97 209.76,102.25 209.76,102.37 210.32,102.92 212.35,102.92 213.58,104.16 213.58,109.49 213.76,109.67 213.97,109.67 214.07,109.57 C94277.1
  IN4 w0.089: v1(210.08,101.97) 209.87,101.97 209.76,102.09 209.76,102.37 209.49,102.64 204.04,102.64 200.65,99.24 197.13,99.24 194,96.12 175.43,96.12 172.66,98.89 166.2,98.89 161.57,103.51 160.79,103.51 160.24,104.06 160.24,105.01 160.31,105.08 160.7,105.08 160.8,104.98 v1(160.8,104.74)
PEG_TXP1: length 77.5
  TOP w0.14: C94275.1 213.92,111.07 213.48,111.07 212.87,110.46 212.87,106.52 211.12,104.77 208.6,104.77 208.37,104.53 208.37,103.96 v1(208.5,103.83) ; v1(162.14,110.14) 161.84,110.43 161.77,110.43 161.48,110.73 161.48,111.41 162.26,112.2 162.26,113.81 162.52,114.06 162.52,114.41 162.71,114.59 162.71,114.76 U13114.BK29
  IN4 w0.089: v1(208.5,103.83) 208.3,104.03 208.3,104.28 208.03,104.55 205.16,104.55 200.54,99.93 196.89,99.93 193.63,96.68 175.66,96.68 172.89,99.45 171.3,99.45 170.58,100.17 165.86,100.17 161.56,104.47 161.56,110.22 161.7,110.35 161.92,110.35 v1(162.14,110.14)
PEG_TXP2: length 76.5
  TOP w0.14: U13114.BM29 162.97,113.4 162.97,110.97 162.69,110.69 162.69,110.03 162.11,109.45 162.11,105.72 162.41,105.41 162.62,105.41 v1(162.86,105.17) ; C94273.1 215.07,112.1 213.12,112.1 212.12,111.1 212.12,107.25 211.35,106.47 211.11,106.47 210.64,106.01 210.64,105.73 v1(210.79,105.58)
  IN4 w0.089: v1(162.86,105.17) 162.86,105.35 162.71,105.5 162.59,105.5 162.25,105.17 162.25,104.57 165.89,100.93 170.63,100.93 171.55,100.01 173.12,100.01 175.9,97.24 193.25,97.24 196.57,100.55 200.19,100.55 205.14,105.5 209.05,105.5 209.75,106.2 210.27,106.2 210.49,105.98 210.49,105.73 210.5,105.73 210.5,105.72 210.64,105.58 v1(210.79,105.58)
