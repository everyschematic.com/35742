# Allegro board DAZGLMB1ED0 dazglmb1ed0-d-ver a-165 (.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
MODE: length 15.9
  TOP w0.14: U13146.31 59.58,31.28 58.85,30.55 58.24,30.55 v1(58.08,30.4) 58.08,30.37 58.51,29.95 R21748.1
  IN1 w0.089: v1(58.08,30.4) 58.08,30.17 58.64,29.61 59.74,29.61 60.98,28.36 60.98,24.93 61.62,24.3 61.62,22.88 v1(61.36,22.63)
  BOTTOM w0.14: v1(58.08,30.4) 58.66,29.82 R21749.2 ; R67356.2 61.65,23.11 61.36,22.83 v1(61.36,22.63)
MODE_1: length 30.2
  TOP w0.14: R21909.1 68.47,38.8 v1(68.83,39.16) 69.17,39.5 69.32,39.5 69.74,39.92 U13147.31
  IN3 w0.079: v1(68.83,39.16) 69.16,38.83 69.16,35.48 69.67,34.97 71.11,34.97 71.8,34.28 71.8,27.8 68.59,24.6 68.59,23.79 68.35,23.54 65.7,23.54 64.82,22.65 v1(62.99,22.65)
  BOTTOM w0.14: R67357.2 63.45,23.11 v1(62.99,22.65) ; v1(68.83,39.16) 68.32,38.65 R21906.2
MODE_2: length 9
  TOP w0.14: R21965.1 v1(43.25,32.91) 43.25,33.24 44.34,34.33 U13149.31
  IN2 w0.089: v1(40.74,30.4) 41.19,30.4 43.07,32.27 43.07,32.73 v1(43.25,32.91)
  BOTTOM w0.14: R21965.1 v1(43.25,32.91) ; v1(40.74,30.4) 40.74,29.96 40.54,29.77 40.54,29.75 40.42,29.63 R67354.2
MODE_3: length 29.2
  TOP w0.14: R21945.1 53.26,41.76 v1(53.27,41.77) v1(53.27,42.46) 53.6,42.46 54.12,42.98 U13148.31
  IN3 w0.079: v1(53.27,41.77) 53.27,41.08 54.68,39.67 54.68,38.7 53.74,37.76 53.74,34.61 52.93,33.8 48.41,33.8 47.04,32.43 43.66,32.43 v1(39.95,28.72)
  BOTTOM w0.14: v1(39.95,28.72) 39.95,28.66 R67355.2 ; R21945.1 53.26,41.76 v1(53.27,41.77)
MP2949A__VFBA: length 4.3
  TOP w0.14: PU37.7 266.56,159.63 v1(266.85,159.35)
  BOTTOM w0.14: PR66867.1 266.93,160.72 PR66864.2 266.7,159.49 v1(266.85,159.35) 267.5,159.35 v1(267.69,159.54)
MP2949A_ADDR_P: length 4.7
  TOP w0.14: PU37.25 268.56,166.61 268.72,166.77 269.95,166.77 270.3,167.12 v1(270.4,167.12) 270.91,167.12 271.7,167.91 PR66870.2 PR66866.2
MP2949A_ALT#: length 2
  TOP w0.14: PR66861.2 267.23,168.19 267.23,167.43 266.96,167.16 PU37.29
MP2949A_CS1: length 3.1
  TOP w0.14: PU37.5 265.76,159.77 265.53,159.53 v1(265.53,159.38) 265.53,159.35 266.18,158.7 PR66855.1
  BOTTOM w0.14: PR66841.1 266.04,158.84 265.53,159.35 v1(265.53,159.38)
MP2949A_CS2: length 2.9
  TOP w0.14: PU37.4 265.36,160.05 264.87,159.55 v1(264.87,159.35) 265.27,158.94 PR66857.2
  BOTTOM w0.14: v1(264.87,159.35) 265.05,159.17 PR66843.1
MP2949A_CS3: length 3
  TOP w0.14: PR66858.1 264.28,158.97 264.18,159.07 v1(264.18,159.43) 264.28,159.43 264.96,160.11 PU37.3
  BOTTOM w0.14: PR66844.1 264.08,158.79 264.08,159.38 264.13,159.43 v1(264.18,159.43)
MP2949A_CS4: length 3.7
  TOP w0.14: PR66852.2 263.29,159.45 v1(263.6,159.76) 263.77,159.94 264.38,159.94 264.56,160.12 PU37.2
  BOTTOM w0.14: PR66845.1 263.52,159.7 263.57,159.76 v1(263.6,159.76)
MP2949A_CS5: length 6.1
  TOP w0.14: PR66860.1 262.88,159.31 262.88,160.01 v1(263.06,160.19) 263.17,160.29 264.13,160.29 264.16,160.33 PU37.1
  BOTTOM w0.14: v1(261.84,160.54) 262.2,160.54 262.55,160.19 v1(263.06,160.19) 262.88,160.01 262.88,159.3 262.53,158.94 PR66846.1
MP2949A_CS6: length 5.7
  TOP w0.14: PR66862.2 261.47,158.7 262.55,159.78 262.55,160.41 PU37.48 ; PR66862.2 261.34,158.67 260.5,157.83 v1(260.5,157.75) ; PR66862.2 261.02,158.7 260.83,158.89 PR66847.1
MP2949A_CSUMA: length 2.4
  TOP w0.14: PR66877.2 270.74,163.49 269.99,163.49 269.77,163.27 PU37.18
MP2949A_CSUMB: length 2.2
  TOP w0.14: PR66879.2 271.17,163.77 269.87,163.77 269.77,163.67 PU37.19
MP2949A_CSUMC: length 2.2
  TOP w0.14: PU37.20 270.45,164.07 270.64,164.25 PR66881.2
MP2949A_EN: length 5.1
  TOP w0.14: v1(259.13,167.3) 259.28,167.15 260.12,167.15 260.22,167.25 PR66848.2 PC5585.1 261.41,167.25 261.89,166.77 261.89,166.76 262.98,165.67 PU37.37
MP2949A_IMONA: length 3.1
  TOP w0.203: PU37.21 270.18,164.47 v1(270.33,164.61)
  BOTTOM w0.508: v1(270.33,164.61) 270.21,164.73 PC5589.2 PR66885.2
MP2949A_IMONB: length 3.3
  TOP w0.14: PU37.22 269.92,164.87 270.15,165.09 PR66891.2 PC5592.2
MP2949A_IMONC: length 4.5
  TOP w0.14: PU37.23 269.87,165.27 270.28,165.68 v1(270.73,165.68)
  BOTTOM w0.14: v1(271.55,166.77) 271.59,166.73 PR66887.1 PC5590.2 270.9,165.68 v1(270.73,165.68)
MP2949A_IREF: length 2.8
  TOP w0.14: PR66875.2 271.23,166.69 270.61,166.69 269.58,165.67 PU37.24
MP2949A_PE: length 5.3
  TOP w0.14: PR66884.1 PR66889.2 PC5591.1 262.28,167.88 262.86,167.3 v1(262.86,166.97) 263.11,166.72 264.05,166.72 264.16,166.61 PU37.36
MP2949A_PSYS: length 5.7
  TOP w0.14: PU37.46 262.53,162.07 262.45,161.99 262.02,161.99 261.45,161.42 PC5587.2 PR66871.2 259.97,161.42 259.81,161.59 PR66869.2 259.53,161.4 259.07,160.95 v1(258.39,160.95)
MP2949A_PW1: length 2.4
  TOP w0.14: PR66825.1 261.46,163.13 262.02,163.69 262.45,163.69 262.88,163.27 PU37.43
MP2949A_PW2: length 2.3
  TOP w0.14: PR66826.1 261.79,164.1 262.45,164.1 262.89,163.67 PU37.42
MP2949A_PW3: length 2.3
  TOP w0.14: PR66827.1 261.61,164.63 262.38,164.63 262.95,164.07 PU37.41
MP2949A_PW4: length 2.3
  TOP w0.14: PU37.40 262.95,164.47 262.22,165.19 PR66835.1
MP2949A_PW5: length 2.4
  TOP w0.14: PR66836.1 261.94,165.9 262.98,164.87 PU37.39
MP2949A_PW6: length 2.5
  TOP w0.14: PR66839.1 261.64,166.62 262.99,165.27 PU37.38
MP2949A_SCL_P: length 3.8
  TOP w0.14: PU37.33 265.36,166.88 264.69,167.56 v1(264.69,167.73) 264.69,167.97 PR66856.2
  BOTTOM w0.14: v1(264.28,167) 264.69,167.4 v1(264.69,167.73) 264.41,168.01 PR66856.2
MP2949A_SCLK: length 3
  TOP w0.14: PR66865.2 v1(269.11,167.91) 269.11,167.86 268.88,167.63 268.42,167.63 267.76,166.97 PU37.27
MP2949A_SDA_P: length 3.7
  TOP w0.14: PU37.32 265.76,167.14 v1(265.36,167.54) 265.32,167.58 265.32,168.04 PR66850.2
  BOTTOM w0.14: PR66850.2 265.39,167.98 265.39,167.57 v1(265.36,167.54) 265.81,167.1 v1(265.81,166.95)
MP2949A_SDIO: length 2.4
  TOP w0.14: PU37.28 267.36,167.13 267.71,167.48 267.71,167.78 268.14,168.22 PR66863.2
MP2949A_SLP_SO#: length 4.5
  TOP w0.14: PU37.35 264.56,166.77 264.34,167 263.55,167 263.29,167.26 v1(263.29,167.61) 262.99,167.91 PR66849.2
  BOTTOM w0.14: v1(262.99,166.89) 262.99,167.3 v1(263.29,167.61) 262.99,167.91 PR66849.2
MP2949A_STB: length 2.4
  TOP w0.14: PU37.34 264.96,166.77 263.7,168.04 PR66854.1
MP2949A_TEMP: length 3.6
  TOP w0.14: PU37.45 262.21,162.47 v1(262.17,162.5)
  BOTTOM w0.203: PC5593.1 263.02,161.79 262.9,161.9 PR66895.1 262.28,162.4 v1(262.17,162.5) 262.02,162.35 PR66893.2
MP2949A_VDIFF_A: length 3.3
  TOP w0.14: v1(266.19,159.35) 266.16,159.37 PU37.6
  BOTTOM w0.14: v1(266.19,159.35) 266.16,159.37 266.16,159.45 266.16,159.45 266.16,160.26 PR66864.1 265.2,160.49 v1(265.09,160.6)
MP2949A_VDIFF_B: length 2.3
  TOP w0.14: PR66876.1 268.6,158.81 268.6,159.27 267.76,160.11 PU37.10
MP2949A_VDIFF_C: length 2.5
  TOP w0.14: PR66898.1 270.75,160.6 270.52,160.6 269.9,161.21 269.9,161.44 269.68,161.67 PU37.14
MP2949A_VFB: length 5.4
  TOP w0.14: PR66898.2 272.3,160.27 v1(272.72,160.69) ; PR66898.2 271.85,160.27 271.24,160.87 270.63,160.87 270.2,161.31 270.2,161.56 269.69,162.07 PU37.15 ; PR66898.2 271.6,160.01 PR66897.1
MP2949A_VFBB: length 4.9
  TOP w0.14: v1(271.04,157.42) 270.61,157.85 270.17,157.85 270.1,157.78 PR66880.1 269.76,158.21 269.55,158.42 PR66876.2 269.55,158.73 268.16,160.12 PU37.11
MP2949A_VIN_SEN: length 4.7
  TOP w0.14: v1(259.56,160.34) 259.69,160.48 PR66840.2 260.79,160.48 260.82,160.45 PR66842.2 261.34,160.67 261.82,161.15 261.82,161.33 262.15,161.67 PU37.47
MP2949A_VORTN: length 2.4
  TOP w0.14: PU37.17 270.6,162.87 v1(270.66,162.81) 271.34,162.12 PR66894.1
MP2949A_VORTNA: length 1.9
  TOP w0.14: PR66874.1 267.94,158.89 267.94,159.45 267.71,159.68 267.71,159.71 267.36,160.05 PU37.9
MP2949A_VORTNB: length 1.6
  TOP w0.14: PU37.13 269.16,161.27 269.07,161.18 269.07,160.88 269.77,160.19 PR66886.1
MP2949A_VOSEN: length 2.7
  TOP w0.14: PU37.16 270.11,162.47 270.73,161.84 v1(270.73,161.51) 271.27,161.51 PR66892.1
MP2949A_VOSENA: length 1.9
  TOP w0.14: PU37.8 266.96,160 267.36,159.6 267.36,159.02 PR66872.1
MP2949A_VOSENB: length 1.9
  TOP w0.14: PR66883.1 269.6,159.48 269.04,160.04 268.66,160.04 268.57,160.14 268.57,160.51 PU37.12
MP2949A_VRHOT#: length 2
  TOP w0.14: PR66937.2 265.83,167.53 266.16,167.2 PU37.31
MP2949A_VRRDY: length 2
  TOP w0.14: PR66853.2 266.8,167.99 266.8,167.56 266.56,167.32 PU37.30
MP86903_GT_CS1: length 9.3
  TOP w0.14: PU46.18 266.82,152.45 266.06,153.2 266.06,153.63 v1(266.05,153.64)
  BOTTOM w0.203: PR66951.2 263.52,157.07 263.88,156.71 265.88,156.71 266.63,155.96 266.63,155.16 266.06,154.58 266.06,153.64 v1(266.05,153.64)
MP86903_GT_CS2: length 11.4
  TOP w0.14: v1(258.82,152.59) 259.28,152.59 259.38,152.5 PU45.18
  IN2 w0.203: v1(258.82,152.59) 259.18,152.59 259.4,152.82 259.4,153.43 259.1,153.74 259.1,154.6 259.25,154.75 259.25,156.84 260.09,157.67 262.43,157.67 v1(262.91,157.19)
  BOTTOM w0.203: v1(262.91,157.19) 262.91,157.32 262.53,157.7 PR66954.2
MP86903_GT_PWM1: length 17.9
  TOP w0.14: PU46.15 267.47,154.41 v1(267.02,154.86)
  TOP w0.203: v1(259.46,165.24) 259.51,165.19 PR66949.2
  IN5 w0.203: v1(267.02,154.86) 267.02,157.04 265.5,158.56 262.17,158.56 261.16,159.58 261.16,164.38 260.29,165.24 v1(259.46,165.24)
MP86903_GT_PWM2: length 14.6
  TOP w0.14: v1(259.74,154.96) 260.08,154.61 PU45.15
  TOP w0.203: v1(259.46,165.9) PR66952.2
  IN5 w0.203: v1(259.46,165.9) 258.97,165.42 258.97,165.07 259.28,164.76 260.17,164.76 260.47,164.46 260.47,158.13 259.74,157.4 v1(259.74,154.96)
MP86903_GT_SYNC1: length 25.4
  TOP w0.14: PU46.16 266.93,153.25 266.85,153.33 266.85,154.04 v1(267,154.19) ; v1(264.31,171.92) v1(264.31,171.24)
  TOP w0.203: v1(264.31,171.24) 264.46,171.09 PR66950.2
  IN3 w0.203: v1(267,154.19) 266.57,154.62 266.57,155.92 266.57,155.92 266.57,155.93 266.19,156.31 266.19,157.85 265.15,158.89 261.94,158.89 261.26,159.58 261.26,163.72 263.73,166.19 263.73,170.33 264.31,170.91 v1(264.31,171.24)
MP86903_GT_SYNC2: length 21.3
  TOP w0.14: v1(259.61,154.3) 259.28,153.97 259.28,153.5 259.48,153.3 PU45.16
  TOP w0.203: PR66953.2 263.75,171.11 v1(263.62,171.24)
  IN3 w0.203: v1(263.62,171.24) 263.15,170.76 263.15,168.84 262.66,168.35 262.66,165.52 260.95,163.82 260.95,158.59 259.3,156.94 259.3,154.6 v1(259.61,154.3)
MP86903_GT_TEMP1: length 19.9
  TOP w0.14: v1(266.14,155.36) 266.14,154.21 266.52,153.83 266.52,153.23 266.9,152.85 PU46.17
  IN4 w0.203: v1(266.14,155.36) 266.14,156.27 265.8,156.61 260.9,156.61 260.55,156.96 260.55,160.21 259.28,161.48 v1(257.83,161.48)
  BOTTOM w0.203: v1(257.83,161.48) 257.88,161.43 259.58,161.43 260.52,162.37 PR66915.2
MP86903_GT_TEMP2: length 17.7
  TOP w0.14: PU45.17 259.2,152.9 v1(258.85,153.25)
  IN4 w0.203: v1(255.09,161.38) 255.09,161.36 259.19,157.26 259.19,154.44 258.85,154.1 v1(258.85,153.25)
  BOTTOM w0.203: PR66920.2 260.32,159.88 256.53,159.88 255.09,161.33 v1(255.09,161.38)
MP86903_VCCSA_CS: length 1.1
  TOP w0.14: PR66957.2 228.87,147.95 PU43.10
MP86903_VCCSA_PWM: length 41.4
  TOP w0.14: v1(231.29,146.78) 231.13,146.93 PU43.7
  TOP w0.203: PR66955.2 v1(259.4,166.62)
  IN5 w0.203: v1(259.4,166.62) 258.45,165.66 257.87,165.66 255.99,163.78 251.37,163.78 251.1,163.52 244.62,163.52 240.3,159.2 238.25,159.2 234.84,155.79 234.84,151.88 231.54,148.58 231.54,147.03 v1(231.29,146.78)
MP86903_VCCSA_SYNC: length 2.1
  TOP w0.14: v1(231.13,148) PR66956.2 229.67,147.33 PU43.8
MP86903_VCCSA_TEMP: length 1.2
  TOP w0.14: PU43.9 229.27,147.64 PR66925.2
MP86903_VCORE_CS1: length 36.2
  TOP w0.14: PU38.18 237.59,154.93 237.23,155.29 237.05,155.29 v1(236.72,155.62)
  IN2 w0.203: v1(265.7,157.24) 265.7,157.57 264.69,158.59 258.01,158.59 256.43,160.16 248.31,160.16 247.87,159.73 245.23,159.73 244.16,158.67 238.17,158.67 236.3,156.8 236.3,156.04 v1(236.72,155.62)
  BOTTOM w0.203: PR66941.2 266.04,157.52 265.76,157.24 v1(265.7,157.24)
MP86903_VCORE_CS2: length 27.6
  TOP w0.14: PU39.18 244.57,154.96 v1(244.37,155.16)
  IN2 w0.203: v1(264.99,157.24) 263.95,158.28 257.86,158.28 256.28,159.86 248.56,159.86 248.09,159.39 245.6,159.39 244.93,158.72 244.93,155.72 v1(244.37,155.16)
  BOTTOM w0.203: v1(264.99,157.24) 265.05,157.3 PR66944.2
MP86903_VCORE_CS3: length 19.3
  TOP w0.203: v1(251.53,155.13) 251.76,155.13 251.94,154.96 PU44.18
  IN2 w0.203: v1(251.53,155.13) 252.04,155.13 252.29,155.39 252.29,158.33 253.49,159.53 256.18,159.53 257.73,157.98 263.37,157.98 264.08,157.27 v1(264.08,157.24)
  BOTTOM w0.203: v1(264.08,157.24) 264.06,157.26 PR66948.2
MP86903_VCORE_PWM1: length 27.7
  TOP w0.14: v1(237.81,157.45) 238.15,157.11 PU38.15
  TOP w0.203: v1(257.45,164.46) 257.45,164.38 258.29,163.54 259.54,163.54 PR66939.2
  IN5 w0.203: v1(257.45,164.46) 256.45,163.45 251.48,163.45 251.25,163.22 244.74,163.22 240.34,158.82 238.32,158.82 237.81,158.31 v1(237.81,157.45)
MP86903_VCORE_PWM2: length 21.2
  TOP w0.14: PU39.15 245.62,156.6 245.49,156.73 v1(245.49,157.14) v1(245.49,157.98)
  TOP w0.203: PR66942.2 259.84,163.95 258.57,163.95 258.13,164.38 v1(258.13,164.44)
  IN5 w0.203: v1(258.13,164.44) 256.85,163.16 254.78,163.16 251.66,160.04 245.94,160.04 245.49,159.58 v1(245.49,157.14)
MP86903_VCORE_PWM3: length 13.4
  TOP w0.14: PU44.15 252.86,157.17 v1(252.88,157.19)
  TOP w0.203: v1(258.85,164.46) 258.92,164.38 259.92,164.38 PR66945.2
  IN5 w0.203: v1(252.88,157.19) 252.88,160.75 254.91,162.78 257.17,162.78 v1(258.85,164.46)
MP86903_VCORE_SYNC1: length 37.1
  TOP w0.14: v1(237.61,156.79) 237.46,156.63 237.46,155.87 237.62,155.71 238.12,155.71 PU38.16
  TOP w0.203: PR66940.2 261.61,171.01 261.34,171.29 v1(260.88,171.29)
  IN3 w0.203: v1(260.88,171.29) 261.34,170.83 261.34,168.68 260.65,168 260.65,164.76 259.58,163.69 255.88,163.69 253.14,160.95 243.12,160.95 240.94,158.77 238.52,158.77 237.29,157.54 237.29,157.1 v1(237.61,156.79)
MP86903_VCORE_SYNC2: length 30.5
  TOP w0.14: PU39.16 245.14,155.76 v1(244.42,156.48)
  TOP w0.203: PR66943.2 262.33,171.11 v1(262.2,171.24)
  IN3 w0.203: v1(262.2,171.24) 262.2,170.35 262.58,169.97 262.58,169.08 260.93,167.43 260.93,164.64 259.68,163.39 255.97,163.39 252.44,159.86 245.99,159.86 244.98,158.84 244.98,157.04 v1(244.42,156.48)
MP86903_VCORE_SYNC3: length 23.7
  TOP w0.203: PU44.16 252.31,155.76 v1(251.61,156.46) ; v1(262.88,171.24) 263.04,171.09 PR66947.2
  IN3 w0.203: v1(262.88,171.24) 262.86,171.22 262.86,168.96 261.22,167.31 261.22,164.49 259.81,163.08 256.17,163.08 252.33,159.24 252.33,157.18 v1(251.61,156.46)
MP86903_VCORE_TEMP1: length 30.5
  TOP w0.14: v1(236.75,156.28) 236.85,156.28 237.18,155.95 237.18,155.74 237.59,155.33 PU38.17
  IN4 w0.203: v1(236.75,156.28) 236.75,157.09 238.45,158.79 240.25,158.79 244.69,163.24 255.42,163.24 v1(257.17,161.48)
  BOTTOM w0.203: v1(257.17,161.48) 257.17,161.38 257.58,160.98 259.66,160.98 260.34,161.66 PR66900.2
MP86903_VCORE_TEMP2: length 23.2
  TOP w0.14: PU39.17 244.86,155.36 v1(244.39,155.82)
  IN4 w0.203: v1(256.51,161.43) 255.82,162.12 253.41,162.12 252.48,161.19 249.58,161.19 249.13,160.75 246.02,160.75 244.93,159.66 244.93,156.13 244.62,155.82 v1(244.39,155.82)
  BOTTOM w0.203: v1(256.51,161.43) 257.35,160.6 259.79,160.6 260.14,160.95 PR66905.2
MP86903_VCORE_TEMP3: length 16.3
  TOP w0.203: v1(251.56,155.79) 251.71,155.79 252.15,155.36 PU44.17
  IN4 w0.203: v1(255.8,161.41) 255.38,161.83 253.63,161.83 252.24,160.44 252.24,156.05 251.99,155.79 v1(251.56,155.79)
  BOTTOM w0.203: v1(255.8,161.41) 255.8,161.38 256.94,160.24 PR66946.2
MX0: length 51.8
  TOP w0.14: U49.58 190,50.77 190.37,50.41 v1(190.37,49.72) ; v1(229.49,48.51) CN2048.26
  BOTTOM w0.14: v1(229.49,48.51) 230.86,49.88 230.86,50.31 231.24,50.69 232.05,50.69 232.18,50.56 RP1.1 ; v1(229.49,48.51) 229.49,47.95 227.84,46.31 203.36,46.31 202.37,47.29 192.62,47.29 v1(191.38,48.53) 190.37,49.55 v1(190.37,49.72) ; v1(229.49,48.51) 229.18,48.82 C94782.1
MX1: length 53
  TOP w0.14: U49.59 190.4,50.77 191.03,50.14 v1(191.03,49.65) ; v1(228.49,48.48) CN2048.25 228.49,50.2 228.82,50.54 231.62,50.54 v1(232.25,51.17) v1(232.25,51.88)
  BOTTOM w0.14: C94782.3 228.39,48.58 v1(228.49,48.48) 228.49,47.77 227.31,46.59 203.49,46.59 202.5,47.57 193.05,47.57 191.03,49.6 v1(191.03,49.65) ; RP1.2 232.81,50.77 232.25,51.32 v1(232.25,51.88)
MX2: length 53.1
  TOP w0.14: v1(191.69,49.62) 191.69,49.88 190.8,50.76 U49.60 ; v1(227.49,48.47) CN2048.24 227.49,50.32 228.01,50.84 230.53,50.84 v1(230.8,51.12) 232.06,52.37 232.44,52.37 232.72,52.1 232.72,52.08 v1(232.91,51.88)
  BOTTOM w0.14: v1(191.69,49.62) 193.46,47.85 202.62,47.85 203.6,46.87 226.78,46.87 227.49,47.58 v1(227.49,48.47) 227.58,48.56 C94782.5 ; v1(232.91,51.88) 232.91,51.31 233.45,50.78 RP1.3
MX3: length 57.6
  TOP w0.14: v1(226.49,48.48) CN2048.23 ; v1(192.43,49.62) 192.36,49.62 191.2,50.78 U49.61
  IN3 w0.079: v1(237.03,49.8) 235.2,47.97 227.02,47.97 226.51,48.48 v1(226.49,48.48)
  BOTTOM w0.14: C94782.7 226.79,48.78 v1(226.49,48.48) 225.15,47.14 203.74,47.14 202.76,48.13 193.92,48.13 v1(192.43,49.62) ; v1(237.03,49.8) 235.76,51.07 234.26,51.07 234.08,50.89 RP1.4
MX4: length 54
  TOP w0.14: v1(225.49,48.47) CN2048.22 ; U49.62 191.6,50.78 192.27,50.11 192.6,50.11 v1(193.09,49.62)
  IN3 w0.079: v1(225.49,48.47) 226.22,47.74 235.25,47.74 v1(236.14,46.85)
  BOTTOM w0.14: C94775.1 225.24,48.72 v1(225.49,48.47) 224.44,47.42 203.87,47.42 202.88,48.41 194.3,48.41 v1(193.09,49.62) ; RP1.6 234.72,47.95 234.74,47.92 234.76,47.92 235.21,47.46 235.53,47.46 v1(236.14,46.85)
MX5: length 53.3
  TOP w0.14: v1(224.49,48.47) CN2048.21 ; U49.63 192,50.8 192.4,50.41 193.21,50.41 193.76,49.86 v1(193.76,49.64)
  IN3 w0.079: v1(235.43,46.85) 234.74,47.54 225.42,47.54 v1(224.49,48.47)
  BOTTOM w0.14: v1(235.43,46.85) 234.64,47.64 234.34,47.64 234.08,47.9 RP1.7 ; v1(193.76,49.64) 193.76,49.56 194.2,49.11 194.79,49.11 195.22,49.55 202.14,49.55 203.99,47.7 224.19,47.7 224.49,48.01 v1(224.49,48.47) 224.45,48.51 C94775.3
MX6: length 54
  TOP w0.14: v1(234.77,46.85) 234.3,47.32 233.91,47.32 233.64,47.05 233.64,45.85 233.15,45.36 226.2,45.36 223.49,48.06 v1(223.49,48.48) CN2048.20 ; v1(194.43,49.65) 194.43,49.78 193.49,50.72 192.55,50.72 192.4,50.87 U49.64
  BOTTOM w0.14: v1(234.77,46.85) 234.46,47.16 234.46,47.16 234.3,47.32 234.04,47.32 233.45,47.91 RP1.8 ; C94775.5 223.64,48.63 v1(223.49,48.48) 222.99,47.98 204.1,47.98 202.23,49.85 194.63,49.85 v1(194.43,49.65)
MX7: length 58.5
  TOP w0.14: v1(222.49,48.48) 219.21,45.2 195.42,45.2 195.07,45.56 195.07,48.05 195.96,48.94 195.96,50.64 195.02,51.58 v1(195.02,52.19) 195.02,53 194.81,53.2 U49.65 ; v1(222.49,48.48) 222.68,48.48 226.08,45.08 233.27,45.08 234.11,45.91 v1(234.11,46.85) ; v1(222.49,48.48) CN2048.19
  BOTTOM w0.14: v1(234.11,46.85) 232.81,48.15 RP1.9 ; v1(222.49,48.48) 222.85,48.84 C94775.7
MY0: length 31
  TOP w0.14: v1(204.95,48.48) 204.49,48.94 CN2048.1 ; U49.36 181.2,52.57 v1(180.97,52.8)
  IN3 w0.079: v1(204.95,48.48) 203.89,49.53 197.09,49.53 195.52,51.1 193.7,51.1 192.65,52.14 183.69,52.14 183.64,52.09 182.11,52.09 182.09,52.11 181.66,52.11 v1(180.97,52.8)
  BOTTOM w0.14: C94777.7 204.82,48.61 v1(204.95,48.48)
MY1: length 31
  TOP w0.14: v1(181.63,52.8) 181.63,52.52 181.6,52.49 U49.37 ; v1(205.76,48.48) 205.49,48.75 CN2048.2
  IN3 w0.079: v1(181.63,52.8) 182.14,52.29 182.16,52.29 182.19,52.26 182.57,52.26 182.62,52.32 192.73,52.32 193.77,51.27 196.67,51.27 198.25,49.69 204.55,49.69 v1(205.76,48.48)
  BOTTOM w0.14: C94777.5 205.61,48.63 v1(205.76,48.48)
MY2: length 31.9
  TOP w0.14: U49.38 182,52.51 v1(182.29,52.8) ; v1(206.49,48.49) CN2048.3
  IN3 w0.079: v1(182.29,52.8) 182.6,52.49 187.5,52.49 188.58,53.58 189.69,53.58 190.09,53.18 190.67,53.18 191.16,52.7 192.6,52.7 193.85,51.45 196.87,51.45 198.47,49.85 205.13,49.85 v1(206.49,48.49)
  BOTTOM w0.14: v1(206.49,48.49) 206.42,48.56 C94777.3
MY3: length 34.7
  TOP w0.14: v1(181.35,50.16) 181.35,50.21 181.74,50.59 182.22,50.59 182.4,50.78 U49.39 ; v1(207.49,48.48) CN2048.4
  IN3 w0.079: v1(181.35,50.16) 181.35,50.18 183.08,51.91 183.71,51.91 183.76,51.96 190.34,51.96 191.38,50.92 195.4,50.92 196.94,49.38 202.8,49.38 204.26,47.92 206.93,47.92 v1(207.49,48.48)
  BOTTOM w0.14: C94777.1 207.21,48.76 v1(207.49,48.48)
MY4: length 34.7
  TOP w0.14: U49.40 182.8,50.77 182.14,50.11 v1(182.01,50.11) ; v1(208.49,48.47) CN2048.5
  IN3 w0.079: v1(182.01,50.11) 182.04,50.13 182.04,50.17 183.6,51.73 183.79,51.73 183.84,51.78 190.27,51.78 191.31,50.74 195.35,50.74 196.88,49.21 202.64,49.21 204.08,47.76 207.78,47.76 v1(208.49,48.47)
  BOTTOM w0.14: C94780.7 208.63,48.61 v1(208.49,48.47)
MY5: length 35.2
  TOP w0.14: v1(209.49,48.48) CN2048.6 ; U49.41 183.2,50.77 182.67,50.24 v1(182.67,49.98)
  IN3 w0.079: v1(182.67,49.98) 182.67,50.38 183.9,51.61 190.15,51.61 191.21,50.56 195.27,50.56 196.78,49.05 202.57,49.05 204.02,47.6 208.62,47.6 v1(209.49,48.48)
  BOTTOM w0.14: v1(209.49,48.48) 209.42,48.55 C94780.5
MY6: length 35.2
  TOP w0.14: U49.42 183.6,50.72 183.5,50.62 183.5,50.35 v1(183.31,50.16) ; v1(210.49,48.47) CN2048.7
  IN3 w0.079: v1(210.49,48.47) 209.46,47.44 203.95,47.44 202.51,48.89 196.71,48.89 195.21,50.38 191.03,50.38 189.96,51.46 184.43,51.46 183.31,50.33 v1(183.31,50.16)
  BOTTOM w0.14: C94780.3 210.23,48.73 v1(210.49,48.47)
MY7: length 36.8
  TOP w0.14: v1(183.89,49.62) 183.78,49.73 183.78,50.5 184,50.72 U49.43 ; v1(211.49,48.49) CN2048.8
  IN3 w0.079: v1(211.49,48.49) 210.29,47.29 203.89,47.29 202.44,48.73 196.64,48.73 195.17,50.21 190.98,50.21 189.89,51.3 184.71,51.3 183.87,50.46 183.87,49.77 183.89,49.75 v1(183.89,49.62)
  BOTTOM w0.14: v1(211.49,48.49) 211.02,48.96 C94780.1
MY8: length 36.1
  TOP w0.14: U49.44 184.4,50.67 184.25,50.51 v1(184.25,50.18) ; v1(212.49,48.46) CN2048.9
  IN3 w0.079: v1(212.49,48.46) 211.16,47.13 203.82,47.13 202.37,48.58 196.58,48.58 195.12,50.03 190.9,50.03 189.81,51.12 185.06,51.12 184.25,50.31 v1(184.25,50.18)
  BOTTOM w0.14: C94781.7 212.69,48.66 v1(212.49,48.46)
MY9: length 38.1
  TOP w0.14: U49.45 184.8,50.64 184.71,50.54 184.71,49.68 v1(184.7,49.67) ; v1(213.49,48.49) CN2048.10
  IN3 w0.079: v1(213.49,48.49) 211.97,46.97 203.74,46.97 202.29,48.42 196.51,48.42 195.71,49.22 190.29,49.22 189.91,49.6 189.91,50.58 189.54,50.94 185.26,50.94 184.75,50.44 184.75,49.72 v1(184.7,49.67)
  BOTTOM w0.14: v1(213.49,48.49) 213.48,48.5 C94781.5
MY10: length 37.6
  TOP w0.14: v1(185.18,50.21) 185.2,50.23 U49.46 ; v1(214.49,48.45) CN2048.11
  IN3 w0.079: v1(185.18,50.21) 185.74,50.77 189.43,50.77 189.73,50.47 189.73,49.45 190.19,48.98 195.73,48.98 196.45,48.26 202.23,48.26 203.68,46.81 212.86,46.81 v1(214.49,48.45)
  BOTTOM w0.14: C94781.3 214.29,48.64 v1(214.49,48.45)
MY11: length 37.7
  TOP w0.14: v1(186.43,50.23) 186.83,50.63 186.97,50.63 186.98,50.63 187.11,50.63 187.2,50.72 U49.51 ; v1(215.18,48.45) 215.49,48.76 CN2048.12
  IN3 w0.079: v1(215.18,48.45) 215.18,48.18 213.66,46.66 203.61,46.66 202.16,48.1 196.38,48.1 195.66,48.83 190.12,48.83 189.57,49.38 189.57,50.38 189.36,50.59 186.79,50.59 v1(186.43,50.23)
  BOTTOM w0.14: v1(215.18,48.45) 215.08,48.56 C94781.1
MY12: length 38
  TOP w0.14: v1(187.09,50.21) 187.1,50.21 187.6,50.71 U49.52 ; v1(216.82,48.47) 216.49,48.8 CN2048.13
  IN3 w0.079: v1(216.82,48.47) 216.68,48.47 214.24,46.03 203.35,46.03 201.9,47.47 196.12,47.47 195.65,47.95 189.15,47.95 187.09,50 v1(187.09,50.21)
  BOTTOM w0.14: v1(216.82,48.47) 216.89,48.53 C94783.7
MY13: length 38.9
  TOP w0.14: v1(187.75,50.21) 188,50.46 U49.53 ; v1(217.49,48.48) CN2048.14
  IN3 w0.079: v1(217.49,48.48) 217.49,48.79 217.27,49.01 216.26,49.01 215.98,48.73 215.98,47.99 214.17,46.18 203.42,46.18 201.97,47.63 196.19,47.63 195.69,48.12 189.2,48.12 187.75,49.57 v1(187.75,50.21)
  BOTTOM w0.14: v1(217.49,48.48) 217.67,48.67 C94783.5
MY14: length 39.3
  TOP w0.14: v1(218.49,48.49) CN2048.15 ; v1(188.41,50.21) 188.44,50.21 188.4,50.17 U49.54
  IN3 w0.079: v1(218.49,48.49) 217.81,49.17 216.19,49.17 215.82,48.8 215.82,48.06 214.11,46.34 203.48,46.34 202.03,47.79 196.25,47.79 195.74,48.3 189.28,48.3 188.41,49.17 v1(188.41,50.21)
  BOTTOM w0.14: v1(218.49,48.49) 218.49,48.49 C94783.3
MY15: length 40.1
  TOP w0.14: v1(189.07,50.21) 188.8,50.48 U49.55 ; v1(219.49,48.47) CN2048.16
  IN3 w0.079: v1(219.49,48.47) 218.62,49.34 216.15,49.34 215.67,48.86 215.67,48.12 214.04,46.5 203.55,46.5 202.1,47.95 196.32,47.95 195.78,48.48 189.33,48.48 188.95,48.86 188.95,50.08 v1(189.07,50.21)
  BOTTOM w0.14: v1(219.49,48.47) 219.27,48.69 C94783.1
MY16: length 38.7
  TOP w0.14: v1(220.49,48.48) CN2048.17 ; v1(192.51,46.68) 192.51,48.63 192.42,48.72 190.32,48.72 189.62,49.42 189.62,50.36 189.2,50.78 U49.56
  IN3 w0.079: v1(192.51,46.68) 193.15,47.32 201.84,47.32 203.29,45.87 217.88,45.87 v1(220.49,48.48)
MY17: length 39.1
  TOP w0.14: v1(193.16,46.7) 193.03,46.83 v1(193.03,48.02) 193.03,48.51 192.54,49 190.44,49 189.9,49.53 189.9,50.48 189.6,50.78 U49.57 ; v1(221.49,48.46) CN2048.18
  IN3 w0.079: v1(193.16,46.7) 193.62,47.16 201.77,47.16 203.22,45.71 218.74,45.71 v1(221.49,48.46)
NBSWON#: length 316.4
  TOP w0.14: R20887.1 190.28,69.55 190.11,69.72 R823.1 189.41,69.72 189.03,69.34 C897.2 188.62,69.18 188.72,69.08 188.72,68.56 188.4,68.25 U49.107 188.4,66.35 188.64,66.11 v1(188.64,66.01) 188.42,65.79 188.35,65.79 187.95,65.4 187.95,63.64 188.08,63.51 188.08,60.28 187.17,59.37 187.17,58.83 188.62,57.39 v1(188.62,56.66) ; v1(176.5,60.93) 175.92,60.34 175.92,60.15 175.03,59.26 C94778.1 174.86,58.87 R21049.1
  IN2 w0.089: v1(208.6,55.19) 210.26,53.53 247.34,53.53 248.48,54.68 248.48,60.45 249.32,61.28 276.75,61.28 278.63,59.4 280.16,59.4 281.2,60.44 286.15,60.44 286.79,61.08 288.49,61.08 290.13,62.72 291.57,62.72 293.09,64.23 293.09,70.32 292.27,71.14 292.27,72.15 294.35,74.24 302.84,74.24 304.19,75.58 305.56,75.58 306.34,76.37 314.93,76.37 317.34,78.78 318.61,78.78 v1(319.68,79.85)
  IN3 w0.079: v1(208.6,55.19) 208.58,55.19 207.74,56.02 206.55,56.02 205.63,55.11 205.63,54.25 204.82,53.43 203.02,53.43 202.62,53.03 200,53.03 199.67,53.36 198.95,53.36 198.43,53.87 195.94,53.87 195.42,54.39 194.34,54.39 192.86,55.87 192.38,55.87 191.44,56.81 188.77,56.81 v1(188.62,56.66) ; v1(378.12,14.88) 377.97,15.03 377.97,16.4 378.3,16.73 378.3,17.24 377.77,17.77 375.61,17.77 375.01,18.37 374.38,18.37 374.17,18.58 374.17,19.74 372.05,21.86 372.05,22.93 371.75,23.23 371.27,23.23 370.68,23.82 370.68,28.79 368.02,31.46 367.51,31.46 366.97,32 366.97,33.72 365.25,35.45 365.25,39.49 364.51,40.22 364.51,40.76 365.33,41.58 365.33,51.85 362.7,54.48 362.7,62.17 360.34,64.53 359.63,64.53 357.91,66.26 357.91,71.85 355.75,74.01 352.78,74.01 352.19,73.42 348.32,73.42 348.07,73.18 344.76,73.18 341.9,70.32 337.94,70.32 337.1,71.16 337.1,72.05 336.35,72.81 336.35,76.61 332.76,80.2 321.75,80.2 321.41,79.85 v1(319.68,79.85)
  IN5 w0.089: v1(188.64,66.01) 188.23,65.59 188.23,64.1 190.14,62.19 190.14,60.8 189.87,60.53 178.18,60.53 178.07,60.42 177.01,60.42 v1(176.5,60.93)
  BOTTOM w0.14: C95946.1 376.76,13.34 R22150.1 377.72,14.14 377.97,14.39 377.97,14.72 v1(378.12,14.88)
NGFF1_RST#: length 9.8
  BOTTOM w0.14: CN2069.50 69.77,16.65 71.8,16.65 72.41,17.26 72.41,20.57 v1(72.59,20.74) 72.74,20.9 72.74,21.17 73.5,21.94 R21737.1
NGFF2_RST#: length 9.3
  BOTTOM w0.14: R21800.1 v1(46.71,21.84) 46.71,21.51 46.32,21.12 46.32,17.34 45.66,16.68 43.73,16.68 CN2070.50
NGFF3_DET1: length 370.6
  TOP w0.14: U13113.AG36 303.93,70.22 v2(303.75,70.4)
  IN3 w0.079: v2(303.75,70.4) 303.4,70.76 302.07,70.76 301.23,71.59 300.03,71.59 299.58,72.04 299.58,72.69 298.85,73.42 293.47,73.42 293.07,73.02 291.93,73.02 291.29,72.39 285.69,72.39 282.34,75.73 282.34,76.73 276.09,82.98 212.82,82.98 207.16,77.33 206.03,77.33 205.49,76.79 205.34,76.79 204.48,75.92 204.48,75.24 204.29,75.05 204.29,72.78 200.65,69.14 198.2,69.14 194.41,65.35 193.42,65.35 191.8,66.97 185.46,66.97 184.88,66.39 184.88,65.16 183.11,63.38 183.11,63.18 182.78,62.86 182.51,62.86 182.27,63.1 182.27,64.06 181.49,64.84 180.08,64.84 179.52,64.28 172.63,64.28 170.99,62.64 170,62.64 167.2,59.83 167.2,55.65 164.61,53.07 117.8,53.07 116.38,54.49 103.42,54.49 101.18,52.25 93.07,52.25 89.21,48.38 70.62,48.38 69.92,49.08 68.6,49.08 67.04,50.64 66.46,50.64 66.21,50.38 64.24,50.38 61.83,52.79 61.83,53.59 60.23,55.2 57.57,55.2 56.19,56.58 53.62,56.58 53.09,56.05 51.05,56.05 50.46,55.46 50.46,54.55 48.49,52.57 45.5,52.57 39.14,46.21 39.14,44.63 39.89,43.88 39.89,42.78 40.35,42.32 40.35,38.69 39.36,37.7 39.36,33.89 38.43,32.97 38.43,29.39 39.52,28.29 44.6,28.29 46.66,30.35 49.5,30.35 50.27,31.11 55.15,31.11 57.23,29.03 58.28,29.03 58.77,28.54 58.77,27.28 61.84,24.2 61.84,22.27 62.15,21.96 65.86,21.96 v1(66.57,22.67)
  BOTTOM w0.14: v1(66.57,22.67) 66.21,23.03 Q7874.3 65.77,23.35 65.47,23.05 R67278.1 ; R21176.1 303.17,77.95 304.16,76.95 304.16,75.41 303.68,74.93 v1(303.68,74.63) 303.68,74.44 303.88,74.24 R21188.2 304.14,73.83 304.37,73.59 304.37,72.9 304.23,72.76 304.23,70.88 v2(303.75,70.4)
NGFF3_DET2: length 332.4
  TOP w0.14: Q7875.3 42.77,30.37 42.36,30.78 R67280.1 42.03,32.13 41.3,32.86 40.41,32.86 39.75,33.52 v1(39.54,33.52) ; v2(302.61,69.78) 302.93,69.46 U13113.AD35
  IN3 w0.079: v1(39.54,33.52) 39.54,37.66 40.51,38.62 40.51,42.38 40.05,42.84 40.05,43.94 39.3,44.69 39.3,46.15 45.56,52.41 48.55,52.41 50.75,54.61 51.87,54.61 53.68,56.42 56.12,56.42 57.51,55.04 58.96,55.04 60.34,53.65 60.34,53.2 60.75,52.79 61.61,52.79 64.17,50.23 66.42,50.23 66.67,50.48 66.98,50.48 69.23,48.23 89.3,48.23 93.17,52.09 114.39,52.09 116.01,53.71 116.93,53.71 117.73,52.91 164.68,52.91 167.36,55.59 167.36,59.77 170.07,62.48 171.05,62.48 172.7,64.12 179.58,64.12 180.15,64.69 181.43,64.69 182.11,64 182.11,63.03 182.44,62.7 182.85,62.7 183.26,63.12 183.26,63.31 185.04,65.09 185.04,66.32 185.53,66.81 191.74,66.81 193.35,65.2 194.48,65.2 198.26,68.98 200.71,68.98 204.44,72.71 204.44,74.98 204.64,75.18 204.64,75.86 205.41,76.63 205.55,76.63 206.09,77.17 207.23,77.17 212.88,82.83 276.03,82.83 282.18,76.67 282.18,75.67 285.62,72.23 291.36,72.23 291.99,72.86 293.14,72.86 293.53,73.26 298.78,73.26 299.43,72.62 299.43,71.97 299.96,71.44 301.17,71.44 301.9,70.7 301.9,70.49 v2(302.61,69.78)
  BOTTOM w0.14: v2(302.61,69.78) 303.3,70.47 303.3,71.34 303.2,71.44 303.2,73.34 302.91,73.63 R21187.2 303.17,74.24 303.17,74.82 303.83,75.48 303.83,76.78 303.37,77.23 302.58,77.23 302.18,77.64 301.75,77.64 R21177.1
NGFF3_PEDET1: length 15.2
  TOP w0.14: v1(71.24,21.81) 71.47,21.81 71.83,21.45 71.83,21.17 72.04,20.97 73.54,20.97 73.74,20.77 CN2069.69
  BOTTOM w0.14: v1(71.24,21.81) 71.24,22.68 71.02,22.9 69.02,22.9 R21738.2 R21739.2 66.87,22 Q7874.2 66.54,22 65.93,22.6 R67278.2 64.76,22.44 64.65,22.33 R67357.1 63.63,22.09 62.27,22.09 R67356.1
NGFF3_PEDET2: length 19.3
  TOP w0.14: R67280.2 41.58,30.42 41.93,30.06 v1(41.93,29.38) 41.93,29.3 42.27,28.96 Q7875.2 42.27,28.26 42.4,28.13 R21802.2 R21801.2 ; CN2070.69 47.74,20.75 47.31,21.17 v1(45.69,21.17)
  BOTTOM w0.14: v1(45.69,21.17) 44.7,21.17 44.01,21.86 44.01,24.4 43.47,24.94 43.47,25.62 43.04,26.05 43.04,26.92 v1(42.51,27.45) 41.78,28.19 R67355.1 R67354.1 41.8,29.25 v1(41.93,29.38)
NVVDD: length 6
  TOP w0.254: v2(175.11,114.56) 174.76,114.21 U13114.BL46 ; U13114.BL47 U13114.BM47
  TOP w0.508: v1(144.79,96.81) 145.18,97.2 145.18,99.29 PR9012.1
  BOTTOM w0.203: C95207.1 154.81,122.97 v2(154.81,122.96) ; v2(160.4,122.96) 160.17,122.73 C95184.1
  vias: v1(180,116.77) v2(152.71,139.76) v2(152.71,138.36) v2(152.71,136.96) v2(152.71,135.56) v2(152.71,134.16) v2(152.71,132.76) v2(152.71,132.06) v2(152.71,129.96) v2(152.71,128.56) v2(152.71,127.16) v2(152.71,125.76) v2(153.41,139.76) v2(153.41,138.36) v2(153.41,136.96) v2(153.41,135.56) v2(153.41,134.16) v2(153.41,132.76) v2(153.41,132.06) v2(153.41,129.96) v2(153.41,128.56) v2(153.41,127.16) v2(153.41,125.76) v2(153.41,124.36) v2(154.81,139.76) v2(154.81,138.36) v2(154.81,136.96) v2(154.81,135.56) v2(154.81,134.16) v2(154.81,132.76) v2(154.81,132.06) v2(154.81,129.96) v2(154.81,128.56) v2(154.81,127.16) v2(154.81,125.76) v2(154.81,124.36) v2(155.51,133.46) v2(155.51,130.66) v2(156.21,139.76) v2(156.21,138.36) v2(156.21,136.96) v2(156.21,130.66) v2(156.21,129.96) v2(156.21,128.56) v2(156.21,127.16) v2(156.21,125.76) v2(156.21,124.36) v2(156.21,122.96) v2(156.91,133.46) v2(156.91,130.66) v2(157.61,139.76) v2(157.61,138.36) v2(157.61,136.96) v2(157.61,130.66) v2(157.61,129.96) v2(157.61,128.56) v2(157.61,127.16) v2(157.61,125.76) v2(157.61,124.36) v2(158.31,136.96) v2(158.31,135.56) v2(158.31,134.16) v2(158.31,132.76) v2(159.01,139.76) v2(159.01,138.36) v2(159.01,135.56) v2(159.01,134.16) v2(159.01,132.76) v2(159.01,130.66) v2(159.01,129.96) v2(159.01,128.56) v2(159.01,127.16) v2(159.01,125.76) v2(159.01,124.36) v2(159.01,122.96) v2(159.71,139.76) v2(159.71,138.36) v2(159.71,136.96) v2(159.71,135.56) v2(159.71,134.16) v2(159.71,132.76) v2(159.71,132.06) v2(159.71,129.96) v2(159.71,128.56) v2(159.71,127.16) v2(159.71,125.76) v2(159.71,124.36) v2(160.28,140.64) v2(160.41,139.06) v2(160.41,134.86) v2(160.41,130.66) v2(160.41,127.16) v2(161.11,139.06) v2(161.11,138.36) v2(161.11,134.86) v2(161.81,130.66) v2(161.93,140.65) v2(162.51,139.76) v2(162.51,138.36) v2(162.51,136.96) v2(162.51,135.56) v2(162.51,134.16) v2(162.51,132.76) v2(162.51,130.66) v2(162.51,129.96) v2(162.51,128.56) v2(162.51,127.16) v2(162.51,125.76) v2(162.51,124.36) v2(162.51,122.96) v2(163.21,139.76) v2(163.21,138.36) v2(163.21,136.96) v2(163.21,135.56) v2(163.21,134.16) v2(163.21,132.76) v2(163.21,132.06) v2(163.21,129.96) v2(163.21,128.56) v2(163.21,127.16) v2(163.21,125.76) v2(163.21,124.36) v2(163.91,136.96) v2(163.91,120.16) v2(163.91,119.46) v2(164.61,139.76) v2(164.61,138.36) v2(164.61,136.96) v2(164.61,135.56) v2(164.61,134.16) v2(164.61,132.76) v2(164.61,129.96) v2(164.61,127.16) v2(164.61,125.76) v2(164.61,124.36) v2(164.61,122.96) v2(165.31,127.16) v2(165.31,124.36) v2(166.01,139.76) v2(166.01,138.36) v2(166.01,136.96) v2(166.01,135.56) v2(166.01,134.16) v2(166.01,132.76) v2(166.01,129.96) v2(166.01,127.16) v2(166.01,125.76) v2(166.01,124.36) v2(166.01,122.96) v2(166.71,132.06) v2(166.71,129.96) v2(166.71,128.56) v2(166.71,127.16) v2(167.41,139.76) v2(167.41,138.36) v2(167.41,136.96) v2(167.41,135.56) v2(167.41,134.16) v2(167.41,132.76) v2(167.41,131.36) v2(167.41,130.66) v2(167.41,129.96) v2(167.41,128.56) v2(167.41,127.16) v2(167.41,125.76) v2(167.41,124.36) v2(167.41,122.96) v2(168.11,135.56) v2(168.11,125.76) v2(168.11,120.86) v2(168.11,120.16) v2(168.11,119.46) v2(168.81,139.76) v2(168.81,138.36) v2(168.81,136.96) v2(168.81,135.56) v2(168.81,134.16) v2(168.81,132.76) v2(168.81,130.66) v2(168.81,129.96) v2(168.81,128.56) v2(168.81,127.16) v2(168.81,125.76) v2(168.81,124.36) v2(168.81,122.96) v2(168.81,120.86) v2(168.81,120.16) v2(170.21,139.76) v2(170.21,136.96) v2(170.2,134.16) v2(170.21,131.36) v2(170.21,129.96) v2(170.21,124.36) v2(170.21,122.96) v2(170.91,120.16) v2(170.91,119.46) v2(170.91,118.76) v2(172.23,120.84) v2(172.23,119.32) v2(173.02,120.82) v2(173.56,119.35) v2(173.63,118.74) v2(173.71,118.06) v2(173.71,117.36) v2(173.71,116.66) v2(173.71,115.96) v2(173.71,114.57) v2(174.29,118.81) v2(175.11,118.06) v2(175.11,117.36) v2(175.11,116.66) v2(175.11,115.96) v2(175.11,115.26) v2(176.47,119.52) v2(176.51,117.36) v2(176.51,116.66) v2(176.51,115.96) v2(176.51,115.26) v2(176.51,113.16) v2(177.91,115.96) v2(177.91,115.26) v2(177.91,113.16) v3(147.16,95.65) v3(147.21,94.86) v3(147.47,96.36) v3(148.1,95.85) v3(148.1,95.09) v3(148.23,96.64) v3(148.86,95.85) v3(148.86,95.09) v3(149.04,96.61) v3(149.63,95.09) v3(149.68,95.9) v3(149.85,96.66) v3(152.5,90.9) v3(152.5,90.14) v3(152.5,89.37) v3(152.52,87.27) v3(152.57,86.4) v3(152.62,85.59) v3(152.65,84.8) v3(153.39,91.66) v3(153.39,90.9) v3(153.39,90.14) v3(153.39,89.37) v3(153.41,87.27) v3(153.46,86.4) v3(153.51,85.59) v3(153.54,84.8) v3(154.2,91.79) v3(154.2,91.02) v3(154.2,90.26) v3(154.99,91.81) v3(154.99,91.05) v3(154.96,90.26) v3(155.8,90.24) v3(157.5,90.27) v3(158.52,90.27) v3(158.64,84.62) v3(159.02,88.48) v3(159.02,87.72) v3(159.02,86.96) v3(159.02,86.2) v3(159,85.39) v3(159.43,84.6) v3(159.53,90.27) v3(159.79,88.48) v3(159.79,87.72) v3(159.79,86.96) v3(159.79,86.2) v3(159.79,85.36) v3(160.19,84.62) v3(160.55,90.27) v3(160.55,88.46) v3(160.55,87.7) v3(160.55,86.94) v3(160.55,86.17) v3(160.55,85.39) v3(160.95,84.62) v3(161.31,88.48) v3(161.31,87.72) v3(161.31,86.96) v3(161.31,86.2) v3(161.31,85.39) v3(161.69,90.27) v3(161.74,84.67) v3(162.07,88.48) v3(162.07,87.72) v3(162.07,86.96) v3(162.07,86.2) v3(162.1,85.44) v3(162.5,84.62) v3(162.83,90.27) v3(162.83,88.51) v3(162.83,87.7) v3(162.83,86.94) v3(162.83,86.17) v3(162.86,85.39) v3(163.27,84.62) v3(163.6,88.48) v3(163.6,87.72) v3(163.6,86.96) v3(163.6,86.2) v3(163.62,85.39) v3(163.98,90.27) v3(164.13,84.6) v3(164.36,88.48) v3(164.36,87.72) v3(164.36,86.96) v3(164.36,86.2) v3(164.49,85.36) v3(164.99,90.27) v3(166.01,90.27) v3(167.03,90.27) v3(169.59,88.84) v3(169.64,85.44) v3(169.59,84.67) v3(169.67,87.72) v3(169.67,86.96) v3(169.69,86.2) v3(170.28,88.48) v3(170.43,87.72) v3(170.43,86.96) v3(170.4,85.44) v3(170.35,84.67) v3(170.45,86.2) v3(171.11,87.32) v3(171.11,86.55) v3(171.11,85.74) v3(171.14,84.98) v3(171.85,86.94) v3(171.85,86.17) v3(171.85,85.39) v3(189.28,108.09) v3(189.25,102.07) v3(189.76,102.71) v3(190.04,107.31) v3(190.01,106.52) v3(190.01,105.76) v3(190.01,104.99) v3(190.01,104.23) v3(190.01,103.47) v3(190.06,108.09) v3(190.82,108.09) v3(190.8,107.31) v3(190.77,106.52) v3(190.77,105.76) v3(190.77,104.99) v3(190.77,104.23) v3(190.77,103.47) v3(191.54,106.52) v3(191.54,105.76) v3(191.54,104.99) v3(191.54,104.23) v3(191.59,108.09) v3(191.56,107.31) v3(192.35,108.09) v3(192.32,107.31) v3(192.3,106.52) v3(192.3,105.76) v3(192.3,104.99) v3(193.09,107.31) v3(193.06,106.52) v3(193.06,105.76) v4(175.1,121.58) v4(181.21,121.5)
NVVDD_CORE1_EN: length 91.3
  TOP w0.254: PR9002.2 148.49,71 v1(148.51,70.98)
  IN4 w0.254: v1(123.44,120.74) 123.77,120.41 123.77,117.06 122.12,115.41 122.12,113.63 121.69,113.2 121.69,112.26 121.51,112.08 121.51,111.68 121.03,111.19 121.03,110.23 122.68,108.58 124.78,108.58 126.49,106.87 126.49,104.39 129.5,101.38 129.5,88.73 127.66,86.88 127.66,78.32 128.99,76.99 131.91,76.99 134.13,79.21 135.28,79.21 136.29,78.2 136.29,76.71 136.83,76.17 146.96,76.17 148.9,74.22 148.9,71.59 148.51,71.2 v1(148.51,70.98)
  BOTTOM w0.14: v1(123.44,120.74) 123.36,120.82 117.95,120.82 117.36,120.23 R21611.2 116.85,120.62 115.84,120.62 R21612.1 C95149.2 114.04,119.54 D8592.1
NVVDD_PG_LOOP_OVT: length 46.1
  TOP w0.14: v1(146.83,103.34) 147.21,103.72 147.72,103.72 148.1,103.34 148.1,102.71 148.23,102.58 149.23,102.58 149.96,101.85 151.96,101.85 152.15,102.05 153.27,102.05 155.45,104.23 156.48,104.23 156.87,104.61 156.87,106.29 157.32,106.75 R21609.2
  IN5 w0.089: v1(146.83,103.34) 146.45,103.72 145.18,103.72 144.75,104.16 144.75,105.07 139.67,110.15 135.73,110.15 135.15,110.74 135.15,114.22 134.39,114.98 132.92,114.98 132.28,115.61 128.52,115.61 128.39,115.74 v1(128.39,116.7)
  BOTTOM w0.14: Q7863.2 126.12,116.04 126.5,116.41 Q7865.3 127.04,116.41 127.53,115.92 Q7864.3 128.23,115.92 128.39,116.08 v1(128.39,116.7)
NVVDD_PSI#: length 10.2
  TOP w0.127: U13114.BD2 143.75,119.11
  TOP w0.14: 143.75,119.11 143.34,119.52 142.59,119.52 140.76,117.69 140.16,117.69 139.91,117.94 138.49,117.94 138.47,117.92 137.77,117.92 137.18,118.51 v1(137.18,118.79) 137.1,118.87 R21591.2 135.91,118.87 135.87,118.83 R21574.1
NVVDD_PWM_GPU: length 89.3
  TOP w0.14: v2(146.41,119.46) U13114.BD6
  IN1 w0.203: v2(146.41,119.46) 146.98,120.04 146.98,120.57 146.48,121.07 146.48,121.66 146.07,122.06 144.06,122.06 143.75,121.75 140.62,121.75 140.1,122.27 138.33,122.27 137.82,121.75 132,121.75 131.55,121.3 128.51,121.3 124.96,117.75 124.96,117.01 124.12,116.17 123.51,116.17 122.7,115.36 122.7,114.65 122.85,114.49 123.46,114.49 123.69,114.72 123.69,114.9 124,115.21 125.24,115.21 125.62,114.82 125.62,114.14 126,113.76 126,109.49 126.99,108.5 126.99,100.33 130.47,96.84 130.47,88.84 128.8,87.16 128.8,84.06 127.96,83.22 127.96,77.46 129.5,75.92 130.94,75.92 133.5,73.37 135.22,73.37 136.65,74.79 137.92,74.79 v1(138.15,75.02)
  BOTTOM w0.203: PR9022.1 138.58,74.01 138.15,74.44 v1(138.15,75.02)
NVVDD_SENSE2_IN_N: length 14
  TOP w0.254: PR67198.2 128.82,75.46 v1(128.82,75.02)
  IN1 w0.254: v1(134.39,67.66) 133.88,67.66 133.5,68.04 133.5,71.78 131.05,74.22 128.78,74.22 128.6,74.4 128.6,74.8 v1(128.82,75.02)
  BOTTOM w0.14: v1(135.05,68.39) 135.05,68.32 v1(134.39,67.66)
  BOTTOM w0.254: PR119.2 134.26,67.53 v1(134.39,67.66)
NVVDD_SENSE2_IN_P: length 14.6
  TOP w0.254: v1(128.16,75.02) 128.16,75.54 PR67197.2
  IN1 w0.254: v1(128.16,75.02) 128.26,74.93 128.26,74.26 128.64,73.88 130.91,73.88 133.15,71.64 133.15,67.9 134.05,67 v1(134.39,67)
  BOTTOM w0.14: v1(134.59,66.29) 134.59,66.79 v1(134.39,67)
  BOTTOM w0.254: v1(134.39,67) 133.95,66.56 PR67194.2
NVVDDPG: length 115.1
  TOP w0.14: R21615.2 125.37,112.61 v1(125.34,112.64) 124.45,112.64 123.86,113.23 U13120.1 ; D8595.1 124.24,120 v1(124.48,120.23)
  IN1 w0.203: v1(125.34,112.64) 125.37,112.61 125.37,110.46 124.61,109.69 124.61,101.84 130.09,96.35 130.09,88.87 128.51,87.29 128.51,84.18 127.67,83.34 127.67,77.32 129.36,75.63 130.82,75.63 133.46,72.99 136.67,72.99 v1(137.69,74.01)
  IN2 w0.089: v1(124.48,120.23) 124.48,119.57 124.92,119.13 125.25,119.13 125.52,118.86 125.52,116.45 125.75,116.22 125.75,113.25 125.34,112.84 v1(125.34,112.64)
  IN3 w0.203: v1(163.67,64.23) 163.32,64.23 162.79,63.69 156.15,63.69 155.74,64.1 149.99,64.1 146.59,67.5 146.59,71.84 144.42,74.01 v1(137.69,74.01)
  BOTTOM w0.14: v1(125.34,112.64) 125.81,112.64 126.32,113.15 128.29,113.15 128.55,113.41 R67325.1 128.55,114.03 128.39,114.19 128.39,115.61 128.64,115.87 128.93,115.87 129.07,116 Q7864.2 ; R21610.2 v1(124.48,120.23)
  BOTTOM w0.203: v1(137.69,74.01) 137.19,73.51 PR9018.1 138.01,72.55 138.56,72.55 139.66,71.45 139.66,70.57 139.78,70.45 PU9001.32
  BOTTOM w0.254: v1(163.67,64.23) 163.67,63.26 164.89,62.04 PR9065.1
NVVDDPG_R: length 16.2
  TOP w0.14: v1(121.05,113.96) 121.94,113.07 121.94,112.74 122.56,112.12 U13120.4 122.56,110.85 122.75,110.66 125.06,110.66 125.37,110.96 R21615.1 R21614.2
  BOTTOM w0.14: v1(121.05,113.96) 120.42,114.6 120.42,115.66 119.91,116.17 119.91,118.2 120.29,118.58 D8594.2 120.63,119.18 121.08,119.63 C95150.1 R21613.2
NVVDDPG_RRR: length 3.2
  BOTTOM w0.14: Q7863.1 126.38,115.04 v1(126.61,114.8) 126.72,114.7 126.72,114.15 126.77,114.09 R67326.2 R67325.2
NVVDDS_PSI: length 70.1
  TOP w0.203: PR67009.2 110.66,72.71 110.21,73.17 v1(110.21,73.37)
  IN1 w0.089: v1(110.21,73.37) 110.76,73.93 110.76,75.04 113.54,77.81 124.46,77.81 126.77,80.12 126.77,83.65 127.51,84.39 127.51,87.62 129.26,89.37 129.26,96.01 122.82,102.45 122.82,110.83 v1(123.21,111.22)
  BOTTOM w0.14: R21582.2 133.48,115.15 132.85,114.52 131.72,114.52 131.59,114.65 131.16,114.65 130.75,114.24 130.75,113.3 130.32,112.87 126.77,112.87 124.53,110.63 123.79,110.63 v1(123.21,111.22)
NVVDDS_PSI_R: length 12.6
  TOP w0.127: v2(145.71,118.06) U13114.BE5
  BOTTOM w0.14: R21582.1 135.63,115.15 135.68,115.21 v1(136.62,115.21) 137,115.21 137.45,115.66 138.55,115.66 138.93,116.03 R21597.2 139.54,116.17 139.97,115.74 141.22,115.74 142.77,117.29 143.35,117.29 143.72,117.66 145.31,117.66 v2(145.71,118.06)
NVVDDS_VID: length 6.9
  TOP w0.127: v2(145.01,118.06) 145.36,118.41 U13114.BE4
  BOTTOM w0.14: v2(145.01,118.06) 144.92,118.06 144.47,118.51 144.01,118.51 143.17,117.67 141.77,117.67 141.42,117.31 140.08,117.31 v1(140,117.24) 139.95,117.19 R67331.2
OVERT#: length 20.3
  TOP w0.127: U13114.BG5 146.06,117.01 v2(145.7,116.66)
  TOP w0.14: v1(133.85,113.15) 133.85,112.68 134.58,111.95 134.59,111.95 134.82,111.73 134.92,111.73 135.13,111.51 Q7861.1 135.13,110.9 135.52,110.52 R21603.1 135.15,110.2 134.99,110.36 R21601.2
  BOTTOM w0.14: v2(145.7,116.66) 145.26,117.1 144.13,117.1 143.71,116.68 142.95,116.68 141.37,115.1 137.68,115.1 136.55,113.97 135.47,113.97 135.12,114.32 134.14,114.32 133.69,113.87 133.69,113.31 v1(133.85,113.15)
OVERT#_R: length 49.7
  IN5 w0.089: v1(117.17,70.47) 117.94,71.24 122.51,71.24 125.34,74.07 125.34,84.24 126.49,85.39 126.49,89.07 128.04,90.61 128.04,93.08 127.3,93.82 127.3,102.06 127.9,102.66 127.9,104.6 v1(125.78,106.72)
  BOTTOM w0.14: D13088.1 123.88,108.2 124.42,107.66 124.84,107.66 v1(125.78,106.72) ; v1(117.17,70.47) 117.66,70.47 117.92,70.21 PR67226.2 v1(118.81,70.21)
PA_USB2_RBIAS: length 2.3
  TOP w0.14: v4(352.32,50.24) U21.H19
  BOTTOM w0.14: v4(352.32,50.24) 352.19,50.11 352.19,48.63 R20848.2
PB_USB2_RBIAS: length 2.6
  TOP w0.14: v4(352.97,50.24) U21.F19
  BOTTOM w0.14: v4(352.97,50.24) 352.47,49.74 352.47,48.84 352.8,48.5 R22147.1
PCBEEP_EC: length 183.2
  TOP w0.14: v1(178.71,49.11) 178.71,49.47 178.94,49.7 179.67,49.7 179.93,49.95 179.93,50.18 180.4,50.66 U49.34 ; D13038.2 17.17,35.15 16.69,35.63 v1(16.43,35.63)
  IN1 w0.089: v1(178.71,49.11) 178.71,49.09 178.23,49.57 177.82,49.57 177.49,49.24 177.49,48.81 176.3,47.62 100.22,47.62 97.01,44.4 84.94,44.4 84.21,43.67 77.63,43.67 76.3,42.33 75.74,42.33 75.44,42.64 72.63,42.64 71.81,43.46 70.58,43.46 69.77,42.66 68.24,42.66 67.48,41.9 67.48,41.06 67.3,40.89 65.22,40.89 64.33,41.77 63.58,41.77 63.18,42.17 63.18,42.45 62.7,42.93 61.66,42.93 61.5,43.1 59.86,43.1 59.46,43.5 59.46,44.67 58.57,45.55 51.73,45.55 51.18,45 49.96,45 48.92,46.04 46.76,46.04 46.27,45.56 38.58,45.56 36.29,43.27 32.68,43.27 32.26,43.7 24.95,43.7 23.49,42.23 23.49,38.29 21.79,36.59 17.72,36.59 16.76,35.63 v1(16.43,35.63)
PCH_2_CPU_TRIG: length 201.2
  TOP w0.079: U41.H23 229.46,120.93 v1(228.83,120.93)
  TOP w0.14: R21360.1 305.33,46.31 305,45.98 v1(305,45.66) ; v1(209.72,59.48) 209.32,59.48 207.56,57.73 207.56,56.67 206.01,55.12 206.01,54.5 202.99,51.48 200.45,51.48 199.83,50.86 v1(199.83,47.82) 199.83,46.98 199.69,46.84 v1(199.69,45.86)
  IN1 w0.089: v1(209.72,59.48) 208.7,60.5 208.7,67.71 209.32,68.33 209.32,69.05 209.44,69.18 209.44,71.2 211.37,73.13 211.37,88.15 218.85,95.63 218.85,99.53 222.73,103.41 222.73,104.21 225.72,107.2 225.72,119.42 226.84,120.54 228.44,120.54 v1(228.83,120.93)
  IN4 w0.089: v1(305,45.66) 304.34,45 289.07,45 286.69,47.38 272.08,47.38 269.7,45 262.44,45 262.18,45.26 203.4,45.26 202.36,46.3 200.13,46.3 v1(199.69,45.86)
PCH_2_CPU_TRIG_R: length 8.1
  TOP w0.112: 306.18,49.59 306.6,50 306.6,50.51 306.49,50.62 306.49,51.37 306.61,51.49 306.61,52.98 306.45,53.15 U13113.AL2
  TOP w0.14: v1(304.54,46.22) 304.57,46.22 305.44,47.09 R21360.2 305.58,47.36 306.06,47.84 306.06,49.46 306.18,49.59
PCH_AZ_CODEC_BITCLK: length 308.1
  IN2 w0.089: v1(317.75,51.05) 316.66,49.95 316.05,49.95 313.61,47.51 310.85,47.51 310.54,47.83 310.54,47.99 310.21,48.31 307.94,48.31 307.16,47.53 303.1,47.53 301.62,46.05 289.03,46.05 286.96,48.12 271.07,48.12 270.7,47.75 269.18,47.75 268.37,46.95 268.37,45.94 268.15,45.72 265.7,45.72 265.36,46.07 258.76,46.07 258.42,45.72 203.41,45.72 202.51,46.63 195.87,46.63 194.94,47.55 191.52,47.55 190.9,46.93 189.99,46.93 189.55,47.36 183.3,47.36 181.95,48.71 181.95,48.71 181.94,48.71 181.62,48.71 181.62,48.71 99.16,48.71 96.5,46.05 87.81,46.05 85.59,43.83 82.06,43.83 81.17,42.94 77.46,42.94 76.7,42.18 75.79,42.18 75.43,42.54 72.06,42.54 70.33,40.81 65.6,40.81 64.82,41.6 62.3,41.6 61.84,42.05 60.71,42.05 60.65,42.08 59.86,42.87 53.11,42.87 52.47,42.23 46.54,42.23 46.26,41.96 43,41.96 41.45,40.4 41.09,40.4 40.78,40.1 40.78,39 38.95,37.16 37.78,37.16 37.08,36.47 34.49,36.47 v1(34.34,36.62)
  BOTTOM w0.14: R21100.1 315.08,55.32 315.23,55.17 C94807.1 316.63,54.84 318.04,53.43 v1(318.04,52.98) 318.04,51.2 317.88,51.05 v1(317.75,51.05) ; v1(34.34,36.62) 33.68,35.96 32.46,35.96 32.27,36.14 R21454.2
PCH_AZ_CODEC_RST#: length 315.3
  TOP w0.14: v1(318.21,48.86) 318.16,48.86 317.52,49.5 R21102.1 ; Q7847.1 43.1,50.08 42.35,49.33 v1(41.64,49.33)
  IN2 w0.089: v1(318.21,48.86) 317.22,47.88 316.66,47.88 314.97,46.19 310.05,46.19 309.51,46.73 308.4,46.73 307.88,46.21 305,46.21 304.61,45.83 304.61,45.35 304.26,45 289.59,45 289.28,45.3 288.74,45.3 286.65,47.39 271.37,47.39 268.98,45 263.22,45 262.87,45.34 259.06,45.34 258.72,45 182.83,45 179.84,47.98 99.46,47.98 96.8,45.32 88.11,45.32 85.89,43.11 84.25,43.11 83.12,41.98 82.09,41.98 80.98,40.87 77.71,40.87 75.92,39.08 75.92,38.27 76.12,38.07 76.12,37.23 72.47,33.59 72.47,31.3 72.21,31.04 67.2,31.04 65.23,33 64.86,33 64.51,32.66 58.19,32.66 57.47,33.37 56.69,33.37 56.05,32.73 51.07,32.73 50.1,33.7 49.26,33.7 47.5,35.45 42.23,35.45 41.4,36.29 41.17,36.29 v1(40.79,36.67)
  IN4 w0.089: v1(41.64,49.33) 41.85,49.12 41.85,42.27 43.23,40.89 43.23,39.09 42.48,38.33 42.48,36.76 41.8,36.08 41.37,36.08 v1(40.79,36.67)
PCH_AZ_CODEC_RST#_PD: length 3.6
  TOP w0.14: Q7847.3 41.19,52.62 v1(40.69,53.13) 40.38,53.43 D8586.1
PCH_AZ_CODEC_SDIN0: length 310.1
  TOP w0.112: v1(314.22,55.21) 313.75,55.67 U13113.BE7
  IN2 w0.089: v1(314.22,55.21) 313.53,55.9 312.19,55.9 311.81,55.52 311.81,55.08 311.55,54.83 311.04,54.83 310.54,54.32 310.03,54.32 309.52,53.81 308.5,53.81 307.23,52.54 306.72,52.54 306.09,51.92 305.21,51.92 303.93,50.64 302.34,50.64 300.14,48.44 297.75,48.44 296.99,49.2 289.35,49.2 288.04,50.51 270.08,50.51 269.71,50.14 265.33,50.14 265.25,50.06 261.15,50.06 260.99,49.9 259.25,49.9 258.66,49.32 249.29,49.32 248.45,48.47 240.7,48.47 240.48,48.69 233.27,48.69 232.69,48.11 229.07,48.11 228.92,48.25 228.92,48.61 228.36,49.17 196.7,49.17 194.65,51.22 187.57,51.22 187.18,51.61 186.69,52.09 177.09,52.09 176.33,51.33 175.53,51.33 175.3,51.1 155.98,51.1 155.55,51.53 128.42,51.53 127.99,51.1 97.15,51.1 94.49,48.44 86.82,48.44 85.21,46.83 81.5,46.83 81,46.32 75.45,46.32 74.89,46.88 73.84,46.88 73.4,46.44 73.39,46.44 72.64,45.68 68.13,45.68 67.24,46.57 66.11,46.57 65.58,47.11 65.58,47.78 63.83,49.53 62.39,50.97 50.9,50.97 50.77,51.1 45.99,51.1 42.74,47.84 38.35,47.84 37.87,48.33 35.17,48.33 v1(34.95,48.56)
  BOTTOM w0.14: R21453.2 34.78,38.82 33.47,40.12 v1(33.47,43.48) 33.47,44.37 34.23,45.13 34.23,46.09 35.07,46.93 35.07,48.43 v1(34.95,48.56)
PCH_AZ_CODEC_SDOUT: length 307
  TOP w0.14: v1(33.37,36.66) 33.37,36.47 33.01,36.11 31.08,36.11 v1(30.98,36.01) 30.7,35.73 30.7,35.48 30.34,35.11 U13108.17
  IN2 w0.089: v1(314.48,54.57) 313.7,54.57 312.52,53.38 309.98,53.38 309.63,53.04 308.74,53.04 307.61,51.9 307.61,51.36 307.02,50.77 305.84,50.77 305.07,50 303.04,50 300.88,47.84 297.45,47.84 296.69,48.6 289.08,48.6 287.77,49.91 270.33,49.91 269.96,49.54 265.88,49.54 265.75,49.42 264.31,49.42 264.15,49.26 259.45,49.26 258.91,48.72 249.54,48.72 248.69,47.88 240.35,47.88 240.14,48.09 233.52,48.09 232.94,47.51 204.4,47.51 203.49,48.42 196.6,48.42 194.41,50.62 187.24,50.62 186.37,51.5 178.18,51.5 177.41,50.73 175.78,50.73 175.54,50.5 97.4,50.5 94.74,47.84 87.07,47.84 85.43,46.21 81.73,46.21 80.82,45.3 75.61,45.3 74.98,45.94 73.75,45.94 73.64,45.84 73.64,45.84 72.89,45.08 67.89,45.08 67.49,45.48 66.06,45.48 66.02,45.53 66,45.53 65.77,45.75 65.77,45.77 64.98,46.56 64.98,47.53 62.14,50.37 52.7,50.37 52.48,50.15 45.92,50.15 42.92,47.16 41.58,47.16 41.27,46.85 39.95,46.85 35.43,42.33 35.17,42.33 34.02,41.18 34.02,40.33 33.37,39.69 33.37,36.69 33.4,36.66 v1(33.37,36.66)
  BOTTOM w0.14: R21103.1 314.34,54.43 v1(314.48,54.57)
