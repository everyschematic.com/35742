# Allegro board DAZGLMB1ED0 dazglmb1ed0-d-ver a-165 (.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VCC0P9_CIO: length 1.8
  TOP w0.254: U21.R8 v4(348.42,55.44) ; U21.R9 v4(348.42,54.79) ; U21.R12 v4(348.42,53.49) ; U21.R11 v4(348.42,54.14)
VCC0P9_DP: length 8.3
  TOP w0.254: U21.L6 v4(351.02,55.44) ; U21.L12 v4(351.02,53.49) U21.L11 ; U21.V11 v4(347.12,54.14) ; U21.M8 v4(349.72,55.44) U21.M6 ; v4(347.12,53.49) U21.V12 U21.V13 ; U21.T12 v4(347.77,53.49) ; U21.L8 v4(351.02,54.79) ; U21.T11 v4(347.77,54.14)
  BOTTOM w0.203: C94584.2 350.81,53.28 v4(351.02,53.49) ; C94586.2 350.5,54.27 v4(351.02,54.79) ; C94585.2 350.64,55.82 v4(351.02,55.44) ; C94582.2 349.88,55.28 v4(349.72,55.44)
  vias: v1(346.83,52.82) v4(345.86,52.84)
VCC0P9_LVR: length 2.4
  TOP w0.254: U21.J11 v4(351.67,53.49) U21.H11 ; v4(352.32,50.89) U21.H18 ; v4(352.97,50.89) U21.F18
  BOTTOM w0.203: v4(351.67,53.49) 351.68,53.48 C94618.1
  vias: v1(353.94,48.71)
VCC0P9_PCIE: length 6.6
  TOP w0.254: v4(349.72,50.24) U21.M18 ; v4(349.72,50.24) U21.N18 ; v4(349.72,50.24) U21.N19 v4(349.72,49.59) ; U21.M13 v4(349.72,52.19) U21.M15 v4(349.72,51.54) U21.M16 U21.L18 350.79,50.47 350.79,50.01 U21.L19 v4(351.02,49.59)
  BOTTOM w0.203: C95993.2 349.99,51.81 v4(349.72,51.54)
  vias: v1(347.95,48.61)
VCC0P9_SVR: length 4.3
  TOP w0.254: U21.M9 U21.L9 v4(351.02,54.14) ; U21.J9 v4(351.67,54.14) ; U21.F12 v4(352.97,53.49) U21.F11 ; U21.E13 v4(353.62,52.19) ; U21.F15 v4(352.97,52.19) U21.F13 ; v4(353.62,53.49) U21.E12
  vias: v1(353.72,63.52) v1(356.33,63.9) v1(356.51,64.53) v1(356.99,63.52) v1(357.09,64.18) v4(352.32,52.19)
VCC0P9_SVR_IND:
  vias: v1(354.86,60.09)
VCC0P9_USB: length 0.9
  TOP w0.254: v4(348.42,50.89) U21.R16 ; U21.R15 348.75,51.86 v4(348.43,51.54)
VCC1V8A_TBTA_LDO: length 7.6
  TOP w0.14: 372.67,22.82 372.05,23.44 371.42,23.44 370.96,23.89 370.96,24.05 370.62,24.38 U13155.K1
  TOP w0.152: C96012.2 373.51,19.45 374.04,19.97 v1(374.04,20.84) 374.04,22.11 373.33,22.82 372.67,22.82
VCC1V8D_TBTA_LDO: length 4.9
  TOP w0.14: 364.89,24.15 364.89,24.48 365.22,24.81 365.94,24.81 U13155.A2
  TOP w0.152: 364.89,24.15 364.89,23.61 364,22.72 364,21.56 C96011.2
VCC3V3_FLASH: length 87.9
  TOP w0.14: 369.73,22.81 369.12,23.42 U13155.G1
  TOP w0.152: 369.73,22.81 369.84,22.7 369.84,21.94
  TOP w0.381: v1(369.88,19.92) 370.01,19.92 370.23,20.14 370.6,20.14 R67127.2 370.89,20.66 370.11,21.44 C96016.1 369.84,21.94 ; v1(336.77,68.77) 336.75,68.8 U13076.8 336.75,70.76 337.23,71.24 v1(337.59,71.24)
  IN3 w0.381: v1(367.1,35.84) 367.86,36.61 367.86,38.78 367.38,39.26 367.38,43.83 368.17,44.62 368.17,52.76 365.08,55.85 365.08,62.56 362.78,64.86 359.81,64.86 358.67,66.01 358.67,72.07 355.21,75.53 349.4,75.53 348.18,74.32 347.39,74.32 346.93,73.85 344.24,73.85 341.52,71.14 339.64,71.14 339.5,71.28 339.48,71.28 339.01,71.76 337.96,71.76 337.59,71.39 v1(337.59,71.24)
  BOTTOM w0.254: R67179.2 366.42,34.87 v1(366.54,34.99) ; v1(369.88,19.92) 369.61,19.65 368.96,19.65 367.78,20.82 R67140.2 R67139.2
  BOTTOM w0.381: v1(367.1,35.84) 370.16,35.84 370.66,35.35 R67115.1
VCC3V3_TBTA_SX: length 4.9
  TOP w0.081: U13155.H2 369.37,24.74 369.37,24.08
  TOP w0.14: 369.37,24.08 369.37,23.58 369.79,23.16 369.97,23.16 v1(370.3,22.83)
  BOTTOM w0.152: v1(369.64,22.93) 370.2,22.93 v1(370.3,22.83) 370.38,22.91 C96017.1
VCCGT_CS1: length 0.7
  BOTTOM w0.14: PR66845.2 PR66951.1
VCCGT_CS2: length 1.6
  BOTTOM w0.14: PR66846.2 261.82,158.77 v1(261.41,158.36) 261.72,158.06 PR66954.1
VCCGT_CSUMB: length 16.1
  TOP w0.14: v1(272.54,163.16) 272.16,163.54 PR66879.1
  TOP w0.203: v1(262.02,157.06) 262.3,157.34 PR66860.2 PR66852.1
  IN4 w0.089: v1(272.54,163.16) 272.23,163.47 271.93,163.47 266.44,157.98 262.94,157.98 v1(262.02,157.06)
VCCIO_VCCSENSE: length 1.9
  TOP w0.112: U41.H14 230.22,113.81 230.56,113.81
  TOP w0.114: v1(230.92,113.81) 230.56,113.81
  BOTTOM w0.14: R20816.1 230.91,113.81 v1(230.92,113.81)
VCCSA_CS1: length 38.4
  TOP w0.14: PR66957.1 v1(228.92,149.57)
  TOP w0.203: v1(258.59,159.35) 258.59,159.13 259.28,158.44 PR66847.2
  IN2 w0.203: v1(228.92,149.57) 228.92,149.93 238.04,159.05 244.04,159.05 245.03,160.04 247.65,160.04 248.08,160.47 257.47,160.47 v1(258.59,159.35)
VCCSA_CSUMC: length 15.8
  TOP w0.14: v1(272.54,164.02) 272.31,164.25 PR66881.1
  TOP w0.203: PR66862.1 261.26,157.84 v1(261.26,157.06)
  IN4 w0.089: v1(272.54,164.02) 272.21,163.7 271.83,163.7 266.34,158.21 262.38,158.21 261.26,157.09 v1(261.26,157.06)
VCCSA_PWM6: length 0.5
  TOP w0.14: PR66955.1 PR66839.2
VCCSA_VCCSENSE: length 87
  TOP w0.114: v1(232.98,131.36) 232.91,131.36 U41.M38
  TOP w0.14: PR66892.2 272.33,161.38 v1(272.36,161.41)
  IN1 w0.089: v1(232.98,131.36) 233.24,131.36 236.38,134.5 262.89,134.5 266.91,138.51 270.27,138.51 272.84,141.08 272.84,143.73 273.8,144.7 273.8,155.8 273.2,156.4 268.47,156.4 268.19,156.13 267.23,156.13 266.31,157.04 266.31,158.02 267.2,158.91 267.44,158.91 269.94,161.41 271.19,161.41 271.55,161.76 271.55,162.88 271.67,163.01 272.05,163.01 272.18,162.88 272.18,161.59 v1(272.36,161.41)
  BOTTOM w0.14: PR66890.1 R20819.1 232.27,137.79 232.98,137.08 v1(232.98,131.36)
VCCSA_VSSSENSE: length 87.6
  TOP w0.114: v1(232.98,130.71) 232.66,130.38 U41.M37
  TOP w0.14: v1(272.97,161.69) 272.64,162.02 272.16,162.02 272.05,162.12 PR66894.2
  IN1 w0.089: v1(272.97,161.69) 272.97,161.47 272.44,160.94 270.14,160.94 267.63,158.44 266.98,158.44 266.49,157.94 266.49,157.11 267.3,156.3 268.12,156.3 268.4,156.58 273.27,156.58 273.98,155.88 273.98,144.62 273.01,143.66 273.01,141.01 270.05,138.04 267.1,138.04 263.09,134.03 236.57,134.03 233.25,130.71 v1(232.98,130.71)
  BOTTOM w0.14: v1(232.98,130.71) 233.25,130.71 233.53,130.99 233.53,137.9 PR66896.1 R20820.1
VCCSENSE: length 71.7
  TOP w0.14: v1(244.79,130.71) 244.72,130.71 U41.AG37 ; PR66872.2 267.2,158.11 v1(267,157.9)
  IN1 w0.089: v1(244.79,130.71) 244.19,131.31 244.19,132.25 245.47,133.53 263.49,133.53 267.51,137.55 270.3,137.55 273.19,140.44 273.19,143.49 274.16,144.46 274.16,155.95 273.31,156.8 268.3,156.8 268.2,156.7 267.69,156.7 267.06,157.33 267.06,157.84 v1(267,157.9)
  BOTTOM w0.14: R552.1 248.97,139.49 v1(248.94,139.52) 248.72,139.52 PR66868.1 R20812.2 248.28,138.16 243.96,133.85 243.96,131.46 244.72,130.71 v1(244.79,130.71)
VCCST_PG: length 107.9
  TOP w0.14: v1(206.73,99.43) 206.54,99.62 D13069.1
  IN3 w0.079: v1(206.73,99.43) 207.31,98.85 209.8,98.85 216.29,92.36 263.79,92.36 272.85,101.42 274.2,101.42 279.5,96.12 279.5,91.69 283.62,87.57 283.77,87.57 284.62,86.72 284.62,86.57 286.15,85.04 286.17,85.03 286.19,85.03 286.21,85.01 286.23,85.01 290.24,85.01 v1(290.67,84.57)
  BOTTOM w0.14: v1(290.67,84.57) 290.95,84.29 R21166.2 ; U53.2 207.21,99.51 207.13,99.43 v1(206.73,99.43) 206.73,99.95 R204.1 206.42,100.22 205.8,99.6 R202.1
VCCST_PWRGD: length 25.6
  TOP w0.112: v1(229.48,113.05) 229.86,112.67 U41.H13
  IN2 w0.089: v1(211.93,104.33) 212.78,105.19 212.78,108.84 216.3,112.36 224.94,112.36 225.7,113.12 229.41,113.12 v1(229.48,113.05)
  BOTTOM w0.14: R179.2 210.65,103.89 210.84,104.08 C417.1 211.67,104.08 v1(211.93,104.33)
VCCST_PWRGD_EN_L: length 3.3
  BOTTOM w0.14: U13064.2 212.08,99.64 211.88,99.43 210.81,99.43 v1(210.69,99.56) 210.69,99.91 210.44,100.16 U53.4
VCCST_PWRGD_R: length 8.9
  TOP w0.14: v1(206.65,103.37) 206.54,103.48 D13069.2
  BOTTOM w0.14: v1(206.65,103.37) 207.12,102.9 R178.2 207.36,102.61 208,103.24 208.87,103.24 R20752.2 210.04,102.73 R179.1 211.28,103.11 211.43,102.95 U13064.4 210.69,102.36 v1(210.64,102.3)
VDD1V8:
  vias: v1(30.88,43.88)
VSS_GPU_SENSE: length 45.6
  TOP w0.203: PR9008.2 145.28,101.49 v1(145.84,100.93) 146.15,100.63 151.2,100.63 151.48,100.35 153.21,100.35 153.89,101.03 170.03,101.03 172.08,103.08 172.08,104.41 173.53,105.86 175.56,105.86 176.91,107.2 176.91,111.35 175.68,112.57 174.3,112.57 173.76,113.12 U13114.BM44 U13114.BL45
VSSIO_VSSSENSE: length 2
  TOP w0.112: 230.56,113.39 U41.J14
  TOP w0.114: 231.45,113.6 231.2,113.35 230.6,113.35 230.56,113.39
  TOP w0.14: v1(231.63,113.79) 231.45,113.6
  BOTTOM w0.14: v1(231.63,113.79) 231.61,113.81 R20817.1
VSSSENSE: length 70.8
  TOP w0.14: v1(244.64,131.52) 244.4,131.28 U41.AG38 ; v1(267.74,157.9) 267.74,158.24 PR66874.2
  IN1 w0.089: v1(244.64,131.52) 244.66,131.54 244.66,132.06 245.66,133.06 263.69,133.06 267.7,137.08 270.08,137.08 273.37,140.37 273.37,143.42 274.34,144.39 274.34,156.02 273.38,156.98 268.23,156.98 268.12,156.88 267.77,156.88 267.53,157.12 267.53,157.7 v1(267.74,157.9)
  BOTTOM w0.14: v1(244.64,131.52) 244.49,131.68 244.49,133.64 249.42,138.57 R552.2 251.07,140.43 R547.2 PR66878.1
1P35V_BOOT: length 3.4
  BOTTOM w0.14: PR2022.2 182.91,80.58 183.26,80.23 v1(183.26,79.7)
  BOTTOM w0.203: 182.16,80.53 181.58,80.53 181.53,80.59 PU2001.18
  BOTTOM w0.508: 182.16,80.53 182.19,80.56 182.78,80.56 PR2022.2
1P35V_CS: length 4.7
  BOTTOM w0.203: PU2001.13 179.12,82.87 179.52,83.28 181.3,83.28 181.53,83.05 v1(181.91,83.05) 182.16,83.3 PR2019.2
1P35V_FB: length 3.2
  BOTTOM w0.203: PU2001.6 177.06,79.33 177.06,78.71 176.54,78.19 PR2032.1 PR2033.1
1P35V_LGATE: length 5.2
  IN5 w0.508: v1(185.36,82.92) 182.11,82.92 181.27,82.08 v1(180.54,82.08)
1P35V_PGOOD: length 3
  BOTTOM w0.203: PU2001.10 177.81,81.39 177.94,81.52 177.94,82.44 177.67,82.72 v1(177.67,83.05) 177.62,83.1 177.62,83.85 PR2017.1
1P35V_PHASE: length 6.9
  IN2 w0.508: v1(185.97,82.16) 185.38,82.16 184.97,81.75 v1(181.91,81.75)
  BOTTOM w0.203: PU2001.16 181.26,81.39 181.63,81.75 v1(181.91,81.75)
  BOTTOM w0.508: v1(181.91,81.75) 182.74,81.75 PC2029.1
1P35V_S3: length 5.6
  BOTTOM w0.203: PC2022.1 176.13,80.19 PU2001.7 ; PC2022.1 175.82,79.86 175.04,79.08 PR2020.1 173.98,78.86 PR2029.1 ; PC2022.1 175.04,80.65 PR2027.2
1P35V_S5: length 7.7
  BOTTOM w0.203: PR2027.1 PC2021.1 ; PC2021.1 176.22,81.8 176.42,81.6 176.42,80.99 176.83,80.59 PU2001.8 ; PC2021.1 PR2018.1 175.82,83.07 175.56,83.33 174.29,83.33 v1(174.11,83.15) 173.71,82.74 PR67229.1
1P35V_TON: length 4
  BOTTOM w0.203: PU2001.9 176.94,80.99 176.78,81.14 176.78,82.03 v1(176.7,82.11) 176.45,82.36 176.45,83.1 175.67,83.88 PR2021.2
1P35V_UGATE: length 5.1
  IN5 w0.508: v1(181.73,81.09) 184.81,81.09 185.06,81.35 v1(185.67,81.35)
  BOTTOM w0.203: v1(181.73,81.09) 181.62,80.99 PU2001.17
1P35V_VDD: length 3.7
  BOTTOM w0.203: PR2024.2 181.01,83.69 PC2040.1 180.31,83.63 179.29,83.63 178.72,83.06 PU2001.12
1P35V_VDDQ: length 30.4
  TOP w0.203: v1(193.7,88.48) 194.03,88.82 PR2026.2
  IN1 w0.203: v1(177.59,78.83) 176.3,80.13 176.3,86.2 178.58,88.48 v1(193.7,88.48)
  BOTTOM w0.203: PU2001.5 178.32,78.57 177.64,77.89 PR2032.2 177.32,78.32 177.59,78.6 v1(177.59,78.83)
1P35V_VID: length 5
  BOTTOM w0.14: PR2030.1 179.21,84.34 179.04,84.51 179.04,85.84 v1(179.17,85.97)
  BOTTOM w0.203: PU2001.11 178.32,83.64 PR2031.1 179.05,83.88 179.15,83.98 179.16,83.98 PR2030.1
2ND_MBCLK: length 574.7
  TOP w0.14: Q7915.3 12.78,30.89 11.44,30.89 10.87,31.46 v1(10.87,31.64) ; v1(366.14,39.01) 366.08,39.06 Q7930.3 ; Q7909.3 313.24,81.51 v1(313.02,81.73) ; R20895.1 184.85,69.63 184.14,68.93 v1(184.14,68.9) 184.3,68.75 184.81,68.75 185.2,68.35 U49.115 185.2,65.81 185.44,65.57 185.44,64.29 186.76,62.97 186.76,60.83 185.85,59.91 185.85,58.21 185.15,57.52 185.15,56.74 185.51,56.38 187.02,56.38 190.05,53.35 192.51,53.35 195.42,50.44 195.42,49.14 194.36,48.07 v1(194.36,45.46)
  IN2 w0.089: v1(338.86,79.42) 338.86,78.96 339.75,78.07 349.02,78.07 349.16,78.21 354.34,78.21 355.26,77.28 355.26,75.96 357.3,73.92 357.3,66.89 359.34,64.86 360.67,64.86 362.27,63.26 362.27,57.43 359.07,54.23 359.07,49.36 365.32,43.12 365.32,39.82 v1(366.14,39.01)
  IN4 w0.089: v1(313.02,81.73) 313.02,81.79 313.25,82.02 330.81,82.02 333.01,79.82 338.45,79.82 v1(338.86,79.42) 338.86,79.29 340.11,78.03 341.76,78.03 341.93,77.87 341.93,76.96 339.59,74.62 339.59,74.06 338.25,72.72 338.25,69.71 335.3,66.75 335.3,65.37 335.45,65.22 335.45,63.58 334.58,62.7 334.58,59.19 335.81,57.95 335.81,54.71 336.37,54.14 337.31,54.14 338.3,55.13 v1(338.3,55.39)
  IN5 w0.089: v1(184.14,68.9) 183.22,69.82 177.63,69.82 173.23,65.42 173.23,64.38 172.52,63.66 172.52,61.28 170.53,59.29 167.81,59.29 167.56,59.05 163.99,59.05 163.84,58.89 163.71,58.89 163.26,58.44 162.34,58.44 162.24,58.53 154.54,58.53 153.73,59.34 152.18,59.34 152.03,59.19 145.81,59.19 144.64,60.36 133.5,60.36 132.18,59.05 126.52,59.05 126.02,59.54 122.74,59.54 121.33,60.95 v1(119.68,60.95) 119.3,61.33 118.89,61.33 118.31,60.75 118.31,60.34 118,60.03 109.48,60.03 106.62,57.17 92.63,57.17 90.35,54.88 84.58,54.88 82.03,52.33 78.14,52.33 77.27,53.2 73.8,53.2 73.04,53.96 69.83,53.96 69.41,54.37 69.41,59.12 68.45,60.09 68.45,61.43 66.61,63.27 66.61,65.78 65.64,66.75 62.82,66.75 60.87,68.7 60.87,69.14 59.72,70.29 56.76,70.29 56.43,69.96 54.83,69.96 52.83,67.96 52.83,67.71 48.86,63.75 46.38,63.75 45.85,64.27 37.83,64.27 37.45,63.89 31.89,63.89 29.74,61.74 29.74,61.02 27.1,58.38 27.1,56.49 26.33,55.72 26.33,54.28 v1(24.97,52.91) 23.43,51.38 22.68,51.38 21.33,50.03 21.33,45.83 21.66,45.5 21.66,43.88 21.36,43.58 21.36,37.96 21.66,37.66 21.66,35.61 21.21,35.16 20.24,35.16 19.62,35.78 17.59,35.78 17.01,35.2 15.64,35.2 13.28,32.83 11.55,32.83 10.87,32.15 v1(10.87,31.64) ; v1(194.36,45.46) 194.71,45.46 195.75,44.42 259.74,44.42 260.22,43.93 262.5,43.93 263.18,44.61 267.34,44.61 268.07,45.33 270.02,45.33 271.35,46.66 286.22,46.66 288.48,44.4 318.16,44.4 318.3,44.54 321.58,44.54 324.51,47.46 329.07,47.46 330.56,48.95 333.99,48.95 336.15,48.95 338.18,50.98 338.18,51.93 337.84,52.28 337.84,54.93 v1(338.3,55.39) ; v1(358.29,39.41) 358.49,39.61 361.65,39.61 361.65,39.61 365.53,39.61 v1(366.14,39.01)
  BOTTOM w0.14: v1(119.68,60.95) 119.6,61.03 119.6,62.81 120.87,64.08 R67276.1 ; R67408.1 358.61,38.22 358.39,38.45 358.39,38.77 358.29,38.87 v1(358.29,39.41) ; v1(24.97,52.91) 24.99,52.89 25.94,52.89 26.06,52.77 27.66,52.77 29.06,51.36 32.19,51.36 32.58,51.76 33.95,51.76 34.14,51.57 34.14,48.18 33.64,47.68 Q7947.3
2ND_MBCLK_THM: length 13.5
  TOP w0.14: v1(361.56,43.88) 361.6,43.92 U13092.8 362.82,44.43 v1(362.53,44.72) ; Q7930.4 367.24,39.06 367.3,39.12 R22100.2 367.76,38.9 v1(367.3,38.45)
  IN5 w0.089: v1(367.3,38.45) 367.3,40.96 366.36,41.91 363.54,41.91 v1(361.56,43.88)
2ND_MBDATA: length 569.8
  TOP w0.14: v1(15.74,34.21) 14.36,32.82 Q7915.6 ; R20896.1 183.65,69.55 183.48,69.38 v1(183.48,68.93) 183.48,68.7 183.97,68.22 184.6,68.22 184.8,68.02 U49.116 184.8,66.42 184.88,66.34 184.88,64.11 186.24,62.75 186.24,61.04 185.32,60.12 185.32,58.42 184.63,57.73 184.63,56.52 185.3,55.86 186.8,55.86 189.83,52.83 192.29,52.83 194.89,50.23 194.89,49.45 193.67,48.23 193.67,45.53 v1(193.59,45.46) ; Q7909.6 312.16,79.86 312.41,80.11 312.41,81.68 v1(312.36,81.73) ; Q7930.6 v1(366.84,40.64)
  IN2 w0.089: v1(334.79,81.01) 334.79,81.09 335.59,80.29 339.11,80.29 339.49,79.91 339.49,79.21 340.13,78.58 348.76,78.58 348.89,78.71 354.6,78.71 355.85,77.46 355.85,76.04 357.77,74.12 357.77,67.09 359.53,65.33 361,65.33 362.78,63.54 362.78,57.27 359.63,54.13 359.63,49.57 365.94,43.26 365.94,41.7 366.84,40.8 v1(366.84,40.64)
  IN4 w0.089: v1(337.94,55.95) 337.94,55.7 337.83,55.58 337.83,55.33 337.12,54.61 336.57,54.61 336.29,54.89 336.29,58.16 335.05,59.4 335.05,62.38 335.94,63.27 335.94,65.5 335.81,65.62 335.81,66.6 339.39,70.18 339.39,71.37 339.19,71.57 339.19,72.94 340.08,73.83 340.08,74.44 342.54,76.9 342.54,78.09 342.04,78.59 340.37,78.59 339.49,79.47 339.49,79.68 338.86,80.32 335.49,80.32 v1(334.79,81.01) 334.1,80.32 333.18,80.32 331.01,82.49 312.94,82.49 312.45,82.01 312.45,81.82 v1(312.36,81.73)
  IN5 w0.089: v1(193.59,45.46) 194.1,45.97 194.94,45.97 196.02,44.89 260.1,44.89 260.57,44.42 262.25,44.42 263.07,45.24 267.31,45.24 268.01,45.94 269.9,45.94 271.08,47.13 286.44,47.13 288.69,44.87 315.41,44.87 316.44,45.9 322.28,45.9 324.31,47.93 328.88,47.93 330.36,49.42 333.8,49.42 333.8,49.42 335.96,49.42 337.37,50.83 337.37,55.38 v1(337.94,55.95) ; v1(360.62,40.99) 360.62,41 361.53,40.09 365.76,40.09 366.06,39.79 366.4,39.79 366.84,40.23 v1(366.84,40.64) ; v1(183.48,68.93) 183.13,68.93 182.7,69.35 177.83,69.35 173.7,65.23 173.7,64.18 172.99,63.47 172.99,61.08 170.73,58.82 168.43,58.82 168.04,58.44 167.61,58.44 167.51,58.54 164.15,58.54 164.03,58.42 163.91,58.42 163.44,57.95 161.79,57.95 161.68,58.06 154.34,58.06 153.54,58.87 152.37,58.87 152.22,58.72 143.63,58.72 142.46,59.89 133.69,59.89 132.38,58.58 126.32,58.58 125.83,59.07 122.35,59.07 121.18,60.24 119.73,60.24 119.19,60.77 v1(119.02,60.77) 118.82,60.57 118.82,60.18 118.19,59.56 109.68,59.56 106.83,56.71 106.72,56.61 92.74,56.61 90.55,54.41 84.78,54.41 82.22,51.86 77.87,51.86 77,52.73 73.6,52.73 72.84,53.49 69.61,53.49 68.85,54.25 68.85,59.02 67.98,59.89 67.98,61.24 66.08,63.13 66.08,65.64 65.45,66.28 62.63,66.28 60.3,68.6 60.3,68.98 59.46,69.82 56.95,69.82 56.62,69.49 55.06,69.49 53.41,67.83 53.41,67.58 49.11,63.28 46.18,63.28 45.66,63.8 38.03,63.8 37.64,63.42 32.09,63.42 30.26,61.59 30.26,60.88 27.57,58.18 27.57,56.3 26.82,55.54 26.82,54.09 25.13,52.4 25.13,51.68 v1(25.14,51.67) 24.39,51.67 23.63,50.91 22.9,50.91 21.84,49.84 21.84,46.04 22.13,45.75 22.13,43.58 21.83,43.27 21.83,38.16 22.13,37.85 22.13,35.41 21.41,34.69 20.05,34.69 19.43,35.3 17.78,35.3 17.19,34.71 16.25,34.71 v1(15.74,34.21)
  BOTTOM w0.14: v1(360.62,40.99) 360.96,40.65 R67407.1 ; v1(119.02,60.77) 119.01,60.79 119.01,63.08 R67274.1 ; v1(25.14,51.67) 25.31,51.83 27.6,51.83 27.93,51.5 27.93,50.64 29.79,48.78 29.79,47.26 30.72,46.33 Q7947.6
2ND_MBDATA_THM: length 5.2
  TOP w0.14: Q7930.1 365.49,40.7 364.85,41.33 R22101.2 364.57,41.33 364.1,41.8 v1(364.1,43.2) 364.03,43.27 U13092.7
3ND_MBCLK: length 461.1
  TOP w0.14: Q7916.3 373.94,16.74 374.17,16.97 v1(374.17,17.41) ; v1(360.45,38.57) 360.27,38.75 R67266.1 359.69,38.06 360,37.75 Q7926.6 ; CN2076.14 139.05,62.1 v1(138.7,62.45) 139.14,62.88 v1(139.31,62.88) ; v1(195.9,45.89) 195.9,48 197.1,49.19 197.1,52.59 199.87,55.36 202.06,55.36 205.63,58.94 205.63,63.62 203.14,66.11 199.16,66.11 199.03,66.23 v1(198.04,66.23) 197.81,66.01 196.99,66.01 R22155.1 196.39,66.51 196.11,66.23 196.11,65.62 195.29,64.8 U49.94 ; v1(269.06,47.08) 269.06,47.18 269.5,47.62 Q7896.3 ; v1(35.92,89.59) CN2074.3
  IN1 w0.089: v1(327.76,50.56) 328.54,49.78 328.89,49.78 330.32,48.35 337.97,48.35 338.77,47.55 344.78,47.55 345.74,46.59 345.74,46.33 346.86,45.21 349.85,45.21 350.15,44.92 352.95,44.92 354.56,43.31 355.51,42.36 355.57,42.3 355.57,41.09 356.31,40.35 356.31,38.68 357.09,37.89 358.46,37.89 359.15,38.57 v1(360.45,38.57)
  IN2 w0.089: v1(89.81,51.1) 90.08,51.37 93.58,51.37 96.12,53.91 100.19,53.91 100.9,54.62 109.84,54.62 110.94,55.72 115.27,55.72 115.58,55.41 118.5,55.41 118.81,55.1 126.25,55.1 130.44,59.29 130.44,60.23 131.27,61.06 137.31,61.06 v1(138.7,62.45) 139.13,62.02 141.59,62.02 142.16,61.46 146.17,61.46 147.54,60.09 149.82,60.09 150.59,59.33 152.07,59.33 152.47,59.73 156.36,59.73 156.89,59.2 160.98,59.2 162.47,60.69 168.4,60.69 170.26,62.55 171.1,62.55 172,63.45 174.39,63.45 175.44,64.49 177.69,64.49 179.63,66.43 181.84,66.43 182.59,67.17 189.82,67.17 190.18,66.81 192.84,66.81 193.57,66.08 197.89,66.08 v1(198.04,66.23) ; v1(374.17,17.41) 372.98,18.61 372.58,18.61 369.38,21.81 366.19,21.81 365.01,22.98 365.01,28.67 364.71,28.97 364.71,32.94 362.22,35.43 362.22,36.03 361.97,36.29 361.59,36.29 361.21,36.67 360.7,36.67 360.45,36.92 v1(360.45,38.57)
  IN3 w0.079: v1(89.81,51.1) 88.95,51.95 87.95,51.95 86.12,50.12 74.86,50.12 74.12,50.86 70.32,50.86 67.7,53.48 66.35,53.48 65.89,53.95 64.64,53.95 62.45,56.13 62.05,56.13 59.31,58.88 57.56,58.88 57.29,59.15 47.75,59.15 45.55,61.36 40.09,61.36 38.36,63.09 37,63.09 34.85,65.24 34.85,88.51 v1(35.92,89.59)
  IN4 w0.089: v1(195.9,45.89) 195.9,46.03 196.34,46.46 196.68,46.46 196.84,46.29 197.06,46.07 197.06,45.69 197.34,45.42 197.73,45.42 198.04,45.73 198.04,46.52 199.23,47.71 203.04,47.71 203.36,47.4 230.44,47.4 230.81,47.77 239.42,47.77 240.51,46.67 266.38,46.67 266.97,47.26 268.5,47.26 268.68,47.08 v1(269.06,47.08) 269.59,47.62 270.3,47.62 271.49,48.81 287.26,48.81 288.93,47.13 291.34,47.13 293.15,48.95 299.05,48.95 300.58,50.47 303.04,50.47 303.59,51.02 304.95,51.02 305.46,50.51 306.22,50.51 306.82,49.91 313.44,49.91 313.76,50.23 315.95,50.23 316.07,50.35 316.78,50.35 317.35,49.79 321.16,49.79 321.37,49.57 322.35,49.57 323.22,50.45 324.51,50.45 325.18,51.12 327.2,51.12 v1(327.76,50.56)
3ND_MBCLK_P_KB: length 7.1
  TOP w0.14: Q7896.4 269.5,45.8 269.26,45.56 R21053.1 268.61,46.31 268.17,46.75 267.38,46.75 266.57,45.94 265.4,45.94 264.86,46.48 U13093.25
3ND_MBCLK_UIF: length 55.7
  TOP w0.14: v1(378.99,6.77) 378.38,6.77 378.32,6.72 U13152.25 ; Q7916.4 373.94,18.09 374.26,18.4 375.57,18.4 R67027.1 376.03,17.48 375.25,16.7 v1(375.25,16.5) ; R67266.2 358.26,38.75 358.06,38.95 357.53,38.95 v1(357.5,38.98)
  IN4 w0.089: v1(378.99,6.77) 378.45,6.77 377.7,7.53 377.7,9.56 373.45,13.81 373.45,15.18 374.62,16.35 375.1,16.35 v1(375.25,16.5)
  IN5 w0.089: v1(375.25,16.5) 373.98,16.5 372.51,17.97 370.29,17.97 369.62,18.64 364.71,18.64 363.23,20.11 363.23,31.47 362.83,31.87 362.83,31.92 357.14,37.61 357.14,38.73 357.4,38.98 v1(357.5,38.98)
3ND_MBDATA: length 458.8
  TOP w0.14: U49.95 194.87,65.2 195.45,65.78 195.45,66.36 196.48,67.39 R22156.1 196.48,67.67 197,68.19 v1(198.17,68.19) 199.21,68.19 v1(199.98,67.42) 200.76,66.64 203.4,66.64 206.19,63.85 206.19,58.76 202.27,54.84 200.16,54.84 197.62,52.3 197.62,48.75 196.57,47.69 v1(196.57,45.86) ; v1(370.47,19.56) 371.16,18.87 R67265.1 372.25,18.87 372.53,18.59 Q7916.6 ; v1(137.99,62.45) 138.55,61.89 CN2076.13 ; v1(270.5,47.13) 270.5,47.13 Q7896.6 ; v1(357.91,38.45) 357.65,38.19 357.65,37.25 358.15,36.75 Q7926.3 ; v1(34.67,89.57) CN2074.4
  IN1 w0.089: v1(327.05,50.56) 327.52,51.03 328.3,51.03 330.51,48.82 338.16,48.82 338.97,48.02 344.98,48.02 346.22,46.77 346.22,46.51 347.05,45.68 350.05,45.68 350.34,45.39 353.15,45.39 353.61,44.92 354.88,43.65 356.04,42.5 356.04,41.28 356.81,40.51 356.81,38.83 357.26,38.38 357.84,38.38 v1(357.91,38.45)
  IN2 w0.089: v1(370.47,19.56) 370.47,20.05 369.28,21.25 365.96,21.25 364.54,22.67 364.54,28.26 364.23,28.57 364.23,32.76 361.84,35.14 361.46,35.14 361.08,35.53 360.19,35.53 359.3,36.41 359.3,37.05 v1(357.91,38.45) ; v1(89.15,51.07) 89.15,51.17 89.82,51.84 93.39,51.84 95.93,54.38 100,54.38 100.71,55.09 106.88,55.09 108.19,56.4 115.26,56.4 115.63,56.03 118.51,56.03 118.88,56.4 124.99,56.4 128.79,60.2 129.7,60.2 131.03,61.53 137.07,61.53 v1(137.99,62.45) 138.02,62.45 138.53,62.96 139.09,62.96 139.55,62.49 141.79,62.49 142.35,61.93 147.56,61.93 148.27,61.21 149.41,61.21 150.82,59.8 151.87,59.8 152.28,60.2 158.04,60.2 159,61.16 168.21,61.16 170.06,63.02 170.9,63.02 171.8,63.92 174.2,63.92 175.25,64.96 177.49,64.96 179.43,66.9 181.65,66.9 182.39,67.64 190.02,67.64 190.38,67.28 198.13,67.28 198.52,66.89 199.46,66.89 v1(199.98,67.42)
  IN3 w0.079: v1(89.15,51.07) 88.73,51.49 88.15,51.49 86.32,49.66 74.53,49.66 73.8,50.4 70.13,50.4 67.51,53.02 66.16,53.02 65.7,53.49 64.45,53.49 62.26,55.67 61.86,55.67 59.12,58.42 57.37,58.42 57.14,58.64 47.61,58.64 45.36,60.9 39.9,60.9 38.17,62.63 36.77,62.63 34.39,65.02 34.39,89.28 v1(34.67,89.57)
  IN4 w0.089: v1(327.05,50.56) 325.29,50.56 324.7,49.98 323.42,49.98 322.53,49.09 321.13,49.09 320.9,49.32 317.15,49.32 316.59,49.88 316.27,49.88 316.05,49.67 313.86,49.67 313.64,49.44 305.13,49.44 304.31,50.26 303.55,50.26 303.19,49.89 300.66,49.89 299.25,48.48 293.35,48.48 291.53,46.66 288.74,46.66 287.07,48.34 271.71,48.34 v1(270.5,47.13) 269.87,46.5 268.52,46.5 268.31,46.71 267.08,46.71 266.57,46.2 240.2,46.2 239.1,47.3 231,47.3 230.64,46.93 203.16,46.93 202.85,47.24 199.54,47.24 198.52,46.22 198.52,45.55 197.92,44.95 197.14,44.95 196.59,45.5 196.59,45.58 196.57,45.61 v1(196.57,45.86)
3ND_MBDATA_P_KB: length 7.2
  TOP w0.14: U13093.26 265.07,46.98 265.58,46.47 266.37,46.47 v1(266.98,47.08) 267.18,47.29 267.95,47.29 R21052.1 268.37,47.46 269.19,48.28 270.28,48.28 270.5,48.06 Q7896.1
3ND_MBDATA_UIF: length 18.3
  TOP w0.14: R67265.2 371.52,17.62 371.95,17.19 372.41,17.19 372.53,17.07 Q7916.1 372.53,16.15 372.58,16.1 R67028.1 372.58,15.57 373.25,14.9 v1(373.26,14.9) 373.96,14.9 v1(373.98,14.93) ; U13152.26 378.91,7.22 378.93,7.2 379.16,7.2 379.18,7.18 379.33,7.18 379.37,7.22 379.52,7.22 379.8,7.5 v1(379.8,7.74)
  IN4 w0.089: v1(379.8,7.74) 379.8,7.64 379.42,7.26 378.68,7.26 378.17,7.77 378.17,9.76 373.98,13.94 v1(373.98,14.93)
700A_EN: length 230.1
  IN5 w0.089: v1(25.7,52.32) 25.75,52.37 28.22,52.37 32.13,56.28 32.13,61.33 32.81,62.02 35.2,62.02 35.71,61.5 49.37,61.5 55.37,67.5 56.54,67.5 57.43,68.4 59.35,68.4 62.09,65.66 62.09,63.4 66.13,59.35 66.13,55.06 66.67,54.53 67.14,54.53 69.19,52.47 72.46,52.47 73.19,51.74 76.59,51.74 77.46,50.87 82.63,50.87 85.18,53.42 90.99,53.42 92.54,54.96 99.7,54.96 100.32,55.59 107.54,55.59 108.66,56.71 111.48,56.71 112.02,57.26 114.05,57.26 115.25,58.46 115.36,58.57 117.42,58.57 118.51,57.48 125.8,57.48 125.91,57.59 133.8,57.59 134.45,58.23 141,58.23 141.94,57.29 146.15,57.29 146.41,57.55 148.91,57.55 149.58,56.88 156.45,56.88 157.04,56.29 168.95,56.29 169.33,56.68 170.36,56.68 171.73,58.05 172.09,58.05 173.29,59.25 173.29,59.99 174.04,60.74 174.04,63.07 175.61,64.64 175.61,65.32 176.47,66.18 178.39,66.18 180.04,67.83 187.85,67.83 189.4,69.38 191.76,69.38 v1(191.97,69.59)
  BOTTOM w0.14: v1(191.97,69.59) 192.53,69.02 193.85,69.02 194.24,68.63 194.24,68 193.36,67.12 193.36,64.94 193.03,64.6 R67341.1
  BOTTOM w0.254: v1(25.7,52.32) 24.81,52.32 21.99,49.5 21.99,43.1 20.42,41.52 20.42,38.42 19.07,37.08 19.07,35.09 17.9,33.93 R67342.1
1006_I2C_SCL: length 31.8
  TOP w0.14: v1(34.26,31.77) 34.08,31.94 33.65,31.94 33.37,31.66 U13108.7 ; U13157.4 35.72,44.55 36.67,45.51 v1(36.98,45.51)
  IN2 w0.089: v1(32.76,49.6) 33.07,49.3 33.07,49.17 33.27,48.96 33.75,48.96 34.06,48.66 34.06,47.84 34.4,47.5 37.01,47.5 37.98,46.54 37.98,45.75 37.95,45.72 37.95,45.7 37.76,45.51 37.74,45.51 37.71,45.47 37.21,45.47 37.18,45.51 v1(36.98,45.51)
  IN3 w0.079: v1(34.26,31.77) 34.35,31.77 36.04,33.47 36.04,34.31 36.8,35.07 36.8,37.3 37.54,38.05 37.54,44.94 v1(36.98,45.51)
  BOTTOM w0.14: Q7947.1 31.24,48.05 31.18,48.12 R67374.1 31.18,49.49 v1(31.21,49.52) 32.68,49.52 v1(32.76,49.6)
1006_I2C_SDA: length 28.7
  TOP w0.14: v1(37.51,45.94) 37.51,45.2 37.21,44.9 36.57,44.9 36.12,44.44 U13157.3 ; v1(33.75,31.36) 33.65,31.26 U13108.6
  IN2 w0.089: v1(37.51,45.94) 37.41,45.94 36.8,46.55 32.99,46.55 v1(32.94,46.6)
  IN3 w0.079: v1(37.51,45.94) 38,45.45 38,37.86 37.87,37.72 37.87,35.6 37.33,35.07 37.33,34.09 34.52,31.28 33.83,31.28 v1(33.75,31.36)
  BOTTOM w0.14: Q7947.4 32.24,45.76 32.08,45.6 R67373.1 32.38,45.38 32.79,45.79 32.79,46.45 v1(32.94,46.6)
1006_I2S_BCLK: length 24.6
  TOP w0.14: v1(33.83,33.11) 33.58,32.86 U13108.10
  IN3 w0.079: v1(38.6,50.46) 39.64,49.42 39.64,48.79 39.1,48.25 38.97,48.25 36.52,45.8 36.52,44.85 37.08,44.29 37.08,38.25 36.32,37.49 36.32,35.28 35.59,34.55 35.59,33.66 34.69,32.76 34.18,32.76 v1(33.83,33.11)
  BOTTOM w0.14: R67378.1 38.2,50.33 38.32,50.46 v1(38.6,50.46) 38.6,50.72 v1(39.08,51.2)
1006_I2S_BCLK_R: length 8.5
  TOP w0.14: v1(35.78,45.41) 35.59,45.21 35.14,45.21 34.89,44.96 34.89,44.61 34.92,44.59 U13157.6
  BOTTOM w0.14: R67378.2 38.52,49.55 38.7,49.37 38.7,47.72 38.47,47.48 C96244.1 37.57,46.85 36.91,46.85 v1(36.62,46.57) 36.15,46.1 36.15,45.77 v1(35.78,45.41)
1006_I2S_LRCK: length 19.9
  TOP w0.14: U13108.12 33.34,33.66 33.68,33.99 33.68,34.23 33.69,34.24 v1(33.69,34.27)
  IN3 w0.079: v1(33.69,34.27) 33.69,34.29 33.73,34.33 33.73,34.64 34.94,35.86 34.94,39.69 34.32,40.31 34.32,44.61 34.48,44.76 34.48,46.18 36.55,48.25 36.55,50.18 v1(36.22,50.51)
  BOTTOM w0.14: v1(36.22,50.51) 36.22,50.44 36.11,50.33 R67377.1
1006_I2S_LRCK_R: length 7.1
  TOP w0.14: v1(35.17,45.66) 35.02,45.66 34.59,45.23 34.59,44.78 34.52,44.71 U13157.7
  BOTTOM w0.14: R67377.2 36.31,49.55 36.65,49.22 36.65,47.79 36.33,47.48 C96245.1 36.11,47.18 35.15,46.22 35.15,45.69 v1(35.17,45.66)
1006_I2S_MCLK: length 22.8
  TOP w0.14: v1(34.46,33.9) 34.34,33.77 33.85,33.77 33.34,33.26 U13108.11
  IN3 w0.079: v1(39.26,50.51) 39.24,50.51 38.86,50.89 38.83,50.89 38.79,50.92 38.41,50.92 38.14,50.65 38.14,50.06 38.7,49.5 38.7,48.65 36.22,46.16 36.22,45.03 35.86,44.67 35.86,35.48 35.13,34.74 35.13,34.11 34.92,33.9 v1(34.46,33.9)
  BOTTOM w0.14: R67379.1 39.24,50.49 v1(39.26,50.51)
1006_I2S_MCLK_R: length 9.3
  TOP w0.14: U13157.5 v1(35.32,44.79)
  BOTTOM w0.14: v1(35.32,44.79) 35.88,44.79 36.49,45.41 36.49,45.79 37.15,46.45 37.89,46.45 v1(37.92,46.47) 38.3,46.85 39.14,46.85 39.24,46.96 C96243.1 39.56,47.48 39.75,47.67 39.75,49.24 39.44,49.55 R67379.2
1006_I2S_OUT: length 22.2
  TOP w0.14: v1(34.44,33.24) 34.44,32.95 33.95,32.46 U13108.9
  IN3 w0.079: v1(37.54,50.44) 37.64,50.33 37.64,48.69 34.94,45.99 34.94,45.98 34.78,45.82 34.78,45.5 34.94,45.34 34.94,44.97 34.92,44.95 34.92,44.62 34.94,44.61 34.94,44.57 34.92,44.55 35.4,44.06 35.4,35.67 34.19,34.45 34.19,34.18 34,34 34,33.71 34.08,33.63 34.08,33.6 v1(34.44,33.24)
  BOTTOM w0.14: v1(37.54,50.44) 37.13,50.03 R67376.1
1006_I2S_OUT_R: length 8.5
  TOP w0.14: U13157.8 34.12,44.65 34.34,44.87 34.34,45.66 34.84,46.17 35.58,46.17 v1(35.71,46.04)
  BOTTOM w0.14: v1(35.71,46.04) 35.71,46.44 36.34,47.07 36.43,47.07 36.85,47.48 C96246.1 37.48,47.48 37.64,47.64 37.64,49.19 37.28,49.55 R67376.2
1080Q_5VCC: length 3.6
  BOTTOM w0.203: PR9053.2 146.56,71.17 146.48,71.09 PC9017.1 v1(145.74,70.6) 145.59,70.6 145.04,70.05 PU9001.10
1080Q_8816ABOOT1:
  vias: v1(113.35,77.82)
1080Q_8816ABOOT2:
  vias: v1(118.33,77.79)
1080Q_8816AEN: length 5.8
  TOP w0.203: PQ9032.2 109.6,76.12 111.1,76.12 PR9123.1 111.66,76.04 111.64,76.01 PC9112.1 v1(112.44,75.61) 112.72,75.89 PU9009.3
1080Q_8816ALGATE1: length 7.8
  TOP w0.203: PU9009.19 114.89,78.24 114.83,78.3
  IN3 w0.61: v3(112.67,85.03) 113.51,84.19 113.51,82.08 114.7,80.89 114.7,79.59 114.49,79.38 v3(114.49,78.96)
  vias: v1(114.47,79.68)
1080Q_8816ALGATE2: length 9
  TOP w0.203: PU9009.17 115.69,78.27 115.79,78.38
  IN3 w0.61: v3(116.15,78.93) 116.15,80.59 117.85,82.29 117.85,84.47 118.46,85.08 v3(119.45,85.08)
  vias: v1(116.21,79.64)
1080Q_8816APG: length 6.7
  TOP w0.203: v1(118.35,76.01) 118.22,75.89 PU9009.13 ; v1(121.61,76.39) 121.42,76.2 PR9121.1 120.92,76.69 120.95,76.72 PR9217.2
  IN5 w0.203: v1(118.35,76.01) 121.23,76.01 v1(121.61,76.39)
1080Q_8816APHASE1: length 10.7
  IN5 w0.61: v3(113.76,79.98) 113.69,80.05 113.69,80.1 112.39,81.4 112.39,83.15 108.19,87.35 v3(107.17,87.35)
  vias: v1(113.3,91.74)
1080Q_8816APHASE2: length 12.9
  IN3 w0.61: v3(118.87,80.05) 119.35,80.54 120.22,80.54 121.91,82.24 121.91,89.4 121.1,90.21 v3(120.42,90.21)
  vias: v1(115.46,91.81)
1080Q_8816APSI: length 5.3
  TOP w0.203: PR9126.2 PR67009.1 PR9224.1 PR9124.2 112.24,74.64 113.08,75.49 PU9009.4
1080Q_8816APVCC: length 1.7
  TOP w0.203: 115.29,79.14 115.32,79.08 v1(115.31,79.04) 115.31,78.54 115.29,78.52 PU9009.18
  vias: v1(115.72,77.94)
1080Q_8816AREFIN: length 7.2
  TOP w0.203: 113.54,72.91 113.7,72.75 PR9129.2 ; 113.54,72.91 PC9126.1 113.92,73.32 114.46,73.32 114.89,73.74 PU9009.7 ; 113.54,72.91 113.54,72.1 113.38,71.94 PR9128.1 112.8,71.27 v1(112.62,71.09) 112.93,70.78 PR9131.2
1080Q_8816ARGDN: length 4.7
  TOP w0.203: PU9009.10 116.09,73.89 116.3,73.68 v1(116.78,73.68) 117.15,73.31 117.46,73.31 118.02,72.75 PC9128.1 PR9135.1 PC9127.1
1080Q_8816ASS: length 3.3
  TOP w0.203: PC9124.1 PR9147.1 118.93,75.49 118.39,75.49 v1(118.13,75.23) 117.87,75.49 PU9009.12
1080Q_8816ATON: length 2.7
  TOP w0.203: PR9145.1 PC9131.1 116.1,73.08 115.69,73.5 PU9009.9
1080Q_8816AUGATE1: length 1.2
  TOP w0.203: PU9009.2 112.85,76.29 112.57,76.57
  vias: v1(112.49,76.88)
1080Q_8816AUGATE1_1: length 12.4
  IN3 w0.61: v3(101.67,86.25) 102.71,86.25 108.86,80.1 v3(111.53,80.1)
  vias: v1(103.19,87.47)
1080Q_8816AUGATE2: length 1
  TOP w0.203: 117.9,76.29 PU9009.14
  vias: v1(117.98,76.55)
1080Q_8816AUGATE2_1: length 6.6
  IN5 w0.61: v3(119.78,79.54) 120.48,79.54 121.08,80.14 121.08,84.42 v3(120.54,84.95)
  vias: v1(120.52,79.47)
1080Q_8816AVREF: length 2.9
  TOP w0.203: PR9129.1 114.95,72.75 PC9121.1 115.29,72.9 PU9009.8
1080Q_8816AVSNS: length 5.9
  TOP w0.203: PC9129.1 PR9136.2 PR9138.1 119.5,74.44 119.47,74.47 PC9127.2 118.69,74.47 v1(118.12,73.91) 117.95,74.07 117.95,74.44 117.3,75.09 PU9009.11
1080Q_9336ADJ: length 3.4
  TOP w0.508: PU9005.5 v1(162.81,58.89)
  BOTTOM w0.508: v1(162.81,58.89) 162.63,59.07 PR9067.1 PR9066.2
1080Q_9336DRV: length 22.7
  TOP w0.14: PQ9009.4 160,61.32 159.84,61.15 v1(159.84,60.65) 160.85,60.65 161.66,59.84 PU9005.6 ; v1(146.73,57.12) 146.73,56.48 146.07,55.82 PD9003.1
  IN3 w0.079: v1(146.73,57.12) 147.3,57.69 156.85,57.69 159.81,60.65 v1(159.84,60.65)
  BOTTOM w0.14: v1(159.84,60.65) 159.84,61.15 160.32,61.64 PR9064.1
1080Q_COMP: length 4.4
  BOTTOM w0.203: PU9001.24 140.81,66.74 140.73,66.66 139.94,66.66 v1(139.69,66.41) 139.69,66.36 138.46,65.13 PC9009.1 PR9034.1
1080Q_CSNSUM: length 3.5
  BOTTOM w0.203: PR9240.2 146.26,65.78 145.41,66.63 v1(145.41,66.82) 145.41,67.49 144.9,68 144.85,68.05 PU9001.15
1080Q_CSPSUM: length 15.8
  BOTTOM w0.203: PR9049.1 155.65,63.47 155.32,63.8 154.22,63.8 154.07,63.64 PR9050.1 153.13,63.32 PR9046.1 152.75,63.3 PR9043.1 151.53,63.91 151.47,63.85 150.51,63.85 PR9045.1 149.55,64.8 PR9048.1 PC9015.1 147.4,64.15 146.76,64.15 v1(146.58,63.97) 146.32,64.24 PC9016.1 146.31,64.81 144.89,66.24 144.89,67.46 144.69,67.65 PU9001.16
1080Q_EAP: length 1.9
  BOTTOM w0.203: PU9001.23 141.21,66.42 141.15,66.36 141.15,66.36 140.93,66.14 140.93,65.95 140.43,65.45 PR9038.1
1080Q_EN: length 7.7
  TOP w0.203: v1(138.71,70.2) 139.12,70.2 139.64,70.73 v1(139.64,71.75) 139.64,72.8 PR9004.1 PR9001.2 139.83,74.44 PQ9001.3
  BOTTOM w0.203: v1(138.71,70.2) 138.92,70.2 139.47,69.65 PU9001.30
1080Q_FB: length 5.5
  BOTTOM w0.203: PR9017.2 PR9020.1 ; PR9020.1 137.93,66.51 137.68,66.27 PR9021.1 PR9027.2 ; PR9020.1 138.55,66.92 138.68,67.05 139.2,67.05 139.8,67.65 PU9001.25
1080Q_FBRTN: length 70.7
  TOP w0.203: PR9005.2 PR9008.1 144.16,101.3 143.53,100.68 143.53,99.66 142.9,99.03 v1(142.9,98.9) ; v1(139.03,67.63) 139.03,67.3 138.48,66.74 138.48,64.25 138.04,63.82 v1(138.04,63.11)
  IN5 w0.203: v1(137.93,70.53) 136.85,70.53 135.86,71.52 134.13,71.52 130.96,74.69 130.25,74.69 126.72,78.22 126.72,83.67 127.9,84.85 127.9,88.43 129.67,90.2 129.67,98.07 131.19,99.58 133.51,99.58 134.45,98.64 137.59,98.64 138.44,99.5 142.3,99.5 v1(142.9,98.9)
  BOTTOM w0.203: PC9001.1 138.8,63.34 138.27,63.34 v1(138.04,63.11) ; PU9001.26 139.53,68.05 139.11,67.63 v1(139.03,67.63) 138.86,67.63 138.5,67.99 138.5,68.28 PC9003.2 PC9004.1 v1(137.93,70.53) ; v1(138.81,74.87) 138.81,75.07 139.32,75.59 PC9007.2 PC9013.2 140.49,75.59 141.09,76.19 142.13,76.19 142.36,75.96 PR9036.2
1080Q_IMON: length 3.3
  BOTTOM w0.203: PR9040.1 PC9014.1 143.02,65.56 v1(143.02,65.78) 142.81,65.99 PU9001.19
1080Q_ISEN1: length 3
  BOTTOM w0.203: PR9235.2 146.17,66.74 145.83,67.08 145.83,67.58 144.96,68.45 PU9001.14
1080Q_ISEN2: length 2.5
  BOTTOM w0.203: PU9001.13 145.09,68.85 146.23,67.71 PR9239.2
1080Q_ISEN3: length 2.2
  BOTTOM w0.203: PR9243.2 145.97,68.67 v1(145.49,69.15) 145.39,69.25 PU9001.12
1080Q_ISEN4: length 4.2
  BOTTOM w0.14: PR9245.2 146.8,70.12 147.52,70.12 148.05,69.59 PR9237.2
  BOTTOM w0.203: PR9245.2 146.3,69.65 PU9001.11
1080Q_LPC: length 3.7
  TOP w0.203: v1(138.73,69.55) 138.73,69.41 138.22,68.9 PR9016.2 PR9026.1
  BOTTOM w0.203: v1(138.73,69.55) 139.08,69.55 139.18,69.45 139.38,69.25 PU9001.29
1080Q_PROG1: length 5.1
  BOTTOM w0.14: PR9023.1 144.3,64.97 143.86,64.54 143.86,63.87 143.86,63.86 143.86,63.21 144.11,62.97 PR9013.2
  BOTTOM w0.203: PR9023.1 144.37,65.17 143.21,66.33 PU9001.18
1080Q_PROG2: length 5.3
  BOTTOM w0.14: PR9024.1 145.48,64.97 145.82,64.63 145.82,63.72 146.07,63.47 PR9014.2
  BOTTOM w0.203: PR9024.1 145.15,64.97 145,65.12 145,65.35 v1(144.47,65.88) 144.24,65.88 143.61,66.51 PU9001.17
1080Q_PROG3: length 5.2
  BOTTOM w0.203: PR9015.2 141.19,62.99 140.91,63.27 140.91,64.59 141.45,65.13 PR9025.1 141.81,65.13 142.41,65.73 PU9001.20
1080Q_PSI: length 5
  BOTTOM w0.14: PR9010.2 136.07,71.08 v1(135.66,71.49)
  BOTTOM w0.203: PU9001.31 139.56,70.05 138.54,71.08 PR9019.1 PR9011.2 PR9010.2
1080Q_PWM1: length 5.2
  BOTTOM w0.14: v1(147.92,73.04) 147.92,73.03 PR9051.1
  BOTTOM w0.203: PR9051.1 146.93,73.03 146.45,72.55 145.97,72.55 145.71,72.3 145.71,71.42 144.75,70.45 PU9001.9
1080Q_PWM2: length 3.6
  BOTTOM w0.203: PR9047.1 145.96,73.03 144.93,72 v1(144.93,71.82) 143.83,71.82 143.61,71.61 PU9001.8
1080Q_PWM3: length 3
  BOTTOM w0.203: PR9044.1 144.48,72.38 143.9,72.38 143.41,71.89 143.27,71.75 143.27,71.75 143.21,71.69 PU9001.7
1080Q_PWM4: length 2.6
  BOTTOM w0.203: PU9001.6 142.81,71.69 142.83,71.72 142.83,71.91 143.47,72.55 143.55,72.55 144.03,73.03 PR9042.1
1080Q_REFADJ: length 2.9
  BOTTOM w0.203: PR9029.2 139.54,72.79 v1(140.1,72.23) 140.42,71.91 140.99,71.91 141.15,71.75 141.15,71.75 141.21,71.69 PU9001.2
1080Q_REFIN: length 8.5
  IN5 w0.203: v1(140.75,72.4) 141.35,72.4 143,74.05 v1(143,74.51)
  BOTTOM w0.203: PR9031.2 142.24,73.84 ; 142.24,73.84 142.24,73.96 PR9037.2 PC9013.1 ; 142.24,73.84 142.32,73.84 v1(143,74.51) ; PU9001.3 141.61,71.84 141.04,72.4 v1(140.75,72.4)
1080Q_SS: length 4.9
  BOTTOM w0.203: PC9001.2 PC9010.2 PR9033.2 140.36,64.62 140.85,65.1 140.85,65.35 141.32,65.83 141.32,66.04 141.5,66.22 141.5,66.22 141.55,66.27 141.55,66.29 141.61,66.35 PU9001.22
1080Q_VID: length 3
  BOTTOM w0.203: PU9001.1 140.46,71.15 PR9022.2
1080Q_VINMON: length 3.3
  TOP w0.203: PR9035.2 PR9032.1 141.85,65.54 v1(141.85,65.87)
  BOTTOM w0.203: PU9001.21 142.01,66.14 141.88,66.01 141.88,65.9 v1(141.85,65.87)
1080Q_VREF: length 2.9
  BOTTOM w0.203: PR9030.2 141.27,73.03 PC9012.1 141.46,72.63 142.01,72.08 142.01,71.7 142.01,71.69 PU9001.4
8068EN_1.8V: length 4.6
  TOP w0.14: v1(87.78,82.69) 87.98,82.49 89.01,82.49 PC9381.1
  TOP w0.203: PU9010.5 90.69,82.57 90.53,82.42 89.9,82.42 PC9381.1 PR100.2
8068FB_1.8V: length 6.6
  TOP w0.14: v1(87.44,77.55) PR98.2
  TOP w0.203: PU9010.6 90.69,80 90.44,80.24 89.43,80.24 PR101.1 PC9378.2 88.77,79.58 88.77,78.06 PR98.2
8068FB_1.8V_S: length 7.7
  TOP w0.203: PC9378.1 PR98.1 87.62,78.33 v1(87.6,78.35)
  BOTTOM w0.203: v1(87.6,78.35) 89.66,78.35 90.44,77.56 PR104.2
8068LX_1.8V: length 1.7
  BOTTOM w0.508: PR66969.1 93.61,85.38 93.14,84.9 v1(93.14,84.47)
  vias: v1(96.87,87.47)
8068NC_1.8V: length 2.7
  TOP w0.203: PC9376.1 89.92,78.36 90.75,79.19 90.98,79.19 91.19,79.4 PU9010.7
8068PG_1.8V: length 2.1
  TOP w0.14: PR102.1 v1(91.47,84.83)
  TOP w0.203: PR102.1 91.47,83.69 91.19,83.41 PU9010.4
8068SVIN_1.8V: length 5.2
  TOP w0.14: v1(90.42,76.9) 91.46,77.94 PR66968.2
  TOP w0.203: PU9010.8 91.69,79.37 91.13,78.81 90.9,78.81 90.29,78.2 PC9379.1 90.65,78.07 90.68,78.04 PR66968.2
9511_OUT1: length 43.3
  TOP w0.203: PR9075.2 v1(145.1,92.42)
  IN1 w0.203: v1(145.1,92.42) 145.1,89.88 149.14,85.84 149.14,79.14 147.53,77.52 147.53,77.32 147.54,77.31 147.54,73.43 147.39,73.28 145.99,71.87 145.99,66.72 148.5,64.22 153.37,64.22 153.82,64.66 v1(154.66,64.66)
  BOTTOM w0.14: PR9238.2 v1(155.6,66.77)
  BOTTOM w0.203: PR9238.2 155.6,65.6 v1(154.66,64.66)
9511_OUT2: length 38.9
  TOP w0.203: v1(142.06,81.2) 142.54,81.68 PR66976.2
  IN1 w0.203: v1(156.51,65.93) 156.15,65.57 156.15,62.75 155.24,61.84 149.63,61.84 145.29,66.18 145.11,66.36 145.11,72.23 146.67,73.79 146.67,76.69 142.16,81.2 v1(142.06,81.2)
  BOTTOM w0.14: PR9058.2 v1(157.42,66.64)
  BOTTOM w0.203: PR9058.2 156.77,65.67 v1(156.51,65.93)
9511_OUT3: length 32.1
  TOP w0.203: v1(156.41,80.66) 156.23,80.84 PR66978.2
  IN1 w0.203: v1(156.41,80.66) 156.05,80.31 152.12,80.31 148.76,76.95 148.76,72.97 147.16,71.38 147.16,67.2 148.13,66.23 152.52,66.23 153,66.72 v1(153.12,66.72)
  BOTTOM w0.14: v1(152.9,67.35) 153.12,67.14 v1(153.12,66.72)
  BOTTOM w0.203: PR9242.2 152.68,66.72 v1(153.12,66.72)
9511_OUT4: length 73.6
  TOP w0.203: v1(172.13,81.96) 172.03,81.96 171.34,81.27 167.2,81.27 167,81.47 PR66980.2
  IN1 w0.203: v1(154.63,65.35) 154.05,65.35 153.21,64.51 148.62,64.51 146.28,66.85 146.28,71.73 147.88,73.34 147.88,77.42 150.54,80.08 150.54,87.11 151.81,88.38 155.72,88.38 157.02,89.68 171.6,89.68 173.04,88.23 173.04,82.87 v1(172.13,81.96)
  BOTTOM w0.14: v1(154.27,66.74) 153.79,66.26 PR9060.2
  BOTTOM w0.203: v1(154.63,65.35) 154.63,65.37 154.28,65.72 PR9060.2
9511_PWM1_S: length 46.6
  TOP w0.14: PR9069.1 132.21,99.29 131.97,99.05 131.97,98.01 v1(131.85,97.88)
  IN5 w0.203: v1(131.85,97.88) 131.58,97.62 131.38,97.62 130.86,97.1 130.86,88.71 130.16,88.02 130.16,85.66 129.42,84.92 129.42,84.1 129.2,83.89 129.2,82.57 128.21,81.58 128.21,78.86 130.73,76.34 131.64,76.34 134.49,73.5 135.15,73.5 137.66,76.01 143.83,76.01 v1(144.22,75.63)
  BOTTOM w0.203: v1(144.22,75.63) 144.32,75.73 144.76,75.73 144.77,75.74 146.59,75.74 147.06,75.27 PR9051.2
9511_PWM2_S: length 37.2
  TOP w0.203: PR66991.1 127.29,87.18 127.76,87.65 128.52,87.65 128.82,87.34 v1(129.71,87.34)
  IN5 w0.203: v1(144.97,75.25) 144.74,75.25 144.67,75.18 143.99,75.18 143.44,75.72 137.78,75.72 135.27,73.21 134.37,73.21 131.54,76.04 130.62,76.04 127.91,78.75 127.91,83.18 129.13,84.4 129.13,86.76 v1(129.71,87.34)
  BOTTOM w0.203: PR9047.2 146.71,74.42 146.71,75.14 146.45,75.4 145.13,75.4 v1(144.97,75.25)
9511_PWM3_S: length 12.5
  TOP w0.203: v1(149.69,67.3) 150.09,67.3 PR66993.1
  IN5 w0.203: v1(149.69,67.3) 147.16,67.3 146.57,67.9 146.57,73.31 145.49,74.39 v1(145.49,74.74)
  BOTTOM w0.203: v1(145.49,74.74) 145.49,74.17 PR9044.2
9511_PWM4_S: length 26.3
  TOP w0.203: v1(162.11,66.89) 162.11,67.53 PR66995.1
  IN5 w0.203: v1(162.11,66.89) 162.11,66.93 161.4,67.63 150.69,67.63 149.92,66.86 149.51,66.86 149.37,67 147.01,67 146.27,67.73 146.27,73.04 v1(144.6,74.72)
  BOTTOM w0.203: v1(144.6,74.72) 144.17,74.29 PR9042.2
9511_SWN1: length 38.8
  TOP w0.203: PR9074.2 v1(144.27,92.42)
  IN1 w0.203: v1(144.27,92.42) 144.27,90.3 148.85,85.72 148.85,79.68 147.59,78.42 147.59,78.41 147.24,78.06 147.24,77.2 147.25,77.18 147.25,73.55 147.1,73.4 145.69,71.99 145.69,66.6 149.17,63.13 149.91,63.13 v1(149.93,63.11)
  BOTTOM w0.203: v1(149.93,63.11) 150.91,63.11 151.05,63.25 152.02,63.25 PR9043.2
9511_SWN2: length 30.6
  TOP w0.203: PR66975.2 141.47,81.65 v1(142.06,82.24)
  IN1 w0.203: v1(142.06,82.24) 142.06,81.88 146.96,76.98 146.96,73.67 146.81,73.52 145.4,72.11 145.4,66.48 149.31,62.58 151.28,62.58 v1(151.4,62.7)
  BOTTOM w0.203: v1(151.4,62.7) 151.58,62.53 152.01,62.53 v1(152.29,62.25) 152.56,62.52 PR9046.2
9511_SWN3: length 35.3
  TOP w0.203: PR66977.2 156.2,80.1 155.65,80.66 v1(155.65,80.86)
  IN1 w0.203: v1(155.65,80.86) 155.39,80.61 151.99,80.61 148.47,77.09 148.47,73.1 146.87,71.5 146.87,67.08 148.01,65.94 152.64,65.94 152.91,66.21 154.86,66.21 155.54,65.52 155.54,63.16 v1(154.91,62.53)
  BOTTOM w0.14: PR9049.2 155.84,62.39 v1(156.48,63.03)
  BOTTOM w0.203: PR9049.2 155.05,62.39 v1(154.91,62.53)
9511_SWN4: length 72.3
  TOP w0.203: v1(172.05,81.27) 171.7,80.92 167.33,80.92 167,80.59 PR66979.2
  IN1 w0.203: v1(154.86,63.21) 154.91,63.21 155.16,63.47 155.16,65.49 154.78,65.88 152.99,65.88 152.76,65.65 147.89,65.65 146.57,66.96 146.57,71.62 148.17,73.22 148.17,77.23 150.87,79.93 150.87,86.96 151.96,88.05 155.85,88.05 157.14,89.35 171.47,89.35 172.71,88.1 172.71,83.43 171.65,82.36 171.65,81.68 v1(172.05,81.27)
  BOTTOM w0.14: v1(154.07,61.71) PR9050.2
  BOTTOM w0.203: PR9050.2 154.19,62.54 v1(154.86,63.21)
24780_ACDET: length 2.7
  BOTTOM w0.178: PU1.6 70.24,52.81 70.1,52.67 69.82,52.67 69.57,52.42 PR31.2 PR211.2
24780_ACDRV: length 261.6
  IN5 w0.178: v1(71.22,51.81) 72.18,50.84 72.91,50.84 74.09,49.66 83.06,49.66 85.51,52.11 91.38,52.11 93.11,53.84 100.25,53.84 100.88,54.47 110.94,54.47 111.96,55.49 112.01,55.49 112.18,55.66 117.66,55.66 118.37,56.37 126.46,56.37 127.04,55.78 141.11,55.78 141.88,55.01 147.08,55.01 147.79,55.72 154.88,55.72 156.29,54.32 168.54,54.32 169.74,55.52 171.73,55.52 174.9,58.68 174.9,58.78 175.76,59.64 175.76,61.33 176.21,61.79 177.16,61.79 177.67,62.3 177.67,64.18 178.56,65.07 178.85,65.07 180.41,66.63 192.11,66.63 192.13,66.62 192.2,66.62 192.76,66.06 195.09,66.06 195.78,66.74 195.84,66.74 195.97,66.74 200.71,71.49 200.71,73.67 201.96,74.92 201.96,77.32 201.65,77.64 201.11,77.64 200.5,77.03 200.48,77.03 200.48,77.03 200.48,77 199.88,77 199.62,77.26 199.62,84.52 199.05,85.08 199.05,85.34 195.16,89.24 195.16,92.8 201.71,99.36 201.71,108.35 208.91,115.55 208.91,129.07 210.41,130.58 210.41,161.34 212.36,163.29 212.36,165.12 210.31,167.17 209.49,167.17 206.52,170.14 206.52,170.63 v1(206.6,170.7)
  BOTTOM w0.178: PU1.4 71.04,51.98 v1(71.22,51.81)
  BOTTOM w0.508: v1(206.6,170.7) 206.6,169.93 PR29.2
24780_ACN: length 256.7
  TOP w0.152: PR2.2 212.16,168.29 214.27,168.29 v1(214.4,168.42)
  IN5 w0.089: v1(75.31,50.94) 76.09,50.16 82.86,50.16 85.35,52.65 91.1,52.65 92.8,54.34 100.02,54.34 100.64,54.96 110.74,54.96 112.2,56.42 117.73,56.42 118.17,56.86 118.25,56.86 118.25,56.86 126.06,56.86 126.16,56.96 141.07,56.96 141.83,56.21 156.14,56.21 156.68,55.67 169.2,55.67 169.59,56.06 171.58,56.06 174.41,58.89 174.41,59.09 175.03,59.71 175.03,62.24 175.4,62.61 178.35,65.56 178.65,65.56 180.21,67.12 193.58,67.12 193.69,67.23 195.64,67.23 195.76,67.23 200.22,71.69 200.22,73.94 201.46,75.17 201.46,76.07 201.02,76.52 199.68,76.52 199.13,77.06 199.13,84.31 198.57,84.88 198.57,85.13 194.66,89.04 194.66,93 201.22,99.56 201.22,108.55 208.4,115.73 208.4,129.25 208.74,129.59 209.73,130.58 209.73,161.67 211.6,163.54 211.6,163.92 211.09,164.43 v1(211.09,164.56)
  BOTTOM w0.14: v1(211.09,164.56) 211.55,164.56 211.83,164.84 211.83,166.83 213.26,168.27 214.24,168.27 v1(214.4,168.42)
  BOTTOM w0.178: PC35.1 74.87,49.62 75.31,50.05 v1(75.31,50.94) 75.2,51.05 PC25.2 74.28,51.05 74.28,52.38 73.9,52.76 72.42,52.76 72.24,52.94 PU1.1
24780_ACP: length 259.2
  TOP w0.14: PR1.2 212.23,168 214.18,168 v1(214.42,167.76)
  IN5 w0.089: v1(72.54,51.81) 73.01,51.33 75.47,51.33 75.74,51.06 75.74,50.89 76.3,50.33 82.79,50.33 85.28,52.82 91.03,52.82 92.72,54.52 99.95,54.52 100.57,55.14 110.67,55.14 112.13,56.6 114.01,56.6 114.22,56.81 114.23,56.81 115.48,58.06 117.3,58.06 118.33,57.03 125.98,57.03 126.09,57.14 141.22,57.14 141.98,56.39 156.21,56.39 156.75,55.85 169.13,55.85 169.52,56.23 171.5,56.23 174,58.73 174,60.07 174.6,60.67 174.6,62.07 174.84,62.3 174.84,62.3 175.22,62.69 175.22,62.69 178.27,65.74 178.58,65.74 180.16,67.33 193.53,67.33 193.62,67.41 195.57,67.41 195.69,67.41 200.05,71.76 200.05,74.01 200.15,74.11 200.15,74.11 201.28,75.25 201.28,76 200.95,76.34 199.6,76.34 198.95,76.99 198.95,84.24 198.39,84.81 198.39,85.06 194.48,88.97 194.48,93.07 201.04,99.63 201.04,108.66 208.22,115.83 208.22,129.33 209.39,130.49 209.39,161.96 v1(211.09,163.67)
  BOTTOM w0.14: v1(72.54,51.81) 71.8,51.07 PC36.2 72.19,50.62 72.61,51.05 PC25.1 ; v1(214.42,167.76) 214.19,167.99 213.38,167.99 212.11,166.72 212.11,164.68 v1(211.09,163.67)
  BOTTOM w0.178: PU1.2 71.84,52.88 72.28,52.44 73.05,52.44 73.49,51.99 PC25.1
24780_BATDRV: length 1.9
  BOTTOM w0.178: PU1.18 71.04,58.33 PR4.2
24780_BATSRC: length 1.8
  BOTTOM w0.178: PU1.17 70.64,58.15 70.28,58.51 PR7.2
24780_BM#: length 2.5
  BOTTOM w0.178: PU1.16 70.24,58.06 69.96,58.34 69.72,58.34 68.98,59.07 PR9.1
24780_BST: length 5.4
  BOTTOM w0.14: v1(77.79,56.86) 77.79,56.86 77.42,56.48 76.64,56.48 PR11.2
  BOTTOM w0.178: PR11.2 75.82,55.67 74.32,55.67 73.99,55.35 PU1.25
24780_CMPIN: length 8.4
  TOP w0.254: v1(68.3,57.4) 69.52,56.18 69.52,54.09 69.52,54.09 69.52,53.71 70.11,53.12 PR67220.1
  BOTTOM w0.178: PU1.13 68.58,56.15 68.37,56.35 68.37,56.58 68.1,56.86 67.91,56.86 PR207.1 68.04,57.16 68.3,57.42 v1(68.3,57.4)
24780_CMPOUT: length 3.7
  BOTTOM w0.178: PR15.1 67.21,59.14 67.86,58.49 68.09,58.49 v1(68.5,58.08) 69.04,57.54 PU1.14
24780_CMSRC: length 260
  IN5 w0.178: v1(71.88,51.83) 72.6,51.11 73.02,51.11 74.2,49.93 82.95,49.93 85.44,52.42 91.28,52.42 92.97,54.12 100.11,54.12 100.74,54.74 110.83,54.74 111.89,55.8 111.93,55.8 112.07,55.93 117.55,55.93 118.25,56.63 126.57,56.63 127.15,56.05 141.5,56.05 141.56,55.99 156.05,55.99 156.62,55.41 169.26,55.41 169.65,55.8 171.63,55.8 174.63,58.79 174.63,58.96 175.29,59.61 175.29,62.19 175.62,62.52 175.62,62.52 178.44,65.34 178.74,65.34 180.3,66.9 192.22,66.9 192.24,66.88 192.31,66.88 192.32,66.87 193.64,66.87 193.78,67.01 195.73,67.01 195.86,67.01 200.45,71.6 200.45,73.84 201.68,75.08 201.68,76.17 201.11,76.74 199.77,76.74 199.35,77.15 199.35,84.41 198.79,84.97 198.79,85.23 194.89,89.12 194.89,92.91 201.44,99.47 201.44,108.46 208.62,115.63 208.62,129.16 208.83,129.37 210.07,130.61 210.07,161.5 211.98,163.41 211.98,165.04 210.13,166.89 209.32,166.89 205.68,170.53 v1(205.68,170.76)
  BOTTOM w0.178: v1(71.88,51.83) 71.88,51.93 71.44,52.37 PU1.3
  BOTTOM w0.508: PR28.2 206.17,167.96 205.68,168.44 v1(205.68,170.76)
24780_DH: length 6.6
  IN5 w0.508: v1(74.54,55.16) 75.2,55.16 76,55.96 77.52,55.96 78.31,56.75 v1(78.31,57.38)
  BOTTOM w0.178: v1(74.54,55.16) 74.33,54.95 PU1.26
24780_DL: length 6.1
  TOP w0.381: PQ29.4 78.02,58.01 77.44,57.44 v1(77.31,57.44)
  IN5 w0.508: v1(77.31,57.44) 74.69,57.44 v1(73.86,56.61)
  BOTTOM w0.178: v1(73.86,56.61) 73.86,56.38 73.62,56.15 PU1.23
24780_ILIM: length 6.7
  BOTTOM w0.178: PR204.1 75.33,60.9 75.59,60.64 PR206.1 PC8.2 75.59,58.55 v1(75.48,58.44) 75.1,58.06 73.4,58.06 72.69,57.35 PU1.21
24780_LX: length 11.8
  IN5 w0.508: v1(81.02,56.56) 80.08,56.56 77.97,54.45 v1(74.57,54.45)
  BOTTOM w0.178: v1(74.57,54.45) 74.47,54.55 PU1.27
  BOTTOM w0.203: PC15.1 74.7,54.32 v1(74.57,54.45)
  BOTTOM w0.508: PR33.1 v3(84.25,59.02)
24780_SRN: length 46.5
  TOP w0.203: v1(97.21,55.85) 97.06,55.69 97.06,53.52 96.17,52.63 96.1,52.63 96.08,52.62 93.87,52.62 93.75,52.49 PR208.2
  BOTTOM w0.203: v1(97.21,55.85) 97.06,56 97.06,61.84 95.82,63.08 94.18,63.08 92.4,64.86 83.37,64.86 80.75,62.25 78.56,62.25 77.09,63.72 72.56,63.72 v1(72.23,63.39) 71.75,62.91 71.75,61.94 72.16,61.53 PC4.2 73.25,61.53 PC3.1 73.52,60.91 72.89,60.28 PR6.2
24780_SRP: length 39.9
  TOP w0.14: 93.75,54.32 PR210.2
  TOP w0.203: 93.75,54.32 93.75,53.1 93.87,52.98 96.03,52.98 96.72,53.66 96.72,55.69 v1(96.57,55.85)
  BOTTOM w0.203: v1(96.57,55.85) 96.72,56 96.72,61.7 95.68,62.74 94.04,62.74 92.27,64.51 83.5,64.51 80.89,61.9 78.39,61.9 77.69,62.6 v1(76.52,62.6) 75.08,62.6 74.7,62.22 PC6.2 PC3.2 74.3,60.74 PR5.2
