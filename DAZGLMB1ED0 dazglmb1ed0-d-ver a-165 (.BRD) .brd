# Allegro board DAZGLMB1ED0 dazglmb1ed0-d-ver a-165 (.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FBD_CMD20: length 27.2
  TOP w0.102: U13142.J4 122.77,150 122.77,149.36 122.99,149.14 124.77,149.14 125.14,148.77 129.06,148.77 129.51,149.21
  TOP w0.17: U13114.M1 139.88,141.51 138.17,143.22
  TOP w0.216: 138.17,143.22 138.17,144.85 v1(133.5,149.52) 132.56,150.46 130.76,150.46 129.51,149.21
FBD_CMD21: length 27.1
  TOP w0.102: U13142.K5 122.45,149.3 122.81,148.94 124.68,148.94 125.07,148.55 129.7,148.55 130.56,149.41 ; 137.82,143.19 139.82,141.19 143.56,141.19 143.88,141.51 U13114.M2
  TOP w0.216: 137.82,143.19 137.82,144.36 132.32,149.85 v1(131.95,149.85) 131,149.85 130.56,149.41
FBD_CMD22: length 28.5
  TOP w0.102: 130.99,148.98 130.34,148.33 125,148.33 124.6,148.73 122.7,148.73 122.12,149.31 122.12,150 U13142.K4 ; U13114.M3 144.51,141.51 144.16,141.16 143.86,141.16 143.66,140.96 139.67,140.96 137.43,143.2
  TOP w0.216: 137.43,143.2 137.43,143.89 v1(133.64,147.69) 132.18,149.15 131.16,149.15 130.99,148.98
FBD_CMD23: length 27.6
  TOP w0.102: U13142.L5 121.8,149.21 122.52,148.48 124.56,148.48 124.92,148.12 130.7,148.12 ; U13114.P3 144.45,140.11 144.1,140.46 143.72,140.46 143.52,140.66 139.59,140.66 137.05,143.2 137.05,143.43
  TOP w0.216: 130.7,148.12 131.08,148.5 131.98,148.5 134.08,146.4 v1(134.08,146.4) 134.09,146.4 137.05,143.43
FBD_CMD24: length 27.7
  TOP w0.102: U13142.L4 121.47,150 121.47,149.52 121.54,149.45 121.54,148.81 122.07,148.28 124.47,148.28 124.85,147.9 130.49,147.9 130.55,147.84 131.19,147.84 ; 136.38,143.26 136.61,143.26 139.44,140.43 143.45,140.43 143.76,140.11 U13114.P2
  TOP w0.216: 136.38,143.26 v1(134.46,145.18) 131.74,147.9 131.24,147.9 131.19,147.84
FBD_CMD25: length 27
  TOP w0.102: U13142.L11 121.48,146.09 121.48,147.23 122.32,148.07 124.39,148.07 124.77,147.69 130.35,147.69 130.66,147.38 131.08,147.38
  TOP w0.216: 131.08,147.38 131.95,146.51 132.24,146.51 v1(135.28,143.48) 135.82,142.93 136.4,142.93 139.22,140.11 U13114.P1
FBD_CMD26: length 28.1
  TOP w0.102: U13142.L10 121.77,146.45 121.77,147.12 122.52,147.87 124.3,147.87 124.72,147.46 130.16,147.46 130.66,146.95 ; 143,139.76 145.01,139.76 U13114.R4
  TOP w0.216: 143,139.76 138.96,139.76 136.14,142.59 135.3,142.59 v1(134.01,143.88) 132.49,145.39 132.22,145.39 130.66,146.95
FBD_CMD27: length 24.5
  TOP w0.102: U13142.J10 123.2,146.52 123.2,147.24 123.62,147.67 124.22,147.67 124.66,147.23 129.54,147.23 129.61,147.16
  TOP w0.216: U13114.R1 138.8,139.41 135.98,142.23 134.54,142.23 v1(132.56,144.21) 129.61,147.16
FBD_CMD28: length 26.1
  TOP w0.102: 129.42,146.49 128.91,147 124.54,147 124.07,147.46 123.7,147.46 123.42,147.18 123.42,146.1 U13142.J11 ; 136.36,141.34 138.61,139.09 143.49,139.09 143.81,139.41 U13114.R2
  TOP w0.216: 136.36,141.34 136.07,141.63 133.84,141.63 v1(131.01,144.47) 130.02,145.46 130.02,145.89 129.42,146.49
FBD_CMD29: length 26.9
  TOP w0.102: 136.28,141.01 138.45,138.84 143.58,138.84 143.8,139.05 144.3,139.05 U13114.R3 ; U13142.H11 124.07,146.1 124.07,146.57 124.28,146.77 128.68,146.77 129.46,145.99 129.46,145.02 129.56,144.92
  TOP w0.216: 129.56,144.92 129.86,144.61 129.86,143.94 130.3,143.5 ; v1(130.3,143.53) 130.3,143.5 ; 130.3,143.5 132.79,141.01 v1(132.81,141.01) 136.28,141.01
  BOTTOM w0.216: v1(130.3,143.53) 130.32,143.55 R22025.2
FBD_CMD30: length 26
  TOP w0.102: U13114.U3 144.39,138.01 144.04,138.37 143.75,138.37 143.52,138.6 138.28,138.6 136.48,140.4 ; 123.41,143.24 123.41,144.65 123.27,144.8 122.77,144.8 U13142.K12
  TOP w0.216: 123.41,143.24 123.9,142.76 129.14,142.76 v1(130.04,141.85) 131.5,140.4 136.48,140.4
FBD_CMD31: length 27.9
  TOP w0.102: 121.38,143.43 121.47,143.52 121.47,145.45 U13142.M11 ; U13114.U2 143.76,138.01 143.38,138.39 138.06,138.39 136.65,139.8
  TOP w0.216: 136.65,139.8 v1(125.54,139.8) 124.35,140.99 122.85,140.99 121.38,142.46 121.38,143.43
FBD_DBI0: length 19.5
  TOP w0.17: U13114.AJ1 141.99,129.61 v4(141,128.62)
  TOP w0.216: v4(126.02,125.75) 126.02,125.75 U13141.R3
  IN4 w0.14: v4(141,128.62) 141,128.35 139.21,126.55 128.62,126.55 128.01,125.94 126.22,125.94 v4(126.02,125.75)
FBD_DBI1: length 21.3
  TOP w0.17: v4(142.74,130.98) 143.22,130.98 U13114.AG1
  TOP w0.216: v4(126.02,131.6) 126.02,131.6 125.7,131.92 U13141.R12
  IN4 w0.081: v4(126.02,131.6) 125.7,131.92 125.7,132.47
  IN4 w0.14: v4(142.74,130.98) 141.04,132.68 130.98,132.68 129.66,134 126.57,134 126.36,133.79 126.36,133.41 125.88,132.93 125.88,132.76 125.7,132.58 125.7,132.47
FBD_DBI2: length 35.1
  TOP w0.102: v4(118.22,131.6) 118.87,131.6 U13141.E12
  TOP w0.216: v4(147.81,134.9) 147.49,135.21 U13114.AA7
  IN4 w0.081: 119.2,133.21 119.2,132.57 v4(118.22,131.6)
  IN4 w0.14: 119.2,133.21 119.2,133.34 119.15,133.39 119.15,133.72 119.99,134.56 120.52,134.56 122.57,136.61 131.59,136.61 132.19,136.01 141.66,136.01 142.83,134.84 144.24,134.84 144.69,135.29 147.44,135.29 147.81,134.92 v4(147.81,134.9)
FBD_DBI3: length 31.5
  TOP w0.216: U13114.AD5 146.03,133.11 v4(145.71,132.79) ; U13141.E3 v4(118.87,126.4)
  IN4 w0.081: 119.74,126.72 119.2,126.72 v4(118.87,126.4)
  IN4 w0.14: v4(145.71,132.79) 145.32,133.19 144.17,133.19 143.86,132.88 143.86,131.56 142.82,130.52 132.22,130.52 131.69,129.99 125.75,129.99 124.12,128.36 122.03,128.36 121.15,127.47 120.48,127.47 119.74,126.72
FBD_DBI4: length 22.6
  TOP w0.17: v4(125.37,151.3) U13142.E3
  TOP w0.216: v4(144.31,147.46) U13114.D3
  IN4 w0.081: 126.87,152.29 125.86,152.29 125.7,152.12 125.7,151.62 v4(125.37,151.3)
  IN4 w0.14: v4(144.31,147.46) 138.56,147.46 133.7,152.32 126.9,152.32 126.87,152.29
FBD_DBI5: length 21.8
  TOP w0.102: U13114.H3 144.44,144.31 144.09,144.67 143.8,144.67 143.51,144.96 141.3,144.96 v4(140.58,144.24)
  TOP w0.216: U13142.E12 126.02,145.45 v4(126.02,145.45)
  IN4 w0.081: v4(126.02,145.45) 126.35,145.77 126.35,146.34
  IN4 w0.14: 126.35,146.34 126.38,146.37 126.64,146.63 136.06,146.63 138.83,143.86 140.21,143.86 v4(140.58,144.24)
FBD_DBI6: length 32.5
  TOP w0.216: U13114.U5 146.03,138.01 v4(145.71,138.33) ; v4(118.87,145.45) 118.88,145.45 119.2,145.13 U13142.R12
  IN4 w0.081: 119.2,143.98 U13142.R12 v4(118.87,145.45)
  IN4 w0.14: 119.2,143.98 119.17,143.95 119.17,143.27 119.79,142.65 119.79,142.09 121.22,140.66 135.33,140.66 136.83,139.17 143.14,139.17 144.37,137.94 145.32,137.94 v4(145.71,138.33)
FBD_DBI7: length 36.1
  TOP w0.216: v4(119.52,150.65) U13142.R3 ; U13114.M9 148.81,141.51 v4(148.5,141.2)
  IN4 w0.14: v4(119.52,150.65) 120.54,149.63 121.28,149.63 122.96,147.95 122.96,147.34 123.71,146.58 123.71,143.33 123.95,143.09 136.55,143.09 137.72,141.92 147.78,141.92 v4(148.5,141.2)
FBD_DEBUG0: length 5
  TOP w0.127: v4(144.31,132.8) 144.62,133.11 U13114.AD3
  BOTTOM w0.14: R21522.1 v1(140.76,132.71) 144.22,132.71 v4(144.31,132.8)
FBD_DEBUG1: length 6.7
  TOP w0.14: v4(144.31,143.3) 144.62,143.61 U13114.J3
  BOTTOM w0.14: v1(139.14,142.89) 139.2,142.95 R21523.1 143.85,143.76 v4(144.31,143.3)
FBD_EDC0: length 21.4
  TOP w0.102: U13114.AJ3 144.27,129.22 142.87,129.22 v4(142.27,128.62) ; U13141.T3 126.67,125.75 v4(126.67,125.1)
  IN4 w0.14: v4(126.67,125.1) 127.22,124.55 138.2,124.55 v4(142.27,128.62)
FBD_EDC1: length 19
  TOP w0.17: v4(141.54,130.93) 141.97,130.49 143.28,130.49 143.79,131.01 U13114.AG2
  TOP w0.216: v4(126.67,132.25) U13141.T12
  IN4 w0.14: v4(126.67,132.25) 126.93,131.99 127.67,131.99 128.06,131.6 129.92,131.6 130.43,131.09 131.34,131.09 131.66,131.41 141.05,131.41 v4(141.54,130.93)
FBD_EDC2: length 36.8
  TOP w0.102: v4(118.87,132.9) 118.87,132.25 U13141.D12
  TOP w0.216: v4(149.21,134.9) 148.89,135.21 U13114.AA9
  IN4 w0.14: v4(118.87,132.9) 118.8,132.9 118.27,133.43 118.27,134.91 119.08,135.72 120.69,135.72 122.27,137.3 131.92,137.3 132.44,136.78 141.81,136.78 142.74,135.86 148.28,135.86 149.21,134.92 v4(149.21,134.9)
FBD_EDC3: length 32.6
  TOP w0.216: U13114.AF4 145.32,131.71 v4(145.01,132.03) ; v4(118.22,125.75) U13141.D3
  IN4 w0.081: 118.55,124.9 118.55,125.42 v4(118.22,125.75)
  IN4 w0.14: 118.55,124.9 118.74,124.71 120.99,124.71 121.36,125.08 121.36,126.78 122.17,127.59 124.35,127.59 126,129.24 132.22,129.24 132.86,129.89 142.97,129.89 145.01,131.92 v4(145.01,132.03)
FBD_EDC4: length 21.1
  TOP w0.216: U13114.E3 144.66,146.44 v4(144.33,146.76) ; v4(126.67,151.3) 126.67,151.3 U13142.D3
  IN4 w0.081: 127.6,150.97 127,150.97 v4(126.67,151.3)
  IN4 w0.14: 127.6,150.97 127.65,150.93 128.96,150.93 129.13,151.1 134.15,151.1 139,146.24 143.81,146.24 v4(144.33,146.76)
FBD_EDC5: length 19.5
  TOP w0.102: U13114.H2 143.76,144.31 143.41,144.66 142.29,144.66 141,143.37 v4(141,143.3)
  TOP w0.216: U13142.D12 v4(126.67,144.8)
  IN4 w0.14: v4(126.67,144.8) 129.28,144.8 129.41,144.66 136.4,144.66 138.22,142.84 140.54,142.84 v4(141,143.3)
FBD_EDC6: length 34.9
  TOP w0.216: v4(118.22,144.8) U13142.T12 ; v4(147.11,138.31) 146.81,138.01 U13114.U6
  IN4 w0.081: 118.55,143.88 118.55,144.47 v4(118.22,144.8)
  IN4 w0.14: 118.55,143.88 118.62,143.81 118.62,143.31 118.49,143.18 118.49,142.82 118.64,142.68 118.64,141.83 120.78,139.69 132.99,139.69 134.26,138.42 142.4,138.42 143.44,137.38 146.17,137.38 v4(147.11,138.31)
FBD_EDC7: length 35.7
  TOP w0.216: U13142.T3 118.22,151.3 v4(118.22,151.3) ; U13114.M5 146.01,141.51 v4(145.7,141.2)
  IN4 w0.081: 119.05,150.32 118.65,150.32 118.55,150.42 118.55,150.97 v4(118.22,151.3)
  IN4 w0.14: 119.05,150.32 119.53,149.85 119.53,148.95 119.8,148.68 120.82,148.68 123.16,146.34 123.16,143.03 123.66,142.52 135.85,142.52 137.55,140.82 145.32,140.82 v4(145.7,141.2)
FBD_VREFC: length 16.4
  TOP w0.254: v4(122.12,144.15) U13142.K13 ; v4(122.12,132.9) U13141.K13
  BOTTOM w0.406: v4(122.12,144.15) 122.03,144.15 121.54,143.65 121.54,142.62 121.8,142.36 C95831.1 121.8,140.67 120.42,139.29 R21877.2 R21874.2 R21876.2 v1(122.7,136.74) 122.7,135.78 122.08,135.16 C95811.1 121.41,134.8 121.41,133.61 v4(122.12,132.9)
FBD_VREFC_CTL: length 2.1
  BOTTOM w0.14: Q7879.3 119.02,137.76 119.03,137.75 R21877.1 v1(119.65,138.62)
FBVDD_EN: length 70.7
  TOP w0.14: U13118.4 127.57,120.35 127.3,120.62 v1(127.15,120.62) ; PR9123.2 110.51,76.67 110.26,76.93 v1(110.26,77.56)
  IN1 w0.089: v1(127.15,120.62) 126.59,121.17 121.74,121.17 120.42,119.85 120.42,111.47 120.74,111.15 120.74,102.91 126.26,97.39 126.26,97.37 127.28,96.35 127.28,94.4 128.47,93.21 128.47,89.71 126.81,88.05 126.81,84.68 126.01,83.88 126.01,80.6 124.75,79.34 120.92,79.34 119.98,78.4 113.39,78.4 112.55,77.56 v1(110.26,77.56)
FBVDDQ_MEM: length 553.8
  TOP w0.102: v4(196.34,152.31) 196.34,151.66 U13138.E2 ; v4(196.34,117.25) 196.34,116.6 U13136.E2 ; U13136.L14 200.63,124.02 200.63,123.49 U13136.L13 ; v4(179.31,163.71) 179.35,163.67 ; 146.58,173.21 v4(146.6,173.18)
  TOP w0.178: v4(129.08,145.79) 128.98,145.7 128.37,145.7 U13142.A11
  TOP w0.2: U13137.L14 v4(180.2,169.93) ; v4(199.58,137.84) 200.08,137.84 v4(200.15,137.91)
  TOP w0.25: U13139.J1 128.49,171.41 v4(128.11,171.41) ; U13140.C14 147.07,166.51 147.43,166.51 U13140.C13 ; U13139.C14 137.14,175.51 137.56,175.51 ; v4(137.41,173.83) U13139.E14 ; U13142.E14 125.94,144.06 125.94,144.23 U13142.E13 ; v4(180.2,173.18) U13137.G14 v4(180.85,173.18) ; v4(137.41,168.63) U13139.N14 v4(136.76,169.28) U13139.N13 v4(136.11,169.28) U13139.M12 ; U13141.J2 v4(122.12,125.1) U13141.J1 ; v4(171.45,170.28) 172.05,170.28 U13137.L1 U13137.L2 v4(173.05,170.58) ; 172.07,177.22 U13137.A1 ; U13140.H10 150.08,169.61 v4(150.13,169.56) ; U13137.W13 180.01,164.92 v4(180.2,164.73) U13137.W14 v4(180.85,164.73) ; U13140.J14 v4(147.25,170.58) U13140.J13 ; 174.09,177.26 174.02,177.19 U13137.A4 ; U13137.U13 v4(180.2,166.68) U13137.U14 v4(180.85,166.03) ; U13137.W4 174.02,164.86 v4(174.24,164.65) ; U13139.J14 137.16,171.48 v4(137.66,171.48) ; U13137.J1 171.9,171.38 171.72,171.38 ; v4(147.25,173.83) U13140.R13 ; 128.29,175.53 128.56,175.53 U13139.C1 ; U13139.W4 130.59,164.86 v4(130.8,164.65) ; U13141.N13 v4(124.07,132.25) U13141.M12 ; U13137.E11 v4(178.25,174.48) U13137.D10 177.62,175.11 v4(177.57,175.11) ; U13137.U1 172.07,166.36 v4(172.4,166.03) U13137.U2 ; U13139.R14 v4(137.41,167.33) ; v4(177.6,173.83) U13137.F10 ; U13140.E13 v4(147.25,167.33) U13140.E14 ; v4(180.95,171.36) 180.74,171.56 U13137.J14 ; U13136.R13 203.28,123.54 203.28,123.97 U13136.R14 ; U13140.L13 v4(147.9,171.23) ; U13142.L2 U13142.L1 v4(121.8,152.76) ; 171.72,174.16 U13137.E1 172.07,174.16 v4(172.4,173.83) U13137.E2 ; U13142.J14 v4(122.77,144.15) U13142.J13 ; v4(177.44,169.54) 177.51,169.61 U13137.M10 ; v4(180.85,175.78) U13137.C14 ; v4(123.82,130.02) 123.75,130.09 U13141.M10 ; U13141.F10 v4(119.52,130.3) ; U13137.R4 174.02,167.66 v4(174.35,167.98) U13137.P5 ; v4(155.91,171.58) 155.4,171.58 U13140.L1 ; v4(131.56,176.43) U13139.B5 ; v4(155.05,166.03) U13140.C2 ; U13136.C14 195.31,124.13 195.31,124.43 ; U13140.G2 v4(155.05,169.28) U13140.G1 ; U13141.E2 v4(119.52,125.75) ; v4(149.85,175.13) U13140.T10 ; U13139.E1 128.61,174.13 128.29,174.13 ; U13137.C2 v4(172.4,175.13) 172.07,175.46 U13137.C1 172,175.53 171.72,175.53 ; v4(120.82,130.3) U13141.H10 ; U13137.L13 179.9,170.26 180.21,169.95 ; U13137.T10 178.06,166.87 v4(178.25,166.68) ; U13139.R1 v4(128.96,167.98) U13139.R2 ; v4(116.81,149.26) 116.83,149.26 116.93,149.36 116.93,149.36 U13142.V5 ; U13137.M12 v4(179.55,169.28) U13137.N13 v4(180.2,169.28) 180.52,168.96 U13137.N14 v4(180.85,168.63) ; 155.85,167.51 155.53,167.51 U13140.E1 v4(155.05,167.33) U13140.E2 ; U13139.H3 v4(129.61,172.53) U13139.G2 v4(128.96,172.53) U13139.G1 128.1,172.86 v4(128.05,172.81) ; U13140.M12 148.23,172.21 v4(148.55,172.53) ; U13141.W14 128.3,133.26 v4(128.63,133.6) ; U13140.A14 146.93,165.03 146.6,164.71 ; v4(123.8,147.01) 123.75,146.95 U13142.H10 ; v4(129,132.01) 128.91,131.92 U13141.W12 ; U13137.R14 180.43,167.57 180.42,167.57 180.38,167.53 180.01,167.53 179.97,167.57 179.96,167.57 U13137.R13 ; U13140.A1 v4(155.7,164.73) 155.4,164.43 v4(155.22,164.43) 155.13,164.52 155.13,164.66 U13140.A2 ; U13137.V5 v4(175,165.38) ; v4(125.37,125.1) U13141.R2 ; v4(155.7,166.03) 155.84,166.03 155.85,166.03 ; v4(175.23,172.33) 175.11,172.21 U13137.H5 ; U13137.B10 177.62,176.41 v4(177.57,176.41) ; v4(177.6,172.53) 177.92,172.21 U13137.H10 ; U13137.R2 v4(172.4,167.98) 172.07,167.66 U13137.R1 171.76,167.35 v4(171.45,167.35) ; U13142.C13 126.85,144.32 126.85,143.97 U13142.C14 ; U13141.H3 v4(120.82,125.75) U13141.G2 ; U13137.M3 v4(173.05,169.28) ; v4(122.77,125.75) U13141.L2 U13141.L1 ; 127.22,124.55 U13141.U1 ; v4(180.85,169.93) 180.85,169.93 U13137.L14 ; v4(136.76,173.18) U13139.G13 ; v4(198.57,120.89) 198.62,120.94 U13136.H10 ; U13139.L2 U13139.L1 128.17,170.26 128.14,170.28 v4(128.13,170.3) ; U13137.W12 179.22,164.45 v4(179.31,164.36) ; U13142.F10 v4(125.37,146.1) U13142.E11 ; U13142.L13 v4(122.12,144.8) ; U13142.R13 v4(118.87,144.15) ; v4(180.85,173.83) U13137.E14 ; v4(122.12,132.25) U13141.J13 ; U13140.M10 149.89,172.21 v4(150.01,172.33) 150.11,172.43 v4(150.11,173.02) 150.02,173.02 149.53,173.51 U13140.P10 ; v4(174.35,169.93) U13137.M5 ; v4(131.72,172.47) 131.45,172.21 U13139.H5 ; U13137.J2 v4(172.4,171.23) ; U13142.P10 119.85,146.42 v4(120.19,146.77) ; v4(136.11,171.23) U13139.J13 ; v4(131.56,165.38) U13139.V5 ; U13141.N14 v4(124.72,133.55) ; v4(155.05,169.93) U13140.J2
  TOP w0.254: U13141.J14 121.94,133.36 121.94,134.15 v4(122.56,134.78) ; U13138.N14 v4(202.19,158.81) U13138.N13 ; U13138.N14 v4(202.19,159.46) 202.19,159.52 202.78,160.11 v4(202.78,160.34) ; U13138.N14 v4(201.54,158.81) 201.54,158.81 ; v4(149.11,178.01) 149.2,177.92 v4(149.2,177.08) U13140.W11 ; U13138.E2 v4(196.34,151.01) U13138.E1 v4(196.32,150.33) 196.28,150.29 v4(196.28,149.49) ; U13136.W4 206.05,117.86 v4(206.29,117.86) ; U13138.C13 195.52,158.63 195.52,158.98 U13138.C14 195.31,159.19 v4(195.31,159.61) ; v4(193.13,134.45) 192.73,134.05 191.79,134.05 191.04,133.3 R22010.1 ; U13135.A4 206.26,141.18 v4(206.44,141) ; U13136.P10 202.52,121.48 v4(202.17,121.13) 202.09,121.05 201.62,121.05 v4(201.54,121.14) 201.22,121.45 U13136.M10 ; U13136.A13 v4(193.74,123.75) 194.07,124.08 U13136.A14 ; v4(123.42,150) U13142.H5 ; U13139.R11 v4(134.81,167.98) U13139.P10 ; U13139.A11 v4(134.81,177.08) 134.81,177.5 v4(135.39,178.08) ; v4(195.84,114.47) 196.32,114.95 v4(196.32,115.28) U13136.E1 v4(196.34,115.95) U13136.E2 ; v4(201.26,139.98) 201.26,140.01 201.24,140.03 201.24,140.51 U13135.H5 ; v4(197.64,134.35) U13135.N14 v4(198.29,135) U13135.N13 v4(198.29,135.65) U13135.M12 ; v4(134.81,166.68) U13139.T10 ; v4(118.22,146.75) U13142.T10 v4(118.87,146.1) U13142.R11 ; U13136.E13 v4(196.34,123.75) U13136.E14 ; U13142.G14 v4(124.72,143.5) ; v4(193.88,149.49) 193.88,150.22 v4(193.74,150.36) U13138.A1 v4(193.74,151.01) U13138.A2 ; U13136.G2 v4(198.29,115.95) U13136.G1 197.97,115.12 v4(198.04,115.05) 198.04,115.03 197.93,114.93 197.93,114.52 v4(198.02,114.43) ; v4(201.37,118.81) 201.37,118.38 U13136.M5 ; v4(137.45,177.3) 137.45,177.31 v4(136.8,177.31) ; v4(137.45,177.3) 137.45,177.12 U13139.A14 136.8,177.04 v4(136.8,177.31) ; v4(137.45,177.3) 137.98,177.3 v4(138.03,177.26) ; v4(205.62,139.96) 205.44,140.14 205.44,140.2 U13135.B5 ; v4(204.14,135.65) U13135.C13 ; v4(128.96,177.08) U13139.A2 ; U13140.B10 v4(149.2,165.38) 148.88,165.06 U13140.A11 ; 190.84,126.9 R22012.1 ; U13138.M5 201.22,153.82 v4(201.27,153.87) ; U13142.L14 121.76,143.78 121.76,143.19 v4(122.11,142.84) ; U13142.A13 v4(128.62,144.15) U13142.A14 v4(128.66,143.46) ; U13139.C1 128.64,175.46 v4(128.96,175.13) U13139.C2 ; U13138.J13 v4(199.59,158.81) 199.27,159.13 U13138.J14 199.59,159.46 v4(199.59,159.57) ; v4(155.7,166.03) U13140.C1 155.37,166.36 v4(155.05,166.03) ; v4(195.69,121.8) U13136.D10 ; U13141.N14 v4(124.07,132.9) U13141.N13 ; U13136.H12 v4(198.29,123.1) U13136.G13 ; U13135.G13 v4(202.19,135) 201.87,134.68 U13135.G14 v4(202.19,134.35) ; U13135.R2 v4(196.99,142.8) 196.67,143.13 U13135.R1 v4(196.34,143.45) ; v4(147.27,177.2) 147.58,176.9 U13140.W13 ; v4(116.16,146.08) 116.47,145.77 U13142.W11 ; 128.29,174.13 v4(128.07,174.13) 127.23,174.13 v4(127.16,174.07) ; v4(130.76,177.19) 130.59,177.02 U13139.A4 ; v4(193.71,140.87) 194.02,141.18 U13135.W4 ; U13135.E2 v4(202.84,142.8) U13135.E1 v4(203.17,143.59) 203.17,143.93 v4(202.79,144.3) ; U13138.A11 194.07,157.18 v4(194.39,156.86) 194.39,156.86 U13138.B10 ; U13114.M10 149.87,141.2 v4(149.92,141.2) ; v4(173.05,169.28) U13137.N2 v4(172.4,169.28) ; U13138.V10 205.12,156.53 v4(205.44,156.21) ; U13138.H12 v4(198.29,158.16) 197.97,158.48 U13138.G13 ; v4(203.17,150.21) U13138.R1 v4(203.49,151.01) U13138.R2 ; v4(116.15,144.1) 116.52,144.47 U13142.W13 ; v4(204.39,144.3) 204.54,144.15 v4(204.54,143.59) 204.47,143.52 U13135.C1 v4(204.14,142.8) U13135.C2 ; U13140.E4 153.42,167.66 v4(153.1,167.98) U13140.F5 ; U13135.V10 v4(194.39,136.95) 194.07,136.63 U13135.W11 ; U13136.B10 v4(194.39,121.8) U13136.A11 194.03,122.17 193.05,122.17 v4(193.01,122.14) ; U13141.L13 v4(123.42,132.9) U13141.L14 v4(123.42,133.55) ; v4(120,153.5) 120.42,153.07 v4(120.42,152.74) 120.5,152.66 U13142.N1 ; v4(128.96,173.83) U13139.E2 ; U13138.F10 197.15,156.7 197.15,156.7 v4(196.99,156.86) 196.81,157.04 196.67,157.18 U13138.E11 ; R22014.1 179.67,161.84 179.67,163.35 179.35,163.67 ; U13135.A13 205.94,135.33 v4(206.26,135.01) 205.93,134.68 U13135.A14 ; U13141.U14 v4(126.67,132.9) U13141.U13 ; v4(154.4,171.23) 154.72,171.56 U13140.L2 ; v4(196.34,134.35) U13135.R14 v4(196.34,135) U13135.R13 ; v4(153.1,164.73) U13140.A4 ; v4(198.29,152.31) 198.47,152.13 U13138.H3 ; U13142.W4 115.84,150.32 v4(115.82,150.3) ; U13114.M43 172.62,141.51 v4(172.31,141.2) ; U13142.H3 v4(124.07,150.65) ; U13142.C2 v4(127.32,151.95) U13142.C1 127.32,152.6 v4(127.32,152.7) 127.32,153.03 v4(126.89,153.46) ; U13142.A1 128.3,152.38 v4(128.62,152.7) 128.97,152.35 v4(128.97,151.86) 128.54,151.86 U13142.A2 ; v4(128.27,164.69) U13139.W1 v4(128.96,164.73) U13139.W2 ; v4(137.57,175.51) 137.56,175.51 ; U13141.W2 128.71,125.42 v4(128.95,125.18) 128.73,124.96 128.48,124.96 U13141.W1 128.65,124.42 v4(128.65,124.05) ; v4(172.31,125.71) 172.61,125.41 U13114.AR43 ; v4(204.14,156.21) 203.92,156.43 U13138.T10 v4(203.49,156.86) 203.17,157.18 U13138.R11 ; v4(203.3,124.56) 202.35,124.56 v4(202.19,124.4) U13136.N14 ; v4(207.54,159.58) v4(206.22,159.58) U13138.W14 205.77,159.13 205.98,158.92 206.14,158.92 v4(206.21,158.85) ; U13136.J13 v4(199.59,123.75) U13136.J14 199.59,124.4 v4(199.59,124.63) ; U13138.U1 204.47,150.53 v4(204.72,150.28) ; v4(139.04,164.62) 137.52,164.62 v4(137.41,164.73) U13139.W14 v4(136.76,164.73) U13139.W13 ; v4(153.76,177.12) 153.43,176.78 U13140.W4 ; U13137.J1 172.07,171.56 v4(172.4,171.23) ; v4(206.21,158.85) 206.28,158.78 207.5,158.78 v4(207.53,158.82) ; v4(206.21,158.85) 205.84,158.48 U13138.W13 ; U13142.M10 121.15,146.47 v4(120.84,146.77) 120.67,146.95 120.37,146.95 v4(120.19,146.77) ; U13140.R11 v4(149.2,174.48) U13140.T10 ; C96153.1 144.17,173.08 144.32,173.23 146.56,173.23 146.58,173.21 ; v4(155.05,173.18) U13140.N2 v4(155.05,172.53) 155.37,172.86 U13140.N1 155.76,172.86 v4(155.84,172.93) ; v4(127.97,127.7) 127.65,127.37 U13141.V5 v4(127.97,127.05) 128.3,126.72 U13141.W4 ; v4(170.94,142.56) 171.26,142.88 U13114.K41 ; U13136.A2 v4(193.74,115.95) U13136.A1 v4(193.74,115.3) ; v4(126.67,130.95) U13141.T10 ; U13140.B5 152.45,165.39 v4(152.45,165.39) ; v4(195.04,118.55) U13136.B5 ; U13142.J2 v4(123.42,151.95) 123.1,152.27 U13142.J1 123.1,152.52 v4(123.28,152.7) ; U13139.J2 v4(128.96,171.23) U13139.J1 ; 172.07,177.22 v4(172.07,177.26) 172.09,177.28 v4(172.72,177.28) U13137.A2 ; v4(206.37,149.45) 206.09,149.73 v4(206.09,150.36) U13138.W1 ; U13138.E4 v4(196.34,152.31) ; v4(171.62,171.38) 171.72,171.38 ; v4(118.19,130.26) U13141.D10 v4(118.87,130.95) U13141.E11 ; v4(147.25,173.83) U13140.R14 146.7,174.38 v4(146.09,174.38) 145.48,174.38 v4(145.46,174.36) ; U13142.C14 127.28,143.54 v4(127.28,143.46) ; U13137.G2 v4(172.4,172.53) 172.07,172.86 U13137.G1 171.61,172.86 v4(171.59,172.83) ; U13135.R11 v4(196.99,136.95) U13135.P10 ; U13135.J2 v4(200.24,142.8) U13135.J1 200.42,143.28 v4(200.42,143.58) ; U13139.E11 v4(134.81,174.48) U13139.D10 v4(134.13,175.17) ; v1(121.41,73.55) 121.33,73.47 PR9136.1 ; U13140.G14 146.93,168.95 v4(146.57,168.6) ; v4(136.8,177.31) v4(136.17,177.31) 136.17,177.01 136.43,176.76 U13139.A13 ; v4(137.41,166.03) U13139.U14 v4(136.76,166.68) U13139.U13 ; 155.85,166.03 156.05,166.03 156.42,166.4 v4(156.42,167.15) 156.07,167.51 v4(155.95,167.51) 155.85,167.51 ; U13142.G13 v4(124.07,144.8) U13142.H12 ; U13139.G13 v4(136.11,172.53) U13139.H12 ; U13138.W4 206.35,152.63 v4(206.64,152.92) ; v4(198.94,140.85) U13135.M5 ; U13114.AR42 171.91,125.41 v4(171.61,125.71) ; v4(193.74,142.8) U13135.W2 ; v4(125.99,143.46) 125.99,143.52 125.7,143.81 U13142.E14 ; U13140.E11 v4(149.2,167.98) U13140.F10 ; v4(205.44,137.6) U13135.B10 v4(205.44,136.95) U13135.A11 ; v4(196.34,117.25) U13136.E4 ; U13142.N1 120.5,152.27 ; U13142.N1 v4(120.82,151.95) ; U13142.N1 v4(120.17,151.95) ; U13140.V5 v4(152.45,176.43) ; v4(201.99,144.3) 201.82,144.13 v4(201.82,143.61) 201.87,143.56 U13135.G1 v4(201.54,142.8) U13135.G2 ; v4(199.31,143.64) 199.29,143.62 199.29,143.48 199.27,143.45 U13135.L1 U13135.L2 v4(199.59,142.15) ; U13142.A4 128.37,150.32 v4(128.67,150.02) ; v4(116.91,146.76) U13142.V10 ; v4(134.14,176.45) U13139.B10 ; U13142.E2 v4(126.02,151.95) U13142.E1 v4(126.05,152.62) ; v4(195.69,135) U13135.U13 ; 127.22,124.55 127.32,124.45 v4(127.32,124.08) 127.21,123.97 v4(127.21,123.3) v4(128.01,123.3) ; v4(204.14,121.15) U13136.T10 v4(203.49,121.8) U13136.R11 ; v1(107.59,77.05) 107.28,76.75 PR9208.1 ; v4(171.72,164.71) U13137.W1 v4(172.4,164.73) U13137.W2 ; v4(197.86,149.51) 197.64,149.73 v4(197.64,150.36) U13138.G1 v4(198.29,151.01) U13138.G2 ; v4(155.73,177.11) U13140.W1 v4(155.05,177.08) U13140.W2 ; v4(196.64,159.61) 196.67,159.59 U13138.E14 196.48,158.94 196.48,158.67 U13138.E13 ; v4(136.76,173.18) U13139.G14 v4(137.41,173.18) ; U13138.G14 197.76,159.34 v4(197.76,159.62) ; v4(117.48,142.37) 117.7,142.58 v4(117.7,143.15) 117.7,143.62 U13142.U14 v4(117.57,144.15) U13142.U13 ; U13136.U2 v4(204.79,115.95) 204.47,115.63 U13136.U1 204.72,115.38 v4(204.72,115.2) 204.72,114.45 v4(204.77,114.4) 204.77,113.38 204.37,112.98 C96071.1 ; v4(128.27,165.99) U13139.U1 v4(128.96,166.68) U13139.U2 ; v4(128.3,177.25) 128.3,177.12 128.64,176.78 U13139.A1 ; v4(201.54,142.15) U13135.H3 ; v4(128.07,175.53) 128.29,175.53 ; 119.2,150.32 U13142.R4 U13142.P5 ; U13136.G14 197.76,124.29 v4(197.76,124.57) ; v4(198.94,152.96) U13138.H5 ; U13140.G1 v4(155.85,168.96) 155.96,168.85 v4(156.55,168.85) ; U13135.W13 v4(193.74,135) U13135.W14 v4(193.74,134.35) ; U13142.B5 127.65,149.67 v4(127.32,149.35) ; U13140.C14 146.93,166.35 v4(146.57,166) ; C95688.1 196.23,132.76 v4(196.03,132.96) ; v4(201.54,135.65) U13135.H12 ; v4(124.32,153.49) 124.53,153.27 124.53,152.41 U13142.G1 124.4,152.27 v4(124.07,151.95) U13142.G2 ; U13140.E14 146.93,167.65 v4(146.57,167.3) ; U13140.R2 v4(155.05,174.48) U13140.R1 v4(155.95,174.16) ; v4(202.94,153.7) U13138.P5 U13138.R4 v4(203.49,152.96) ; U13139.L13 136.76,169.93 v4(136.76,169.93) U13139.L14 v4(137.41,169.93) ; U13135.E14 203.17,134.41 v4(203,134.24) ; U13136.F5 197.32,118.23 v4(196.99,118.56) ; U13142.M3 v4(120.82,150.65) ; U13141.U1 v4(127.32,125.1) U13141.U2 ; v4(128.96,169.28) U13139.N2 ; v4(203.49,115.95) U13136.R2 ; v4(204.14,137.6) U13135.D10 v4(203.49,136.95) U13135.E11 ; v4(206.23,122.06) 206.08,122.06 206.01,122.13 U13136.W11 ; U13139.R13 136.57,167.53 136.96,167.53 U13139.R14 v4(137.41,167.98) ; U13139.W12 135.79,164.64 v4(135.84,164.59) ; v4(130.91,173.83) 130.59,174.16 U13139.E4 ; v4(204.88,125.53) 204.85,125.5 204.85,124.71 204.87,124.69 v4(204.87,124.59) 204.87,124.48 U13136.U14 v4(204.79,123.75) U13136.U13 ; U13135.P5 v4(196.99,140.85) U13135.R4 ; v4(200.24,158.16) 200.57,158.48 U13138.L13 ; v4(200.01,125.46) 200.59,124.87 200.59,124.36 200.57,124.34 U13136.L14 ; v4(193.72,143.48) U13135.W1 ; U13139.R1 v4(128.27,167.29) ; v4(116.27,130.95) U13141.A11 ; U13139.V10 v4(134.81,165.38) U13139.W11 ; v4(194.39,140.2) U13135.V5 ; U13138.A13 v4(193.74,158.81) U13138.A14 v4(193.71,159.49) ; U13141.N2 124.07,125.1 v4(124.07,125.1) U13141.N1 ; v4(193.74,152.96) U13138.A4 ; U13138.U13 v4(204.79,158.81) 204.78,158.81 204.47,159.12 U13138.U14 204.85,159.51 v4(204.85,159.97) 204.85,160.55 v4(204.88,160.58) ; v4(198.92,134.33) U13135.L14 ; U13135.E4 v4(202.84,140.85) U13135.F5 ; v4(202.84,137.6) U13135.F10 ; U13141.R13 125.85,132.73 125.85,133.07 U13141.R14 ; v4(179.55,172.53) U13137.H12 ; U13135.A2 v4(206.29,142.48) 206.29,143.11 v4(206.27,143.13) ; v4(130.26,167.33) U13139.R4 v4(130.91,167.98) U13139.P5 ; v4(171.61,174.13) 171.63,174.16 171.72,174.16 ; v4(121.14,149.1) 121.15,149.12 U13142.M5 ; v4(200.24,151.66) 200.24,151.66 U13138.L2 U13138.L1 v4(200.57,150.21) ; U13135.W12 193.22,135.98 v4(193.15,135.9) ; v4(205.44,153.61) U13138.V5 ; v4(201.54,122.45) U13136.M12 ; v4(146.59,164.7) 146.6,164.71 ; U13136.C1 v4(195.04,115.95) U13136.C2 v4(195.04,116.6) ; U13142.L2 121.8,151.62 v4(122.12,151.3) ; v4(171.61,175.53) 171.72,175.53 ; U13142.E4 125.7,150.32 v4(125.37,150) U13142.F5 ; v4(198.94,117.9) U13136.H5 ; v4(200.24,116.6) U13136.L2 U13136.L1 200.57,115.18 v4(200.54,115.15) ; U13136.E11 v4(196.99,121.8) U13136.F10 ; v4(203.3,160.61) v4(203.3,159.84) 203.17,159.71 U13138.R14 v4(203.49,158.81) ; U13135.M3 v4(198.29,142.15) U13135.N2 v4(198.29,142.8) U13135.N1 v4(197.64,143.45) ; v4(123.42,127.05) U13141.M5 ; U13140.L14 146.89,171.59 146.18,171.59 v4(145.76,171.17) ; v4(201.54,137.6) U13135.H10 ; U13138.W11 205.91,157.03 v4(206.22,157.03) ; v4(204.79,134.35) U13135.C14 ; U13140.M3 v4(153.75,172.53) ; U13136.C14 195.48,123.97 195.48,123.54 U13136.C13 ; v4(202.37,114.4) 202.37,114.61 201.94,115.04 v4(201.94,115.17) ; U13135.M10 198.6,137.3 v4(198.6,137.81) ; U13138.N1 201.87,150.29 v4(201.94,150.22) 201.94,149.88 v4(202.37,149.45) ; v4(200.24,160.15) 200.59,159.79 200.59,159.16 U13138.L14 ; U13138.F5 v4(196.99,153.61) ; v4(180.88,177.12) U13137.A14 ; U13135.A1 v4(206.27,143.13) ; v4(206.27,143.13) 207.03,143.13 v4(207.25,142.91) ; U13138.W2 v4(206.09,151.01) ; U13140.H3 v4(153.75,169.28) ; U13135.U14 v4(195.03,134.34) 195.03,133.1 v1(195.22,132.91) ; v4(149.2,166.68) U13140.D10 ; v4(195.69,136.95) U13135.T10 ; v4(193.74,117.9) U13136.A4 ; U13140.V10 v4(149.85,176.43) ; U13136.W13 205.85,123.43 v4(206.2,123.78) 205.91,124.08 U13136.W14 ; U13142.R2 v4(118.87,151.95) U13142.R1 v4(119.2,152.84) ; U13135.U2 v4(195.04,142.8) U13135.U1 v4(195.02,143.48) ; U13138.B5 v4(195.04,153.61) ; v4(200.32,134.26) 200.32,134.41 200.57,134.65 U13135.J14 ; U13138.J2 v4(198.94,151.01) U13138.J1 199.09,150.5 v4(199.09,150.26) ; U13142.W14 v4(116.15,143.37) ; U13136.V10 v4(205.44,121.15) 206.07,120.52 v4(206.89,120.52) ; v4(155.7,164.73) 156.43,164.73 v4(156.57,164.87) ; U13141.W14 v4(128.62,132.9) U13141.W13 ; v4(201.54,156.18) 201.62,156.11 202.1,156.11 v4(202.17,156.18) 202.52,156.53 U13138.P10 ; v4(134.16,172.53) U13139.H10 ; v4(116.27,151.95) U13142.W2 ; 195.31,124.43 v4(195.31,124.69) 195.31,125.58 v4(195.27,125.62) ; U13136.V5 205.12,118.24 v4(205.52,118.64) ; U13140.A13 v4(147.25,164.73) U13140.A14 ; v4(155.78,169.92) 155.44,170.26 U13140.J1 155.37,170.26 v4(155.05,169.93) ; U13136.J2 v4(198.94,115.95) 199.27,115.63 U13136.J1 v4(198.94,115.3) ; U13140.U1 v4(155.05,175.78) U13140.U2 ; v4(134.16,173.83) U13139.F10 ; U13114.K12 150.96,142.88 v4(151.27,142.56) ; v4(126.05,124.05) 126.05,124.35 125.7,124.7 U13141.R1 125.7,124.77 v4(125.37,125.1) ; v4(180.23,177.12) U13137.A13 ; v4(198.94,135) U13135.L13 ; U13138.M12 201.37,157.68 v4(201.54,157.51) ; U13141.W11 128.3,131.27 v4(127.97,130.95) U13141.V10 ; U13142.B10 v4(127.97,146.1) ; v4(200.24,135.65) U13135.J13 ; v4(130.91,169.93) U13139.M5 ; U13136.L13 v4(200.24,123.1) ; v4(201.54,117.25) U13136.M3 ; U13138.C2 v4(195.04,151.01) U13138.C1 195.15,150.46 195.15,149.82 v4(195.48,149.49) ; U13140.U13 v4(147.25,175.78) U13140.U14 146.74,175.64 v4(146.27,175.64) 146.18,175.73 C96145.1 ; U13136.W1 v4(206.09,115.95) U13136.W2 ; v4(120.82,125.1) U13141.G2 ; v4(195.69,156.86) U13138.D10 ; U13138.M3 v4(201.54,152.31) ; v4(202.84,135.65) U13135.E13 ; v4(129.61,170.58) U13139.L2 ; v4(174.19,177.36) 174.09,177.26 ; v4(198.29,117.25) U13136.H3 ; v4(179.31,164.36) v4(179.31,163.71)
  TOP w0.28: U13141.L1 v4(123.1,124.15) ; U13142.J14 122.77,143.5 v4(122.77,143.45) ; v4(125.27,123.32) 124.72,123.87 v4(124.72,124.45) ; U13140.J14 v4(146.6,170.58)
  TOP w0.3: U13140.H12 v4(147.9,169.28) U13140.G13 ; U13137.J13 v4(179.55,171.23) ; v4(180.85,167.33) U13137.R14 ; v4(196.34,134.35) 196.34,133.28 196.03,132.97 v4(196.03,132.96) ; v4(128.05,172.81) 127.6,173.27 v4(127.16,173.27) ; v4(136.11,173.83) U13139.E13 ; v4(203.27,125.56) 203.3,125.54 v4(203.3,124.56) 203.3,124.4 203.17,124.27 U13136.R14 ; v4(118.89,143.03) 118.89,143.51 U13142.R14 v4(118.87,144.15) ; v4(139.04,167.02) 137.72,167.02 v4(137.41,167.33) ; v4(128.01,168.81) 128.49,168.81 U13139.N1 v4(128.96,169.28) ; U13137.G2 v4(173.05,172.53) U13137.H3 ; v4(170.6,173.27) 170.91,173.27 171.11,173.07 171.36,173.07 v4(171.59,172.83) ; U13137.C13 v4(179.55,175.13) ; U13137.U1 v4(171.75,166.03) ; U13137.E13 v4(179.55,173.83) ; v4(151.94,172.17) 151.98,172.21 U13140.M5 ; U13140.H5 v4(153.1,169.93) ; U13141.R4 v4(125.37,127.05) U13141.P5 ; v4(126.67,146.1) U13142.D10 ; U13137.F5 v4(174.35,173.83) U13137.E4 ; U13141.P10 v4(125.37,130.95) U13141.R11 ; U13137.R11 v4(178.25,167.98) U13137.P10 ; U13141.R14 125.99,133.52 v4(125.99,133.61) ; v4(170.6,174.07) 170.66,174.13 v4(171.61,174.13) ; U13139.F5 131.43,173.7 v4(131.69,173.7) ; v4(126.05,124.05) 126.05,123.95 125.42,123.32 v4(125.27,123.32) ; v4(204.79,134.35) 204.47,134.03 v4(204.47,133.03) ; U13142.M12 121.15,145.12 v4(120.82,145.45) ; 190.84,126.9 193.15,124.59 v4(193.71,124.59) 193.71,125.55 v4(193.65,125.61) ; v4(119.52,132.25) U13141.E13 ; v4(129.61,169.28) U13139.M3 ; v4(139.06,166.22) 137.6,166.22 v4(137.41,166.03) ; v4(196.62,124.59) 196.62,124.59 v4(196.62,125.61) ; v4(133.96,169.54) 134.03,169.61 U13139.M10 ; v4(120.82,132.25) U13141.H12 ; v4(136.11,175.13) U13139.C13 ; U13137.A11 v4(178.25,177.08) 178.02,177.31 v4(178.02,178.39) v4(178.82,178.39) ; U13137.W11 v4(178.25,165.38) U13137.V10 ; v4(120.82,144.15) 120.5,143.82 U13142.N14 120.5,143.82 v4(120.17,144.15) ; v4(118.22,132.25) U13141.C13 ; v4(202.52,139.74) U13135.F5 ; v4(180.85,173.83) 180.96,173.72 180.96,173.3 v4(180.85,173.18) ; v4(138.12,175.51) v4(137.57,175.51) ; v4(171.75,168.63) U13137.N1 v4(172.4,169.28) ; v4(155.73,177.11) 156.56,177.11 v4(156.57,177.09) v4(156.57,176.53) ; U13140.R4 153.42,174.16 v4(153.1,174.48) ; v4(155.84,172.93) 156.15,172.93 v4(156.57,173.36) ; v4(152.33,173.88) 152.41,173.88 U13140.P5 ; U13141.N2 v4(124.07,125.75) U13141.M3 ; U13141.N1 v4(124.72,124.45) ; v4(119.52,133.55) U13141.E14
  TOP w0.305: v4(172.33,125.06) 172.66,124.74 U13114.AT43 ; v4(193.71,124.59) 193.71,124.44 U13136.A14 ; U13138.H10 198.62,156 v4(198.57,155.94) ; U13142.N14 120.29,143.62 v4(120.29,142.96)
  TOP w0.35: C95687.1 203.08,131.55 203,131.63 v4(203,134.24)
  TOP w0.381: v4(145.46,174.36) 145.22,174.59 142.39,174.59 142.13,174.34 v1(140.99,174.34) ; C95816.1 117.57,142.29 v4(117.48,142.37) ; v4(125.99,133.61) 125.99,133.85 126.35,134.21 v4(126.35,134.97) ; v4(116.15,144.1) 115.84,144.1 115.45,143.72 v1(115.2,143.72) ; v1(203.21,114.36) 202.59,113.74 C96069.1 ; v4(206.26,135.01) 206.3,134.97 v4(206.3,134.34) 206.87,133.76 v4(207.14,133.76) ; C95817.1 119.16,142.76 v4(118.89,143.03) ; v4(128.07,175.53) 127.3,175.53 v4(127.16,175.67) ; v4(128.75,134.97) 128.75,133.71 v4(128.63,133.6)
  TOP w0.406: v4(180.42,178.39) v4(179.62,178.39)
  TOP w0.508: v1(202.71,129.76) R21859.1
  IN1 w0.254: v4(120.82,144.15) 120.82,144.13 v4(122.11,142.84) ; v4(136.76,169.93) 136.11,170.58 v4(136.11,171.23) ; v4(200.32,134.26) 199.69,134.9 199.69,135.14 200.2,135.65 v4(200.24,135.65)
  IN1 w0.305: v4(203.49,136.95) v4(204.14,137.6)
  IN4 w0.254: v4(123.42,133.55) 123.42,133.92 v4(122.56,134.78)
  IN5 w0.254: v3(115.08,101.64) 115.08,100.42 113.94,99.28 109.06,99.28 107.69,97.91 107.69,90.39 105.46,88.15 105.46,78.48 106.88,77.05 v1(107.59,77.05) ; v4(201.94,115.17) 201.94,114.83 v4(202.37,114.4) 202.43,114.4 203.13,115.11 v4(203.17,115.11) ; v4(204.77,114.4) 204.72,114.45 v4(204.72,115.2) ; v4(197.64,134.35) 197.02,133.73 196.81,133.73 v4(196.03,132.96) ; v4(123.42,150) v4(124.07,150.65) ; v4(198.29,135) v4(198.94,135)
  BOTTOM w0.254: C95814.1 128.11,141.82 v4(127.89,142.03) ; C95117.1 138.13,149.13 v1(137.43,149.83) ; C96065.2 116.97,149.42 v4(116.81,149.26) ; v4(120.84,146.77) 121.08,147.01 C95823.2 ; v4(117.65,152.75) 117.6,152.8 v4(117.6,153.5) 118.25,154.15 C95085.1 ; C96073.2 122.1,151.32 v4(122.12,151.3) ; v4(127.32,149.35) 127.25,149.27 C96063.2 ; v4(128.67,150.02) 129.02,149.67 C95821.2 ; R21874.1 121.56,139.36 v1(122.37,140.17) ; C95830.1 115.8,153.07 v4(116.25,152.62) ; v4(115.82,150.3) 115.94,150.18 C96064.2 ; C96068.2 123.27,144.65 v4(122.77,144.15) ; C95825.2 126.52,146.25 v4(126.67,146.1) ; C95826.2 125.06,146.52 125.37,146.22 v4(125.37,146.1) ; C95824.2 121.07,149.04 v4(121.14,149.1) ; v1(140.99,174.34) 141.24,174.08 R21869.1 ; v4(179.55,172.53) 179.32,172.3 C96108.2 ; C95828.1 127.28,142.72 v4(127.28,143.46) ; v4(123.42,150) 123.6,149.82 C95819.2 ; v3(122.17,100.37) 123.69,98.85 127.81,98.85 129.56,97.1 129.56,89.83 124.8,85.07 124.8,76.94 v1(121.41,73.55) ; C96066.2 120.13,146.83 v4(120.19,146.77) ; v4(194.39,140.2) 194.55,140.04 C95681.2 ; C95818.1 128.18,146.3 v4(127.97,146.1) ; C96046.2 126.16,143.29 v4(125.99,143.46) ; v1(182.32,145.05) 182.82,144.54 C95130.1 ; C95822.2 118.09,146.88 v4(118.22,146.75) ; v4(116.91,146.76) 116.83,146.84 C96116.2
  BOTTOM w0.381: C95827.1 128.55,152.77 v4(128.62,152.7) ; C96042.1 116.11,146.13 v4(116.16,146.08) ; v4(116.15,143.37) 115.24,142.47 C96117.1 ; C96114.1 v1(115.2,143.72)
  vias: v1(119.83,168.42) v1(119.81,167.76) v1(119.9,114.92) v1(120.16,163.85) v1(120.52,168.44) v1(120.47,167.76) v1(120.7,163.08) v1(121.1,163.85) v1(121.23,168.44) v1(121.18,167.76) v1(121.91,168.44) v1(121.89,167.76) v1(121.86,163.06) v1(122.17,163.82) v1(122.6,168.44) v1(122.58,167.73) v1(125.12,171.8) v1(136.8,150.46) v1(145.51,166.74) v1(182.82,145.53) v1(184.32,175.12) v1(184.73,172.48) v1(184.7,165.41) v1(190.26,124.53) v1(192.93,133.29) v1(193.18,161.21) v1(207.17,136.86) v1(208.4,132.89) v1(208.4,132.11) v3(115.08,105.45) v3(115.08,104.69) v3(115.08,103.93) v3(115.08,103.17) v3(115.08,102.4) v3(115.84,105.45) v3(115.84,104.69) v3(115.84,103.93) v3(115.84,103.17) v3(115.84,102.4) v3(115.84,101.64) v3(116.61,105.45) v3(116.61,104.69) v3(116.61,103.93) v3(116.61,103.17) v3(116.61,102.4) v3(116.61,101.64) v3(117.57,115.59) v3(117.57,114.82) v3(117.57,114.06) v3(117.57,113.3) v3(117.57,112.54) v3(117.57,111.78) v3(117.57,111.01) v3(117.57,110.25) v3(118.33,115.59) v3(118.33,114.82) v3(118.33,114.06) v3(118.33,113.3) v3(118.33,112.54) v3(118.33,111.78) v3(118.33,111.01) v3(118.33,110.25) v3(118.69,106.39) v3(118.69,105.63) v3(118.69,104.87) v3(119.1,115.59) v3(119.1,114.82) v3(119.1,114.06) v3(119.1,113.3) v3(119.1,112.54) v3(119.1,111.78) v3(119.1,111.01) v3(119.1,110.25) v3(119.45,106.39) v3(119.45,105.63) v3(119.45,104.87) v3(120.21,106.39) v3(120.21,105.63) v3(120.21,104.87) v3(120.64,100.37) v3(121.41,100.37) v4(115.21,134.54) v4(116,126.89) v4(116.13,125.41) v4(116.13,124.77) v4(116.3,134.59) v4(116.27,133.55) v4(116.27,132.9) v4(116.27,132.25) v4(116.92,150.65) v4(116.93,130.26) v4(116.87,127.88) v4(116.92,126.4) v4(117.17,123.6) v4(117.57,151.95) v4(117.57,151.3) v4(117.6,133.59) v4(117.9,134.59) v4(118.22,126.4) v4(118.22,125.1) v4(119.22,124.31) v4(119.52,127.7) v4(119.52,127.05) v4(119.91,133.95) v4(120.17,132.9) v4(120.17,131.6) v4(120.17,126.4) v4(120.37,123.6) v4(120.55,124.19) v4(120.82,134.1) v4(121.05,127.95) v4(124.72,126.4) v4(125.37,131.6) v4(126.02,126.4) v4(126.87,165.25) v4(127.16,172.47) v4(128.72,142.06) v4(130.26,176.43) v4(130.26,173.19) v4(130.26,168.63) v4(130.26,166.03) v4(132.19,178.08) v4(135.46,175.78) v4(135.46,173.18) v4(135.46,167.98) v4(136.19,178.08) v4(138.15,178.14) v4(145.82,177.2) v4(145.91,178.01) v4(146.62,177.2) v4(146.71,178.01) v4(147.25,173.18) v4(147.25,172.53) v4(150.61,140.43) v4(150.61,139.1) v4(150.61,138.33) v4(150.63,136.19) v4(150.61,134.9) v4(150.61,134.13) v4(150.61,132.8) v4(150.61,130.7) v4(150.61,129.93) v4(150.61,128.6) v4(152.04,142.56) v4(152.04,141.86) v4(153.37,142.56) v4(153.75,176.43) v4(154.14,142.56) v4(155.47,142.56) v4(155.47,141.86) v4(155.73,175.81) v4(156.24,142.56) v4(156.24,141.86) v4(157.57,142.56) v4(157.57,141.86) v4(158.24,141.79) v4(158.34,142.56) v4(159.67,142.56) v4(159.7,141.84) v4(160.44,142.56) v4(160.47,141.85) v4(161.77,142.56) v4(161.77,141.86) v4(162.54,142.56) v4(163.87,142.56) v4(163.87,141.86) v4(164.64,142.56) v4(164.64,141.86) v4(165.96,142.57) v4(165.97,141.87) v4(166.74,142.56) v4(167.38,142.59) v4(168.07,142.56) v4(168.07,141.86) v4(168.84,142.56) v4(170.17,142.56) v4(170.17,141.86) v4(170.3,166.43) v4(170.3,164.83) v4(170.56,142.21) v4(171.61,140.43) v4(171.61,139.1) v4(171.61,137) v4(171.61,136.23) v4(171.61,134.9) v4(171.61,134.13) v4(171.61,132.8) v4(171.61,130.7) v4(171.61,129.93) v4(171.61,128.6) v4(171.61,127.81) v4(172.31,140.43) v4(172.31,139.1) v4(172.31,138.33) v4(172.31,137) v4(172.31,136.23) v4(172.31,134.9) v4(172.31,134.13) v4(172.31,132.8) v4(172.31,132.03) v4(172.31,130.7) v4(172.31,129.93) v4(172.31,128.6) v4(172.31,127.83) v4(172.31,127.19) v4(173.7,176.43) v4(173.7,173.18) v4(173.7,168.63) v4(173.7,167.33) v4(175.2,173.74) v4(178.9,175.78) v4(178.9,173.18) v4(178.9,167.98) v4(179.31,142.55) v4(179.55,177.08) v4(182.31,167.14) v4(182.33,165.54) v4(182.31,163.94) v4(182.31,163.14) v4(193.04,125.55) v4(193.1,159.46) v4(193.13,143.28) v4(193.13,123.73) v4(195.6,161.17) v4(196.34,141.5) v4(196.99,152.31) v4(196.99,136.3) v4(196.99,117.25) v4(197.64,157.51) v4(197.64,141.5) v4(197.64,122.45) v4(199.6,121.03) v4(200.19,121.03) v4(201.54,151.01) v4(201.54,123.75) v4(201.54,115.95) v4(202.19,151.01) v4(202.19,141.5) v4(202.19,136.3) v4(202.19,123.75) v4(202.19,115.95) v4(202.51,154.45) v4(202.91,118.65) v4(203.49,158.16) v4(204.14,117.25) v4(204.79,151.01) v4(204.79,136.3) v4(205.44,152.31) v4(205.44,141.5) v4(205.44,117.25) v4(206.14,151.65) v4(206.12,115.28) v4(206.22,114.72) v4(206.92,150.33) v4(207.02,144.28) v4(207.54,157.83)
FBVDDQ_SENSE: length 151.5
  TOP w0.203: PR9138.2 121.36,74.44 v1(121.43,74.51) ; U13114.E52 180.16,147.61 181.51,147.61 182.42,146.7 v1(182.42,146.3)
  IN2 w0.203: v1(121.43,74.51) 125.42,78.5 125.42,84.07 126.39,85.03 126.39,88.43 128.06,90.11 128.06,93.06 126.89,94.23 126.89,96.09 127.05,96.24 127.05,108.8 126.24,109.6 126.24,112.99 126.28,113.03 126.28,115.96 126.99,116.68 126.99,118 127.62,118.63 130.02,118.63 130.83,117.82 131.21,117.82 131.8,118.41 131.8,118.79 132.33,119.32 133.34,119.32 135.66,121.63 136.29,121.63 138.6,123.94 142.29,123.94 143.17,124.83 143.17,126.23 142.13,127.27 138.24,127.27 136.11,129.4 136.11,136.29 138.98,139.16 138.98,147.74 143.07,151.83 157.45,151.83 159.79,154.17 174.54,154.17 v1(182.42,146.3)
FLIP_EDP: length 4.8
  TOP w0.14: U13079.21 332.88,71.41 332.71,71.24 331.52,71.24 v1(331.39,71.11) 331.34,71.06 331.34,69.91 R20938.2 R20936.2
FLIP_TBT_CLK: length 4.8
  TOP w0.14: R20833.1 R20838.1 331.24,51.11 331.24,52.21 331.55,52.52 332.33,52.52 332.63,52.82 U13025.21
FN+F9_BLACKLIGHT: length 68.7
  IN5 w0.089: v1(176.35,58.44) 175.89,57.98 175.03,57.98 174.23,57.18 174.23,56.14 173.01,54.92 170.1,54.92 168.9,53.73 155.73,53.73 155.07,54.39 141.65,54.39 140.84,55.19 126.9,55.19 126.7,54.99 125.5,54.99 125.49,54.98 122,54.98 v1(121.47,55.52)
  BOTTOM w0.14: R67300.1 127.05,50.21 Q7939.1 127.48,50.64 R67299.1 125.43,51.55 v1(121.47,55.52) ; R67394.2 176.47,58.31 v1(176.35,58.44)
FN+F9_BLACKLIGHT_R: length 7.2
  TOP w0.14: v1(125.88,54.07) 125.93,54.12 CN2049.5
  BOTTOM w0.14: Q7939.3 128.26,50.45 R67299.2 128.26,51.97 R67302.1 127.71,52.72 127.45,52.98 126.97,52.98 v1(125.88,54.07)
FRM_LCK#: length 223.1
  TOP w0.14: Q7821.3 333.73,84.09 v1(333.66,84.15) ; R21590.2 138.32,113.45 138.42,113.35 138.96,113.35 139.38,113.77 v1(139.67,113.77) 139.85,113.95 139.85,114.09 142.44,116.68 143.63,116.68 U13114.BG2
  IN1 w0.089: v1(139.67,113.77) 139.67,113.23 141.24,111.65 141.24,108.31 142.29,107.26 142.29,103.72 141.94,103.37 141.94,102.39 143.81,100.52 146.07,100.52 146.23,100.36 149.53,100.36 149.85,100.68 152.06,100.68 157.64,95.09 200.93,95.09 v1(202.2,93.82)
  IN3 w0.079: v1(333.66,84.15) 333.51,84 333.07,84 331.93,82.86 305.62,82.86 305.07,83.41 299.79,83.41 297.92,85.28 294.58,85.28 293.42,84.12 289.86,84.12 289.46,84.51 285.99,84.51 284.13,86.37 284.13,86.52 283.57,87.08 283.42,87.08 280.46,90.04 208.29,90.04 206.41,91.91 206.17,91.91 204.26,93.82 v1(202.2,93.82)
FRM_LCK#_PANEL: length 22.1
  TOP w0.14: Q7821.1 335.19,83.43 335.76,83.99 335.76,84.5 335.99,84.73 338.81,84.73 v1(340.15,86.07) 340.72,86.64 340.72,87.25 341.07,87.6 341.42,87.6 v1(342.79,86.22) ; v1(348.84,81.86) 348.35,81.37 CN2042.19
  IN4 w0.089: v1(342.79,86.22) 343.2,85.82 344.88,85.82 v1(348.84,81.86)
GC6FBEN: length 33
  TOP w0.14: v1(125.95,117.01) 125.95,117.14 126.27,117.45 U13118.1 ; v2(146.41,120.16) U13114.BB5 ; R21573.2 130.42,115.92 130.16,116.18 Q7856.2 130.64,117.96 v1(131.03,118.36)
  IN1 w0.089: v2(146.41,120.16) 145.65,120.92 143.89,120.92 143.49,121.31 140.54,121.31 139.89,120.67 138.65,120.67 138,121.31 132.93,121.31 131.59,119.98 131.59,118.5 131.45,118.36 v1(131.03,118.36) 130.5,118.89 130.5,119.32 129.59,120.23 128.93,120.23 128.72,120.03 128.72,119.22 126.79,117.28 126.23,117.28 v1(125.95,117.01)
  BOTTOM w0.14: v1(125.95,117.01) 125.95,117.14 126.27,117.45 Q7865.2 125.79,117.71 v1(125.6,117.9)
GC6FBEN_Q: length 257.4
  TOP w0.14: v1(302.86,79.37) 302.79,79.29 R67216.2 ; Q7855.3 129.66,119.9 129.38,119.63 v1(129.15,119.63)
  IN1 w0.089: v1(302.86,79.37) 303.14,79.37 303.8,78.71 307.49,78.71 308.5,77.69 318.91,77.69 320.9,75.71 322.4,75.71 326.13,79.44 v1(328.9,79.44)
  IN1 w0.14: v1(129.15,119.63) 129.15,118.71 128.93,118.48 128.93,115.35 128.24,114.67 128.24,113.28 128.57,112.96 128.57,111.63 128.24,111.31 128.24,100.85 129.69,99.4 133.82,99.4 134.47,98.75 138.02,98.75 138.17,98.9 140.62,98.9 141.28,98.24 151.18,98.24 156.03,93.39 198.32,93.39 199.28,92.42 199.28,89.63 198.39,88.74 198.39,85.13 205.07,78.45 205.07,78.15 v1(205.25,77.97)
  IN2 w0.089: v1(302.86,79.37) 300.88,77.39 298.9,77.39 v1(297.2,75.68)
  IN3 w0.079: v1(205.25,77.97) 205.4,78.11 206.76,78.11 212.42,83.77 276.42,83.77 281.92,78.27 283.13,77.06 283.13,76.28 284.31,75.09 292.88,75.09 293.21,75.42 296.94,75.42 v1(297.2,75.68)
  BOTTOM w0.14: v1(328.9,79.44) 328.9,78.76 v1(329.08,78.58) 329.08,78.57 329.94,77.71 329.94,71.54 329.61,71.21 R67218.1
GC6FBEN_Q_EC: length 2.4
  BOTTOM w0.14: v1(128.29,119.4) 128.53,119.16 Q7945.3 128.53,118.52 129.02,118.03 R67395.1
GC6FBEN_Q_NL5: length 5.5
  TOP w0.14: R67216.1 302.87,78.23 304.06,77.04 304.06,75.73 303.98,75.66 303.98,73.96 304.3,73.64 U13113.AG43
GC6FBEN_Q_ZRYD_WS1: length 27
  TOP w0.14: U13113.AV29 309.82,66.82 v2(309.57,67.07)
  IN1 w0.089: v1(324.94,71.04) 324.63,71.35 322.1,71.35 321.1,70.35 319.12,70.35 318.79,70.02 318.03,70.02 317.14,69.13 316.22,69.13 315.84,69.51 313.96,69.51 312.11,67.66 310.15,67.66 v2(309.57,67.07)
  BOTTOM w0.14: R67217.1 R67218.2 329.16,71.31 328.47,72 328.47,73.22 328.32,73.37 R21311.2 326.86,73.37 326.31,72.81 326.31,72.25 325.73,71.67 R21312.1 325.73,70.91 325.68,70.86 325.11,70.86 v1(324.94,71.04)
GFX_SCL: length 29.3
  TOP w0.14: U13114.BJ8 147.81,115.96 v2(147.81,115.98)
  IN1 w0.089: v1(148.03,101.13) 148.03,101.39 147.59,101.82 144.87,101.82 144.13,102.56 143.57,102.56 143.28,102.85 143.28,103.17 143.1,103.34 143.1,108.09 142.77,108.42 142.77,108.97 145.6,111.8 145.6,113.19 146.24,113.83 146.24,117.22 147.6,118.58 147.98,118.58 148.27,118.29 148.27,116.46 147.81,115.99 v2(147.81,115.98)
  BOTTOM w0.14: R21599.2 147.6,101.56 v1(148.03,101.13) 147.92,101.13 147.47,100.68 Q7858.1
GFX_SDA: length 25
  TOP w0.127: U13114.BH8 148.16,116.31 v2(147.8,116.66)
  IN1 w0.089: v1(149.25,101.31) 148.46,102.1 148.25,102.1 148.07,102.29 145.07,102.29 143.57,103.79 143.57,108.21 144.17,108.8 144.17,109.7 146.07,111.61 146.07,113 146.71,113.63 146.71,116.85 146.93,117.07 147.25,117.07 147.66,116.66 v2(147.8,116.66)
  BOTTOM w0.14: Q7860.4 149.89,100.54 149.25,101.18 v1(149.25,101.31) 149.49,101.56 R21600.2
GPD2: length 7.3
  TOP w0.102: U13113.BD11 312.85,57.8 313.22,58.05 313.85,58.05 314.2,57.7 315.28,57.7 315.53,57.45 317.11,57.45 v1(317.11,57.46)
  TOP w0.14: R21124.2 319.61,57.19 317.46,57.19 317.19,57.46 v1(317.11,57.46)
GPIO17_IFPD_HPD_EDP: length 7.3
  TOP w0.14: U13114.BH1 142.68,116.31 140.38,114.01 140.38,113.78 139.9,113.3 139.52,113.3 139.27,113.05 R21561.2 139.22,112.87 138.6,112.87 v1(138.58,112.84) 138.11,112.38 Q7854.3
GPIO18_IFPE_HPD_DP: length 10.8
  TOP w0.127: U13114.BE3 144.31,118.76
  TOP w0.14: v1(136.9,117.44) 137.05,117.29 R21560.2 ; R21560.2 137.18,116.78 137.34,116.62 139.33,116.62 139.82,117.11 141.12,117.11 142.77,118.76 144.31,118.76 ; R21560.2 136.52,116.78 136.29,116.55 Q7852.3
GPIO18_IFPE_HPD_Q: length 2.9
  TOP w0.14: Q7852.2 134.5,117.71 v1(134.41,117.8) 134.27,117.94 R21563.1 R21566.1
GPIO24_IFPF_HPD_TBT: length 16.5
  TOP w0.14: R21881.2 131.94,119.42 131.82,119.3 Q7880.3 v1(132.49,118.85) ; v2(145.71,119.46) U13114.BD5
  BOTTOM w0.14: v2(145.71,119.46) 145.71,119.34 145.36,118.99 144.8,118.99 144.5,119.3 143.68,119.3 143.58,119.19 139.03,119.19 138.7,118.86 137.76,118.86 137.18,118.28 v1(134.08,118.28) 133.55,118.28 132.97,118.85 v1(132.49,118.85)
GPIO27_IFPC_HPD_HDMI: length 16.8
  TOP w0.14: v2(145.01,121.56) U13114.BA4
  IN1 w0.114: v2(145.01,121.56) 144.63,121.19 143.95,121.19 143.63,121.5 140.51,121.5 140,122.02 138.43,122.02 137.92,121.5 132.48,121.5 v1(131.85,120.87)
  BOTTOM w0.14: v1(131.85,120.87) 131.94,120.77 R21562.2 131.94,119.44 131.74,119.24 Q7853.3
GPIO27_IFPE_HPD_Q: length 2.8
  BOTTOM w0.14: v1(132.94,117.36) 132.75,117.55 Q7853.2 132.24,117.2 132.22,117.18 132.22,116.57 R21567.1 R21565.1
GPIO28_OC_WARN#: length 86.1
  IN2 w0.089: v1(136.67,120.49) 135.91,119.73 135.02,119.73 134.39,119.09 134.39,115.79 131.57,112.97 131.19,112.97 130.96,112.74 130.96,112.33 130.46,111.83 130.46,105.5 130.15,105.2 130.15,89.1 128.19,87.15 128.19,84.33 127.33,83.47 127.33,78.27 132.84,72.76 132.84,70.78 131.64,69.59 127.63,69.59 v1(126.64,70.58)
  BOTTOM w0.14: v1(126.64,70.58) 126.44,70.58 125.5,71.52 121.98,71.52 120.74,70.29 119.67,70.29 118.8,71.16 v1(117.5,71.16) 117.01,71.16 116.17,70.32 115.72,70.32 114.32,68.93 114.32,65.12 115.1,64.34 PQ147.3 ; v1(136.67,120.49) 136.12,119.94 D8588.1
GPIO28_OC_WARN#_Q: length 15.4
  TOP w0.14: v2(145.71,120.16) U13114.BB4
  IN1 w0.089: v1(134.26,120.87) 134.53,121.14 137.93,121.14 138.58,120.49 139.96,120.49 140.61,121.14 143.42,121.14 143.91,120.64 145.23,120.64 v2(145.71,120.16)
  BOTTOM w0.14: D8588.2 134.43,120.7 v1(134.26,120.87) 134.64,121.25 R21596.2
GPP_B2: length 5.2
  TOP w0.102: v1(314.47,63.59) 314.09,63.97 313.34,63.97 312.84,63.47 U13113.BD23
  BOTTOM w0.14: R21101.1 315.74,64.23 315.62,64.1 314.98,64.1 v1(314.47,63.59)
GPU_CLK: length 143.3
  TOP w0.102: v2(154.12,118.76) 154.46,118.42 U13114.BE17 ; C94749.1 225.57,166.16 225.67,166.06 225.67,165.7 225.52,165.55 v1(225.45,165.55)
  IN1 w0.089: v2(154.12,118.76) 154.31,118.57 154.54,118.57 154.77,118.34 154.77,114.33 155.9,113.2 156.15,113.2 156.61,112.74 156.61,106.01 157.26,105.36 157.26,104.19 157.5,103.95 157.5,103.22 161.96,98.76 167.37,98.76 168.28,97.84 190.13,97.84 200.26,107.98 204.65,107.98 211.01,114.34 211.01,158.19 215.01,162.18 218.65,162.18 220.83,164.37 224.95,164.37 225.78,165.19 225.78,165.45 225.67,165.55 v1(225.45,165.55)
GPU_CLK#: length 143.5
  TOP w0.102: C94750.1 v1(226.33,165.6) ; U13114.BF17 154.36,117.71 154.08,117.99 v2(154.08,118.04)
  IN1 w0.089: v1(226.33,165.6) 226.04,165.31 226.04,165.08 225.06,164.1 220.94,164.1 218.76,161.92 215.12,161.92 211.28,158.08 211.28,114.23 204.76,107.71 200.38,107.71 190.24,97.58 168.17,97.58 167.26,98.49 161.85,98.49 157.23,103.11 157.23,103.84 156.99,104.08 156.99,105.25 156.34,105.9 156.34,112.63 156.04,112.93 155.79,112.93 154.5,114.22 154.5,118.23 154.43,118.3 154.35,118.3 v2(154.08,118.04)
