# Allegro board DAZGLMB1ED0 dazglmb1ed0-d-ver a-165 (.BRD) .brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+3V_SSD2 on BOTTOM (solid shape): 31.9,21.94 31.9,18.08 31.43,17.61 31.43,17.18 31.25,17 30.21,17 30.02,17.19 30.02,18.91 29.7,19.23 29.7,20.86 29.42,21.15 30.69,21.15 30.69,21.09 30.71,21.04 30.73,20.98 30.75,20.93 30.79,20.89 30.83,20.85 30.87,20.82 30.9,20.8 30.9,19.41 30.92,19.39 30.92,19.19 31.41,19.19 31.41,19.39 31.43,19.41 31.43,20.96 31.44,20.99 31.46,21.04 31.48,21.09 31.48,21.15 31.48,21.21 31.46,21.26 31.44,21.31 31.42,21.36 31.38,21.41 31.34,21.45 31.3,21.48 31.25,21.51 31.19,21.53 31.14,21.54 31.08,21.54 31.03,21.54 30.97,21.53 30.92,21.51 30.87,21.48 30.82,21.45 30.78,21.41 30.75,21.36 30.72,21.31 30.7,21.26 30.69,21.2 30.69,21.15 29.42,21.15 29,21.57 28.33,21.57 28.21,21.68 28.21,22.19 28.55,22.52 31.31,22.52
+3V_SSD2 on IN1 (solid shape): outline of 2370 points within 28.14,16.98 48.74,29.33
+3V_TYPEC_DP on TOP (solid shape): 334.08,63.33 334.08,61.64 333.82,61.39 333.82,60.85 333.66,60.65 333.66,60.39 333.67,60.36 333.52,60.21 333.52,59.91 333.47,59.86 333.32,59.86 333.22,59.96 333.22,60.77 333.28,60.84 333.28,61.09 333.31,61.12 333.31,61.34 333.28,61.37 333.28,61.56 332.8,61.56 332.8,61.37 332.67,61.23 332.59,61.23 331.89,60.53 330.86,60.53 330.21,60.53 329.77,60.97 329.77,62.25 329.86,62.33 329.86,62.33 329.98,62.45 331.95,62.45 331.97,62.44 332.8,62.44 332.81,62.45 332.92,62.45 333.1,62.63 333.1,63.22 333.33,63.45 333.95,63.45
+3V_TYPEC_DP on BOTTOM (solid shape): outline of 966 points within 328.13,47.36 334.57,62.12
+3V_U3_R on TOP (solid shape): 28.77,56.65 28.97,56.6 29.17,56.65 29.75,56.65 29.83,56.58 29.83,55.79 29.72,55.68 29.72,55.6 29.72,55.59 29.7,55.46 29.72,55.34 29.72,55.33 29.72,54.1 29.67,54.05 29.15,54.05 29.06,54.14 29.06,55.19 28.82,55.42 28.3,55.42 28.21,55.34 28.21,54.81 28.48,54.55 28.48,54.05 28.42,54 25.66,54 25.58,54.08 25.58,56.19 26.04,56.65
+3V_U3_R on BOTTOM (solid shape): 31.65,54.06 31.65,52.77 31.53,52.65 30.27,52.65 29.84,53.08 29.84,54.12 30.02,54.3 31.41,54.3
+3V_U3_R on IN2 (solid shape): outline of 898 points within 24.25,42.18 31.54,56.18
+3VA on TOP (solid shape): 16.66,19.4 16.66,18.51 16.53,18.38 15.64,18.38 15.39,18.63 15.39,19.14 15.77,19.52 16.53,19.52
+3VA on TOP (solid shape): 24.05,20.11 24.05,18.81 24.02,18.79 22.8,18.79 22.6,18.99 22.6,19.68 23.11,20.18 23.97,20.18
+3VA on BOTTOM (solid shape): 24.1,19.68 24.1,18.76 24.02,18.68 22.81,18.68 22.68,18.81 22.68,19.56 22.68,19.58 22.69,19.6 22.88,19.78 24,19.78
+3VA on BOTTOM (solid shape): 16.66,19.4 16.66,18 16.53,17.87 15.94,17.87 15.93,17.9 15.56,18.14 15.2,17.9 15.19,17.87 14.02,17.87 13.94,17.95 13.94,18.6 14.46,19.12 15.08,19.12 15.49,19.52 16.53,19.52
+3VA on IN3 (solid shape): outline of 987 points within 12.01,18.76 24.02,32.99
+3VPCU on TOP (solid shape): 44.55,75.53 44.55,73.85 44.11,73.42 42.54,73.42 42.34,73.63 42.34,75.78 42.54,75.99 44.09,75.99
+3VPCU on TOP (solid shape): 39.03,76.57 39.03,74.34 38.65,73.96 36.57,73.96 36.41,74.12 36.41,75.06 36.37,75.1 36.37,75.45 35.85,75.97 35.85,76.56 36.07,76.78 38.83,76.78
+3VPCU on TOP (solid shape): 92.32,79.44 92.56,79.44 92.56,80.13 92.98,80.13 94.61,78.5 94.61,78.17 94.41,77.97 93.75,77.97 93.59,77.82 93.59,77.79 93.54,77.74 92.48,77.74 92.07,78.15 92.07,80.1 92.1,80.13 92.32,80.13
+3VPCU on TOP (solid shape): 252.27,154.27 252.44,154.27 252.46,154.25 253.25,154.25 253.26,154.25 253.26,154.12 253.19,154.06 252.31,154.06 252.22,153.97 252.22,153.61 252.08,153.47 251.62,153.47 251.28,153.81 251.28,154.21 251.35,154.28 252.25,154.28
+3VPCU on TOP (solid shape): 266.47,151.76 267.07,151.76 267.08,151.74 267.85,151.74 267.86,151.73 267.86,151.58 267.84,151.55 266.82,151.55 266.64,151.38 266.64,151.17 266.52,151.05 266.06,151.05 265.91,151.2 265.91,151.91 266.31,151.91
+3VPCU on TOP (solid shape): 259.69,151.79 260.46,151.79 260.47,151.78 260.47,151.63 260.45,151.6 259.4,151.6 258.54,150.74 258.36,150.74 258.22,150.88 258.22,151.29 258.67,151.73 259.13,151.73 259.2,151.81 259.68,151.81
+3VPCU on TOP (solid shape): 245.05,154.25 245.99,154.25 246.02,154.22 246.02,154.09 245.98,154.06 245.63,154.06 245.62,154.06 245.21,154.06 245.19,154.04 245.03,154.04 245,154.02 245,153.53 244.93,153.46 244.62,153.46 244.11,153.97 244.11,154.27 244.15,154.31 244.99,154.31
+3VPCU on TOP (solid shape): outline of 115 points within 61.44,59.42 69.53,69.95
+3VPCU on BOTTOM (solid shape): 347.47,89.07 347.47,88.28 347.41,88.22 345.12,88.22 345.05,88.29 345.05,89.02 345.27,89.25 347.29,89.25
+3VPCU on BOTTOM (solid shape): 346.1,65.37 346.1,64.47 346.06,64.39 346.04,64.31 346.03,64.29 345.71,63.97 344.57,63.97 344.32,64.23 344.32,65.4 344.57,65.65 345.82,65.65
+3VPCU on BOTTOM (solid shape): 377.09,9.04 377.09,8.29 377.12,8.26 377.77,8.26 377.79,8.28 377.79,8.5 377.93,8.64 378.83,8.64 378.91,8.57 378.91,8.3 378.55,7.94 378.55,7.56 378.35,7.36 378.08,7.36 377.77,7.67 377.22,7.67 376.98,7.91 376.41,7.91 376.06,8.26 376.06,9.04 376.12,9.11 376.21,9.11 376.26,9.07 376.26,8.29 376.26,8.29 376.45,8.29 376.46,8.29 376.46,9.07 376.51,9.13 377,9.13
+3VPCU on BOTTOM (solid shape): 70.12,67.43 70.12,66.88 70.09,66.81 70.02,66.78 69.55,66.34 70.02,65.89 70.09,65.86 70.12,65.79 70.12,64.94 69.92,64.74 68.12,64.74 67.84,64.46 65.76,64.46 65.64,64.34 65.64,62.94 64.46,61.77 63.28,61.77 62.73,62.32 62.73,65.74 63.81,66.82 66.55,66.82 66.77,67.05 68.35,67.05 68.88,67.58 69.97,67.58
+3VPCU on BOTTOM (solid shape): outline of 120 points within 85.49,78.27 94.3,82.9
+3VPCU on IN3 (solid shape): outline of 700 points within 341.65,63.92 355.98,73.63
+3VPCU on IN4 (solid shape): 345.75,65.72 345.82,65.71 345.94,65.59 345.94,64.48 345.47,64 342.16,64 341.75,64.41 341.75,65.68 341.8,65.73 345.7,65.73
+3VPCU on IN4 (solid shape): outline of 6128 points within 35.91,59.25 148.36,82.01
+3VPCU on IN5 (solid shape): outline of 1267 points within 343.89,72.1 361.39,93.29
+5V on TOP (solid shape): 324.5,77.45 324.5,76.2 324.31,76.02 323.84,76.02 323.65,76.2 323.65,77.4 323.75,77.5 324.45,77.5
+5V on TOP (solid shape): 34.54,25.96 34.54,25.57 33.96,24.99 33.96,24.59 33.94,24.56 33.89,24.54 33.86,24.52 33.38,24.52 33.17,24.73 32.88,24.73 32.79,24.74 32.69,24.73 31.29,24.73 31.13,24.57 31.13,24.57 30.48,23.93 29.76,23.93 28.22,22.39 26.76,22.39 26.72,22.43 26.72,22.85 26.82,22.94 28.08,22.94 29.52,24.38 30.27,24.38 30.33,24.44 30.33,25.02 30.88,25.58 31.82,25.58 32.05,25.81 33.47,25.81 33.82,26.15 34.35,26.15
+5V on TOP (solid shape): 19.32,36.41 20.76,36.41 20.8,36.41 20.83,36.41 21.11,36.41 21.14,36.41 21.17,36.41 21.54,36.41 21.58,36.41 21.61,36.41 21.89,36.41 21.92,36.41 21.95,36.41 22.63,36.41 22.75,36.29 22.75,35.47 22.94,35.29 22.94,34.92 22.86,34.85 21.95,34.85 21.74,34.64 21.74,33.75 21.61,33.62 20.34,33.62 20.21,33.75 20.21,34.89 19.71,35.4 18.18,35.4 17.93,35.65 17.93,36.8 18.18,37.05 18.69,37.05
+5V on TOP (solid shape): 42.41,43.7 42.41,43.02 41.66,42.27 41.6,42.27 41.6,42.21 41.55,42.16 41.55,40.61 40.94,40 40.54,40 40.51,40.02 40.51,40.03 40.14,40.3 39.76,40.03 39.74,40.01 39.71,40 39.47,40 39.39,40.07 39.37,40.07 39.33,40.09 39.32,40.12 39.32,40.14 39.33,40.16 39.07,40.8 38.68,40.23 38.69,40.19 38.67,40.17 38.58,40.12 38.53,40.07 38.31,40.07 38.31,40.08 37.3,40.08 37.23,40.15 37.23,40.23 37.25,40.27 37.28,40.28 38.31,40.28 38.31,40.48 37.28,40.48 37.25,40.5 37.23,40.53 37.23,40.63 37.25,40.67 37.28,40.69 38.31,40.69 38.31,40.88 37.28,40.88 37.25,40.9 37.23,40.93 37.23,41.03 37.25,41.07 37.28,41.09 38.31,41.09 38.31,41.28 37.28,41.28 37.25,41.3 37.23,41.33 37.23,41.42 37.3,41.48 38.31,41.48 38.31,41.49 39.11,41.49 39.82,42.21 40.05,42.21 41.14,43.3 41.14,43.7 41.32,43.88 42.23,43.88
+5V on BOTTOM (solid shape): 258.54,52.06 258.54,50.56 258.31,50.33 257.45,50.33 257.35,50.44 257.35,51.86 257.7,52.21 258.39,52.21
+5V on BOTTOM (solid shape): 21.99,36.67 21.99,35.5 21.74,35.25 20.24,35.25 19.96,35.53 19.96,36.24 20.52,36.8 21.86,36.8
+5V on BOTTOM (solid shape): 42.69,43.83 42.69,43.3 42.67,43.27 42.67,41.34 41.75,40.43 40.48,40.43 40.41,40.5 40.41,40.96 40.71,41.26 40.71,42.1 40.58,42.23 40.58,43.73 40.76,43.91 42.62,43.91
+5V on BOTTOM (solid shape): 141.12,61.31 145.56,61.31 146.07,60.8 146.07,54.96 145.87,54.75 143.05,54.75 142.87,54.93 142.87,59.27 144.63,59.27 144.63,59.25 144.64,59.19 144.66,59.14 144.68,59.09 144.71,59.04 144.75,59 144.79,58.96 144.84,58.93 144.89,58.91 144.94,58.89 145,58.88 145.06,58.88 145.11,58.89 145.17,58.91 145.22,58.93 145.27,58.96 145.31,59 145.34,59.04 145.38,59.09 145.4,59.14 145.41,59.19 145.42,59.25 145.42,59.3 145.41,59.36 145.4,59.41 145.38,59.46 145.34,59.51 145.31,59.55 145.27,59.59 145.22,59.62 145.17,59.64 145.11,59.66 145.06,59.67 145,59.67 144.94,59.66 144.89,59.64 144.84,59.62 144.79,59.59 144.75,59.55 144.71,59.51 144.68,59.46 144.66,59.41 144.64,59.36 144.63,59.3 144.63,59.27 142.87,59.27 142.87,59.61 142.56,59.91 140.61,59.91 139.97,60.54 138.83,60.54 138.78,60.6 138.78,61.76 138.83,61.81 140.61,61.81
+5V on BOTTOM (solid shape): 116.25,61.9 116.25,61.05 117.29,60.01 117.29,57.78 117.3,57.76 117.3,57.71 117.84,57.18 117.84,56.54 117.63,56.35 115.46,56.35 114.96,56.86 114.96,59 113.76,60.19 113.76,61.96 113.75,61.97 115.07,61.97 115.07,61.91 115.08,61.86 115.09,61.8 115.12,61.75 115.15,61.71 115.18,61.66 115.23,61.63 115.27,61.6 115.33,61.57 115.38,61.56 115.43,61.55 115.49,61.55 115.55,61.56 115.6,61.57 115.65,61.6 115.7,61.63 115.74,61.66 115.78,61.71 115.81,61.75 115.83,61.8 115.85,61.86 115.86,61.91 115.86,61.97 115.85,62.03 115.83,62.08 115.81,62.13 115.78,62.18 115.74,62.22 115.7,62.26 115.65,62.29 115.6,62.31 115.55,62.33 115.49,62.34 115.43,62.34 115.38,62.33 115.33,62.31 115.27,62.29 115.23,62.26 115.18,62.22 115.15,62.18 115.12,62.13 115.09,62.08 115.08,62.03 115.07,61.97 113.75,61.97 113.74,61.98 113.74,62 113.73,62 113.53,62.19 113.53,62.58 113.66,62.7 115.44,62.7
+5V on IN2 (solid shape): outline of 918 points within 142.64,51.65 189.58,59.1
+5V on SVCC (solid shape): outline of 93 points within 27.17,24.73 42.34,45.23
+5V on IN3 (solid shape): outline of 253 points within 115.18,55.21 145.82,58.39
+5V on IN4 (solid shape): outline of 2282 points within 18.23,40.2 41.63,52.44
+5V on IN5 (solid shape): outline of 628 points within 188.21,50.4 258.64,53.94
+5V on IN5 (solid shape): outline of 4583 points within 13.43,35.58 116.86,90.11
+5V_GPU_LED on TOP (solid shape): 86.27,80.44 86.27,79.79 86.3,79.79 86.3,79.34 86.1,79.14 83.51,79.14 83.36,79.29 83.36,80.08 83.76,80.48 86.23,80.48
+5V_HDD on TOP (solid shape): 42.88,42.17 42.9,42.1 42.92,42.03 42.92,41.97 42.92,41.96 42.88,41.7 43.01,41.46 43.16,41.31 43.16,39.84 43.09,39.78 43.09,39.33 42.95,39.18 41.84,39.18 41.73,39.3 41.73,39.67 41.74,39.77 41.73,39.87 41.73,42.1 41.96,42.33 42.72,42.33
+5V_HDD on TOP (solid shape): 69.77,35.27 69.9,35.25 70.02,35.27 70.03,35.27 70.79,35.27 70.8,35.27 70.96,35.23 71.12,35.27 71.13,35.27 73.65,35.27 74.14,34.79 76.42,34.79 76.45,34.77 76.47,34.74 76.47,34.53 75.5,34.53 75.5,34.28 76.47,34.28 76.47,34.02 75.5,34.02 75.5,33.78 76.47,33.78 76.47,33.52 75.5,33.52 75.5,33.28 76.47,33.28 76.47,33.09 76.45,33.05 76.42,33.04 75.43,33.04 74.85,32.45 71.11,32.45 70.28,31.61 69.01,31.61 68.83,31.79 68.83,35.02 69.08,35.27 69.76,35.27
+5V_HDD on BOTTOM (solid shape): 70.8,35.27 70.91,35.24 71.02,35.24 71.03,35.24 71.05,35.23 71.34,34.94 71.34,32.58 71.22,32.45 67.38,32.45 67.15,32.68 67.15,35.12 67.3,35.27 70.79,35.27
+5V_HDD on IN2 (solid shape): outline of 2603 points within 41.8,32.15 71.9,41.34
+5V_HDMIC on TOP (solid shape): 231.69,171.31 231.69,170.1 232.07,169.71 232.07,168.22 231.95,168.09 230.35,168.09 230.3,168.14 230.27,168.24 230.35,168.31 230.61,168.89 229.98,168.96 229.94,168.95 229.9,168.96 229.87,169 229.87,169.05 229.88,169.07 230.03,169.25 230.08,169.45 230.08,171.48 230.09,171.52 230.13,171.53 231.48,171.53
+5V_HDMIC on IN2 (solid shape): outline of 155 points within 227.91,170.6 231.64,174.82
+5V_KB_LED on TOP (solid shape): 255.29,51.91 255.27,51.86 255.25,51.72 255.29,51.57 255.29,51.56 255.29,49.47 254.84,49.02 254.84,49.02 254.6,48.78 254.39,48.78 254.35,48.8 254.34,48.84 254.34,49.9 254.14,49.9 254.14,48.84 254.13,48.8 254.09,48.78 253.87,48.78 253.84,48.81 253.84,51.11 253.82,51.11 253.79,51.14 253.79,51.27 253.82,51.32 253.83,51.32 253.99,51.54 253.97,51.82 253.96,51.84 253.97,51.94 254.05,51.98 255.21,51.98
+5V_KB_LED on BOTTOM (solid shape): 255.2,51.83 255.24,51.82 255.25,51.73 255.25,51.49 255.16,51.4 255.15,51.4 255.07,51.34 255.01,51.25 255.01,51.24 254.98,51.22 254.98,51.02 254.98,50.97 254.99,50.87 255.07,50.7 255.23,50.63 255.38,50.63 255.52,50.63 255.68,50.7 255.75,50.86 255.76,50.88 256.04,51.16 256.04,51.73 256.05,51.82 256.09,51.83 256.92,51.83 257.07,51.68 257.07,50 256.99,49.93 254.32,49.93 253.88,50.37 253.88,51.34 253.88,51.36 253.9,51.38 253.99,51.53 254,51.72 254.03,51.8 254.1,51.83
+5V_KB_M on TOP (solid shape): 129.84,59.96 129.84,58.97 129.48,58.61 126.46,58.61 126.23,58.84 126.23,60.32 126.51,60.6 129.2,60.6
+5V_KB_M on BOTTOM (solid shape): 130.58,59.63 130.58,57.67 130.27,57.37 128.65,57.37 128.21,57.8 128.21,59.78 128.65,60.21 129.99,60.21
+5V_PVDD on TOP (solid shape): 46.43,46.6 46.43,44.03 46.32,43.93 45.33,43.93 44.93,44.34 44.93,46.45 45.21,46.73 46.3,46.73
+5V_PVDD on TOP (solid shape): 33.73,27.83 33.73,26.94 32.79,26 32.28,26 32.15,26.13 32.15,27.27 32.79,27.91 33.65,27.91
+5V_PVDD on BOTTOM (solid shape): outline of 198 points within 28.72,24.73 33.37,28.29
+5V_PVDD on IN5 (solid shape): outline of 1319 points within 30.45,26.97 46.78,46.96
+5V_S5 on TOP (solid shape): 351.89,94.22 351.89,92.61 352.02,92.61 352.02,92.6 352.09,92.52 352.09,92.12 351.84,91.86 350.67,91.86 350.34,92.19 350.34,94.1 350.49,94.25 351.86,94.25
+5V_S5 on TOP (solid shape): 21.37,65.69 22.87,65.69 22.87,65.83 23.38,65.83 23.46,65.79 23.48,65.71 23.41,64.98 23.49,64.26 23.49,64.25 23.56,64 23.64,63.75 23.64,63.59 23.59,63.54 21.41,63.54 20.67,64.28 20.67,65.59 20.91,65.83 21.37,65.83
+5V_S5 on TOP (solid shape): 137.12,69.16 137.37,68.9 137.12,68.65 137.03,68.65 136.42,68.03 136.42,67.77 136.38,67.63 136.27,67.54 135.77,67.54 135.77,67.51 135.39,67.51 135.13,67.77 136.52,69.16
+5V_S5 on TOP (solid shape): outline of 82 points within 23.54,85.46 26.13,91.76
+5V_S5 on TOP (solid shape): 363.99,38.71 364,38.7 364,38.68 364,38.57 364.03,38.54 364.03,38.24 364.31,37.96 365.4,37.96 365.48,37.89 365.48,36.92 365.35,36.8 363.35,36.8 363.28,36.87 363.28,36.88 363.08,37.07 362.68,37.07 362.44,36.84 362.44,36.59 362.34,36.49 361.39,36.49 361.02,36.85 361.07,36.9 361.28,37.38 360.83,37.64 360.74,37.66 360.71,37.74 360.7,37.84 360.67,37.93 360.67,38.12 361.01,38.45 361.83,38.45 362.07,38.21 362.57,38.21 363.04,38.21 363.18,38.66 363.19,38.75 363.27,38.8 363.31,38.8 363.34,38.83 363.88,38.83
+5V_S5 on BOTTOM (solid shape): 117.65,75.05 117.65,73.91 117.55,73.8 116.83,73.8 116.58,74.06 116.58,75.12 116.63,75.18 117.52,75.18
+5V_S5 on BOTTOM (solid shape): 115.08,54.21 115.08,52.24 114.27,51.42 110.61,51.42 110.48,51.55 110.48,52.81 110.6,52.94 112.26,52.94 112.6,53.28 112.6,53.46 112.66,53.52 112.74,53.59 112.81,53.67 112.86,53.73 112.86,54.14 113.18,54.45 114.84,54.45
+5V_S5 on BOTTOM (solid shape): 122.6,59.03 123.38,59.03 123.44,58.97 123.44,58.87 123.4,58.83 122.6,58.83 122.6,58.63 123.41,58.63 123.44,58.61 123.44,58.41 121.05,56.02 121.05,55.41 120.7,55.06 120.06,55.06 119.76,55.36 119.76,56.23 121.53,58 121.53,58.72 121.64,58.82 121.94,58.82 122.17,59.05 122.6,59.05
+5V_S5 on BOTTOM (solid shape): 181.45,85.19 181.45,84.66 181.45,84.6 181.43,84.55 180.97,84.55 180.95,84.6 180.94,84.66 180.94,84.98 180.76,85.16 179.92,85.16 179.71,84.94 179.67,84.91 179.63,84.88 179.42,84.88 179.31,84.98 179.27,85.12 179.29,85.22 179.35,85.3 179.71,85.67 180.97,85.67
+5V_S5 on SVCC (solid shape): outline of 333 points within 1.98,29.18 364.26,94.5
+5V_S5 on IN4 (solid shape): outline of 2659 points within 349.93,36.41 364.81,92.57
+5V_TP_RGB on BOTTOM (solid shape): 138.32,61.81 138.32,59.38 138.31,59.27 138.32,59.17 138.32,59.15 138.07,58.89 137.33,58.89 137.18,59.05 137.18,61.81 137.31,61.94 138.2,61.94
+5VA on TOP (solid shape): 22.37,31.84 22.75,31.84 22.88,31.72 22.88,30.7 22.63,30.45 21.48,30.45 20.72,31.21 20.21,31.21 20.09,31.33 20.09,32.73 20.21,32.86 21.36,32.86
+5VA on TOP (solid shape): 28.72,27.4 28.72,27.14 28.09,26.51 28.09,25.49 27.83,25.24 27.07,25.24 26.94,25.37 26.94,25.75 27.45,26.25 27.45,27.02 27.96,27.02 28.47,27.52 28.6,27.52
+5VA on IN3 (solid shape): outline of 466 points within 21.1,25.24 28.21,32.55
+5VPCU on TOP (solid shape): 360.73,53.99 361.44,53.99 362.55,52.87 362.55,52.09 362.48,52.01 361.72,52.01 361.64,52.01 361.31,52.34 361.31,52.49 360.98,52.82 360.17,52.82 359.99,53 359.99,53.99 360.09,54.09 360.62,54.09
+5VPCU on TOP (solid shape): 100.99,67.28 100.99,64.86 100.97,64.85 100.97,64.34 102.46,62.86 102.46,59.58 102.08,59.2 100.15,59.2 99.77,58.82 99.77,57.85 99.59,57.67 97.53,57.67 97.3,57.9 97.3,62.07 94.5,64.87 94.5,67.4 94.76,67.66 100.6,67.66
+5VPCU on TOP (solid shape): 366.88,38.69 366.9,38.66 366.89,38.63 366.89,38.28 367.14,38.03 367.16,38.01 367.17,37.98 367.17,36.75 367.07,36.64 366.33,36.64 366.32,36.65 366.24,36.68 366.15,36.68 366.07,36.68 365.99,36.65 365.79,36.65 365.68,36.77 365.68,38.42 365.78,38.52 366.21,38.52 366.44,38.75 366.82,38.75
+5VPCU on BOTTOM (solid shape): 374.25,9.06 374.25,8.29 374.26,8.29 374.46,8.29 374.46,8.29 374.46,9.08 374.51,9.14 374.61,9.14 374.65,9.09 374.65,8.13 374.6,8.08 372.55,8.08 372.26,8.36 372.17,8.36 372.12,8.39 372.07,8.4 371.78,8.4 371.7,8.48 371.7,8.73 371.81,8.84 372.25,8.84 372.54,9.14 374.18,9.14
+5VPCU on BOTTOM (solid shape): 366.91,38.63 366.91,38.47 366.91,38.42 366.91,38.22 367.22,37.91 367.6,37.91 367.6,37.78 368.37,37.78 368.39,37.76 368.39,36.91 368.25,36.78 366.71,36.78 366.31,37.18 364.18,37.18 363.43,36.42 362.98,36.42 362.96,36.41 362.76,36.41 362.58,36.59 362.58,37.15 363.42,37.99 364.51,37.99 364.61,37.98 364.72,37.99 364.79,37.99 364.89,38.09 364.92,38.13 365.25,38.45 365.71,38.45 365.87,38.62 366.06,38.62 366.14,38.61 366.21,38.62 366.36,38.62 366.48,38.74 366.8,38.74
+5VPCU on BOTTOM (solid shape): outline of 194 points within 97.81,53.89 108.73,64.37
+5VPCU on IN1 (solid shape): 106.36,64.21 106.36,63.62 106.13,63.39 105.06,63.39 104.83,63.62 104.83,64.32 104.92,64.41 106.16,64.41
+5VPCU on SVCC (solid shape): outline of 1212 points within 97.96,36.49 371.49,69.05
+5VPD on TOP (solid shape): 365.7,36.15 365.7,35.31 366.18,34.83 366.19,34.82 366.19,31.81 366.81,31.19 366.82,31.17 366.82,31.15 366.89,30.86 367.14,30.69 367.16,30.69 367.18,30.66 367.18,30.64 367.75,30.06 367.75,29.42 367.69,29.36 365.95,29.36 365.5,29.81 365.49,29.84 365.5,29.88 365.47,30.4 364.94,30.43 364.91,30.42 364.87,30.44 363.93,31.38 363.93,34.64 363.86,34.71 363.86,36.2 364,36.34 365.52,36.34
+12V_PANEL on TOP (solid shape): 373.15,89.16 373.15,88.28 372.57,87.7 372.57,87.08 372.16,86.66 371.12,86.66 370.99,86.79 370.99,89.08 371.33,89.41 372.89,89.41
+12V_PANEL on TOP (solid shape): 358.48,81.49 358.48,80.3 358.72,80.3 358.72,81.49 358.76,81.53 358.98,81.53 359.04,81.46 359.04,78.16 358.99,78.11 358.05,78.11 357.96,78.21 357.96,79.96 358.22,80.22 358.22,81.49 358.27,81.54 358.43,81.54
+12V_PANEL on BOTTOM (solid shape): 359.46,79.42 359.46,78.07 359.4,78.02 358.59,78.02 357.88,78.73 357.88,79.16 358.26,79.54 359.33,79.54
+12V_PANEL on BOTTOM (solid shape): 372.35,88.92 372.35,87.64 372.13,87.42 372.13,87.41 371.02,86.29 370.46,86.29 369.75,87 369.75,87.27 369.75,87.28 369.75,89.02 370.01,89.29 371.99,89.29
+12V_PANEL on IN1 (solid shape): outline of 433 points within 357.68,77.79 372.36,88.08
+A3VPCU on BOTTOM (solid shape): 191.16,57.24 191.43,57.13 191.71,57.24 192.43,57.24 192.65,57.01 192.96,57.01 193.09,56.89 193.09,56.56 192.91,56.38 191.84,56.38 191.56,56.66 191.05,56.66 190.98,56.73 190.98,57.19 191.03,57.24
+VCC3P3_S0 on TOP (solid shape): 342.03,49.24 342.67,49.24 342.79,49.11 342.79,47.84 342.54,47.59 339.11,47.59 338.98,47.72 338.98,49.75 339.24,50 341.27,50
+VCC3P3_SX on BOTTOM (solid shape): 358.78,64.25 358.78,64.24 358.92,63.98 359.2,63.88 359.27,63.86 359.3,63.78 359.3,61.94 359.18,61.81 357.96,61.81 357.84,61.93 357.84,64.34 357.9,64.4 358.63,64.4
+VCC3P3_SX on BOTTOM (solid shape): 344.51,63.83 344.53,63.83 344.65,63.72 345.84,63.72 346.04,63.52 346.04,63.51 346.14,63.33 346.31,63.22 346.34,63.2 346.35,63.17 346.35,62.32 346.22,62.2 344.15,62.2 344.07,62.24 344.06,62.33 343.69,62.84 343.3,62.35 343.28,62.26 343.2,62.22 342.94,62.22 342.91,62.23 342.89,62.25 342.63,62.45 342.31,62.39 342.29,62.38 342.25,62.38 342.11,62.53 342.11,63.49 342.51,63.9 344.45,63.9
+VCC3P3_SX on IN1 (solid shape): outline of 664 points within 343.17,59.62 359.3,65.24
+VCC_CORE on TOP (solid shape): outline of 91 points within 239.12,112.01 243.39,113.79
+VCC_CORE on TOP (solid shape): outline of 234 points within 230.19,112.01 238.66,113.79
+VCC_CORE on TOP (solid shape): outline of 1372 points within 232.94,124.13 258.42,147.57
+VCC_CORE on BOTTOM (solid shape): outline of 1131 points within 231.67,112.36 251.61,143.86
+VCC_CORE on IN2 (solid shape): outline of 2579 points within 231.85,112.16 251.66,144.9
+VCC_CORE on SVCC (solid shape): 253.13,145.17 253.13,141.02 252.15,140.04 251.99,139.94 251.89,139.78 245.02,132.91 244.91,132.75 244.88,132.55 244.88,112.61 244.88,112.59 244.26,111.98 235.11,111.98 234.78,112.24 234.44,111.98 234.19,111.98 233.86,112.22 233.53,111.98 230.84,111.98 230.59,112.2 230.27,112.22 230.14,112.34 230.14,113.91 232.94,116.7 232.94,125.87 233.45,126.38 233.45,130.59 233.63,130.78 233.7,131.03 233.7,143.36 233.71,143.45 233.7,143.54 233.7,145.04 234.42,145.76 252.54,145.76
+VCC_CORE on IN3 (solid shape): outline of 2647 points within 230.14,111.98 253.13,145.76
+VCC_CORE on IN4 (solid shape): outline of 2334 points within 231.54,112.23 251.73,144.24
+VCC_GT on TOP (solid shape): outline of 2217 points within 245.55,111.88 272.69,145.58
+VCC_GT on BOTTOM (solid shape): outline of 1204 points within 245.89,112.41 272.44,143.6
+VCC_GT on SVCC (solid shape): outline of 82 points within 245.89,113.12 268.5,145.76
+VCC_GT on IN3 (solid shape): outline of 2716 points within 245.89,113.12 268.5,145.76
+VCC_GT on IN4 (solid shape): outline of 2160 points within 245.89,113.12 272.05,143.98
+VCC_SA on TOP (solid shape): outline of 273 points within 219.88,124.67 232.91,143.4
+VCC_SA on BOTTOM (solid shape): outline of 664 points within 224.43,125.44 232.86,143.35
+VCC_SA on SVCC (solid shape): 230.74,145.76 231.13,145.39 231.53,145.76 232.22,145.76 232.68,145.3 232.68,143.14 232.57,142.87 232.68,142.59 232.68,138.83 232.59,138.6 232.68,138.37 232.68,131.53 232.64,131.36 232.68,131.19 232.68,131.03 232.69,130.97 232.7,130.9 232.67,130.57 232.94,130.37 232.94,127.79 232.64,127.45 232.94,127.11 232.94,126.56 232.58,126.2 224.53,126.2 224.03,126.71 224.03,126.97 223.9,127.2 223.03,128.07 223.03,138.3 223.1,138.5 223.03,138.7 223.03,139.13 223.07,139.28 223.03,139.44 223.03,142.5 226.29,145.76
+VCC_SA on IN3 (solid shape): outline of 1174 points within 223.03,124.68 232.94,141.39
+VCC_SA on IN4 (solid shape): outline of 1163 points within 220.91,126.51 232.47,141.06
+VCCAMPHY_1P0 on TOP (solid shape): 300.31,65.22 300.31,65 300.1,64.79 300.1,64.75 299.88,64.52 299.88,64.16 300,64.04 300,63.85 299.72,63.57 299.72,62.69 299.56,62.53 299.16,62.53 299.05,62.65 299.05,64.36 298.87,64.54 298.28,64.54 298.11,64.7 298.11,65 298.16,65.05 298.18,65.05 298.27,65.08 298.35,65.13 298.42,65.16 298.49,65.13 298.78,65.06 298.98,65.26 298.99,65.28 299.1,65.39 300.14,65.39
+VCCAMPHY_1P0 on BOTTOM (solid shape): 298.44,66.29 298.53,66.24 298.53,66.14 298.82,65.63 299.24,66.04 299.26,66.12 299.34,66.16 299.41,66.16 299.71,65.85 299.71,65.59 299.7,65.54 299.7,65.5 299.7,65.21 299.72,65.19 299.72,65.17 299.75,65.17 300.08,64.83 300.09,64.82 300.1,64.8 300.1,63.95 299.88,63.73 299.55,63.73 299.44,63.85 298.44,63.85 298.17,64.13 296.87,64.13 296.77,64.23 296.77,64.41 296.79,64.44 296.81,64.45 297.14,64.81 296.81,65.18 296.78,65.19 296.77,65.23 296.77,65.52 296.79,65.56 296.85,65.6 296.92,65.63 296.98,65.6 297.48,65.62 297.51,66.12 297.49,66.23 297.59,66.29
+VCCAMPHYPLL_1P0 on TOP (solid shape): 288.08,77.08 288.21,77.08 290.8,74.49 290.86,74.45 290.88,74.39 291,74.12 291.27,74.01 291.3,74.01 291.55,73.76 291.58,73.76 291.7,73.73 291.82,73.76 291.88,73.77 291.94,73.73 292.11,73.61 292.31,73.64 292.34,73.64 292.37,73.63 292.48,73.52 292.48,73.24 292.32,73.09 291.95,73.09 291.93,73.1 291.91,73.12 291.78,73.25 291.6,73.24 291.59,73.24 290,73.24 289.86,73.38 289.85,73.39 289.77,73.53 289.62,73.62 289.61,73.62 289.56,73.67 289.55,73.69 289.56,73.71 289.34,74.19 288.82,74.14 288.8,74.12 288.76,74.12 288.75,74.14 288.44,74.27 288.13,74.15 288.11,74.14 288.07,74.14 288.01,74.2 288.01,74.76 287.94,74.83 287.28,74.83 287.14,74.97 287.14,75.78 286.88,76.05 286.88,76.08 286.85,76.08 286.76,76.17 286.53,76.17 286.28,76.42 286.28,77.26 286.44,77.42 287.66,77.42 287.68,77.45 287.71,77.45
+VCCAPLLEBB on BOTTOM (solid shape): 299.87,68.11 299.87,68.09 300.74,67.22 300.74,66.71 300.82,66.63 300.85,66.55 300.81,66.48 300.69,66.35 300.63,66.18 300.63,66.16 300.45,65.98 300.02,65.98 299.67,66.33 299.65,66.35 299.65,66.38 299.66,66.43 299.67,66.49 299.67,66.87 299.21,67.33 299.17,67.36 299.13,67.39 299.11,67.41 299.11,67.43 299.11,67.47 299.12,67.48 299.19,67.71 299.12,67.94 299.11,67.97 299.12,68 299.26,68.14 299.84,68.14
+VCCATS on BOTTOM (solid shape): outline of 334 points within 301.52,52.52 304.26,58.49
+VCCCLK5 on BOTTOM (solid shape): 297.89,52.82 297.89,52.21 297.79,52.06 297.77,51.85 297.76,51.83 297.33,51.4 297.33,50.38 297.2,50.26 297.2,49.42 297.19,49.38 297.15,49.37 296.57,49.37 296.44,49.5 296.44,51.3 296.29,51.3 296.17,51.41 296.17,51.58 296.16,51.69 296.11,51.79 296.11,52.34 296.7,52.92 297.78,52.92
+VCCDSW3P3 on BOTTOM (solid shape): 301.67,59.3 301.67,58.33 301.66,58.3 301.63,58.28 301.58,58.26 301.54,58.23 301.48,58.15 301.46,58.05 301.46,58.02 301.17,57.73 301.16,57.73 301.02,57.66 300.92,57.55 300.9,57.53 300.87,57.52 300.45,57.52 300.35,57.62 300.35,57.89 300.43,58.06 300.41,58.25 300.41,58.28 300.42,58.31 300.55,58.44 300.65,58.44 300.65,58.53 300.65,58.54 300.65,58.67 300.66,58.68 300.67,58.77 300.66,58.85 300.65,58.86 300.65,59.25 300.93,59.53 301.44,59.53
+VCCDSW_1.0V on BOTTOM (solid shape): 308.11,68.52 308.15,68.51 308.16,68.47 308.16,68.06 308.28,67.71 308.58,67.5 308.65,67.43 308.63,67.33 308.65,66.83 309.16,66.82 309.23,66.85 309.3,66.82 309.57,66.7 309.84,66.82 309.9,66.85 309.97,66.84 310.4,66.85 310.52,67.27 310.54,67.36 310.62,67.4 310.94,67.4 311.04,67.3 311.03,67.17 311.04,67.08 311.04,66.54 310.66,66.16 310.07,66.16 310.05,66.16 310.03,66.18 309.7,66.33 309.41,66.13 309.39,66.11 309.36,66.11 308.92,66.11 308.73,66.19 308.53,66.16 308.45,66.16 308.4,66.21 308.23,66.37 308,66.39 307.97,66.39 307.95,66.41 307.58,66.78 307.58,67.48 307.56,67.49 307.56,68.37 307.72,68.52
+VCCIO on TOP (solid shape): 218.03,143.13 218.03,141.95 218.71,141.27 218.71,139.03 218.46,138.78 215.41,138.78 215.16,139.03 215.16,140.55 214.52,141.19 214.52,143.25 214.69,143.41 217.75,143.41
+VCCIO on TOP (solid shape): 230.84,123.59 231.14,123.59 231.28,123.45 231.28,122.35 231.16,122.23 230.83,122.23 230.57,122.48 230.01,122.48 229.56,122.93 229.56,123.69 229.61,123.74 229.71,123.8 229.78,123.89 229.8,123.9 229.82,123.9 230.53,123.9
+VCCIO on TOP (solid shape): 229.61,119.56 229.63,119.55 229.65,119.54 229.83,119.46 230.05,119.52 230.29,119.52 230.69,119.12 231.58,119.12 231.83,118.86 231.83,117.98 231.85,117.97 231.85,114.42 231.71,114.29 230.8,114.29 230.56,114.06 229.85,114.06 229.71,114.21 229.31,114.21 229.2,114.1 229.11,114.1 229.04,114.17 229.04,114.55 229.29,114.8 229.37,114.88 229.41,114.97 229.41,115.16 229.23,115.35 229.19,115.38 229.19,115.53 229.16,115.56 229.16,115.57 229.09,115.67 228.99,115.74 228.97,115.76 228.96,115.78 228.96,115.84 228.97,115.86 228.99,115.88 229.09,115.95 229.16,116.05 229.16,116.06 229.19,116.1 229.19,116.31 229.24,116.36 229.29,116.37 229.39,116.46 229.59,116.46 229.65,116.39 229.68,116.37 229.72,116.34 229.79,116.27 230.66,116.27 230.84,116.45 230.84,116.77 230.61,117 229.36,117 229,117.37 229,117.43 229,117.45 229.14,117.59 229.19,117.75 229.19,117.77 229.41,117.98 229.41,118.12 229.41,118.17 229.41,118.25 229.36,118.33 229.31,118.38 229.22,118.47 229.22,118.72 229.03,118.91 229.03,118.98 229.24,119.19 229.24,119.37 229.43,119.56
+VCCIO on BOTTOM (solid shape): 231.16,123.54 231.16,122.39 230.53,121.76 230.53,119.47 231.03,118.96 231.66,118.96 231.91,118.71 231.91,115.17 231.77,115.03 231.01,115.03 230.55,114.57 229.61,114.57 229.23,114.95 229.23,115.21 229.27,115.24 229.27,115.6 229.23,115.63 229.23,115.81 229.22,115.82 229.22,116.13 229.23,116.2 229.22,116.27 229.22,116.3 229.26,116.35 229.44,116.52 229.44,117.4 229.35,117.49 229.34,117.51 229.38,117.88 229.23,118.18 229.14,118.26 229.14,118.32 229.15,118.33 229.23,118.58 229.14,118.82 229.14,119.11 229.19,119.18 229.22,119.26 229.22,119.27 229.42,119.47 229.42,119.68 229.43,119.72 229.44,119.75 229.82,119.94 229.8,120.37 229.8,121.48 229.87,121.71 229.8,121.95 229.8,122.27 229.87,122.5 229.8,122.74 229.8,123.06 230.4,123.66 231.03,123.66
+VCCIO on IN2 (solid shape): outline of 159 points within 270.78,123.66 273.83,126.64
+VCCIO on SVCC (solid shape): 222.02,141.49 222.02,137.78 221.95,137.58 222.02,137.38 222.02,127.86 222.05,127.67 222.15,127.51 222.15,127.03 222.64,127.02 223.18,126.48 223.41,126.35 223.67,126.35 224.25,125.77 224.33,125.71 224.43,125.7 231.95,125.7 232.43,125.21 232.43,116.91 231.23,115.71 230.78,115.68 230.75,115.23 229.71,114.19 229.65,114.11 229.64,114.01 229.64,111.78 229.22,111.69 229.22,111.26 228.96,111.01 228.59,110.94 228.52,110.56 227.39,109.44 226.99,109.44 226.88,109.46 226.77,109.44 224.14,109.44 223.81,109.68 223.48,109.44 213.46,109.44 210.33,112.57 210.33,141.74 210.8,142.21 221.3,142.21
+VCCIO on IN5 (solid shape): outline of 313 points within 271.5,125.08 274.42,131
+VCCPCIE3PLL_1P0 on TOP (solid shape): outline of 112 points within 288.03,73.78 292.98,78.32
+VCCPGPPBCH on TOP (solid shape): 313.01,72.92 313.01,71.99 312.77,71.75 312.77,71.74 312.28,71.74 312.26,71.76 312.26,71.78 312.21,71.95 312.08,72.06 312.08,72.33 312.26,72.51 312.34,72.6 312.34,72.77 312.64,73.06 312.87,73.06
+VCCPGPPD on TOP (solid shape): 315.95,78.27 315.95,77.11 313.96,75.12 313.31,75.12 312.83,74.64 312.76,74.59 312.71,74.52 312.62,74.43 312.62,74.28 312.52,74.19 312.52,73.76 312.42,73.66 312.26,73.66 312.13,73.79 312.13,74.03 311.88,74.28 311.37,74.28 311.3,74.35 311.3,74.57 312.49,75.77 312.52,75.79 312.55,75.82 313.33,76.6 314.37,76.6 314.71,76.94 314.71,76.94 314.8,77 314.87,77.09 314.9,77.13 314.92,77.28 314.9,77.38 314.9,78.21 315.08,78.39 315.83,78.39
+VCCPGPPEF on BOTTOM (solid shape): 308.57,77.14 308.57,73.89 308.43,73.75 308.29,73.75 307.77,73.52 308.09,73.05 308.41,72.73 308.41,72.54 308.37,72.46 308.27,72.45 307.8,72.33 307.86,71.85 307.89,71.74 307.79,71.67 306.23,71.67 306.15,71.71 306.07,71.73 306.05,71.73 305.79,71.98 305.79,73.15 305.83,73.18 305.86,73.2 305.9,73.18 306.53,72.55 306.73,72.55 306.75,72.55 306.77,72.53 307.42,72.76 306.77,72.99 306.76,72.98 306.74,72.97 306.7,72.97 306.3,73.38 306.28,73.4 306.29,73.43 306.29,73.45 306.32,73.46 306.32,73.58 306.55,73.82 306.58,73.83 306.61,73.83 306.64,73.82 306.64,73.8 307.12,73.8 307.12,74.02 307.14,74.08 307.15,74.13 307.15,74.3 307.37,74.52 307.37,74.6 307.37,74.62 307.38,74.64 307.45,74.73 307.49,74.83 307.49,74.85 307.61,74.97 307.61,77.03 307.77,77.18 308.53,77.18
+VCCPLL on TOP (solid shape): 230.8,124.49 231.18,124.49 231.23,124.44 231.23,123.93 231.13,123.83 230.8,123.83 230.6,124.03 230.6,124.03 230.55,124.08 229.88,124.08 229.85,124.09 229.83,124.12 229.78,124.28 229.66,124.39 229.64,124.4 229.63,124.43 229.63,124.61 229.71,124.69 230.6,124.69
+VCCPRIM_1.0V_AC17 on BOTTOM (solid shape): 303.63,61.26 303.63,60.59 303.61,60.56 303.57,60.54 303.37,60.34 303.24,60.03 303.38,59.72 303.39,59.7 303.4,59.68 303.4,59.58 303.36,59.53 303.34,59.49 303.32,59.47 303.28,59.47 303.23,59.48 303.17,59.48 302.56,59.48 302.43,59.61 302.41,59.65 302.36,59.72 302.19,59.84 301.97,59.85 301.89,59.88 301.85,59.95 301.85,60.04 302.37,60.56 302.37,61.19 302.66,61.48 303.4,61.48
+VCCPRIM_1.0V_AJ20 on TOP (solid shape): 305.92,64.33 305.91,64.19 305.95,64.06 305.95,64.05 305.95,63.52 305.95,63.46 305.95,63.4 305.95,61.88 305.91,61.83 305.44,61.83 305.15,62.13 305.15,62.85 305.11,62.89 305.08,62.95 305.05,62.99 305.05,63.37 305.13,63.59 305.02,63.79 305.02,64.08 305.45,64.51 305.74,64.51
+VCCPRIM_1.0V_AJ20 on BOTTOM (solid shape): 305.81,66.03 305.81,64.58 305.53,64.3 305.53,63.9 305.35,63.72 305.07,63.72 304.9,63.9 304.9,64.25 305.02,64.38 305.17,64.38 305.17,64.6 305.17,64.61 305.19,64.71 305.17,64.82 305.17,64.82 305.17,65.04 304.95,65.04 304.77,65.22 304.77,66.03 304.85,66.11 305.73,66.11
+VCCPRIM_1.0V_AJ20_AA23 on TOP (solid shape): outline of 135 points within 300.79,62.98 303.45,66.14
+VCCPRIM_1.0V_AJ20_AA23 on BOTTOM (solid shape): 302.86,66.59 302.9,66.58 302.92,66.54 302.92,65.9 302.38,65.37 302.38,65.17 302.34,65.08 302.25,65.07 301.76,64.69 302.31,64.39 302.33,64.4 302.37,64.39 302.38,64.35 302.38,64.33 302.39,64.32 302.39,63.02 302.33,62.96 301.39,62.96 301.06,63.28 301.06,65.6 301.26,65.8 301.31,65.8 301.31,65.84 301.33,65.87 301.33,66.13 301.33,66.19 301.31,66.25 301.31,66.4 301.49,66.59
+VCCPRIM_1.0V_AL22 on BOTTOM (solid shape): 308.07,65.35 308.07,65.04 307.41,64.38 307.01,64.38 307.01,64.26 307,64.25 307,64.14 306.99,64.09 306.99,64.05 306.99,63.77 306.98,63.75 306.89,63.6 306.86,63.45 306.67,63.26 306.26,63.26 306.25,63.28 306.15,63.28 306.08,63.35 306.08,63.71 306.38,64.02 306.38,65.38 306.42,65.42 308,65.42
+VCCRTCPRIM_3.3V on BOTTOM (solid shape): 310.9,62.42 310.9,62.4 311.03,62.17 311.27,62.08 311.3,62.07 311.45,61.92 311.45,61.9 312.11,61.9 312.11,61.91 312.14,61.94 312.16,61.94 312.24,61.94 312.26,61.96 312.29,61.96 312.61,62.06 312.71,62.39 312.72,62.41 312.73,62.43 312.76,62.46 313.65,62.46 313.81,62.3 313.81,61.81 313.74,61.71 313.7,61.59 313.7,61.57 313.63,61.5 312.61,61.5 312.53,61.43 312.53,61.27 312.14,60.88 311.95,60.88 311.94,60.88 311.86,60.89 311.77,60.88 311.76,60.88 311.71,60.88 311.63,60.92 311.61,61.01 311.57,61.36 311.26,61.52 311.15,61.5 311.06,61.45 310.99,61.43 310.93,61.46 310.8,61.55 310.65,61.57 310.54,61.55 310.45,61.51 310.38,61.49 310.31,61.52 310.27,61.55 310.23,61.58 310.21,61.6 310.2,61.63 310.2,62.16 310.21,62.17 310.24,62.26 310.24,62.36 310.27,62.43 310.34,62.46 310.85,62.46
+VCCSPI on TOP (solid shape): 317.27,78.2 317.27,76.7 315.31,74.74 315.31,74.06 313.93,72.69 313.9,72.7 313.62,72.67 313.46,72.42 313.46,72.38 313.2,72.38 313.13,72.45 313.13,73.54 313.29,73.7 313.46,73.7 314.03,74.27 314.03,74.95 316.3,77.22 316.3,78.16 316.52,78.38 317.09,78.38
+VIN on TOP (solid shape): 229.08,155.34 229.08,154.78 230.25,153.61 235.43,153.61 235.63,153.4 235.63,153.03 235.38,152.77 235.38,150.79 235.13,150.55 226.04,150.55 225.45,151.15 225.45,153.33 227.54,155.43 228.99,155.43
+VIN on TOP (solid shape): 351.65,89.36 351.71,89.32 351.78,89.29 351.88,89.2 351.88,88.65 351.76,88.54 350.83,88.54 350.36,88.06 349.1,88.06 348.91,88.25 348.91,88.91 349.03,89.03 350.6,89.03 350.92,89.36
+VIN on TOP (solid shape): 248.47,158.32 248.47,157.5 248.28,157.31 247.46,157.31 247.07,156.93 247.07,155.48 246.58,154.98 246.58,152.9 246.35,152.9 246.35,157.01 246.06,157.3 246.06,158.22 246.07,158.22 246.07,158.48 246.08,158.5 248.29,158.5
+VIN on TOP (solid shape): 241.07,158.33 241.07,157.22 240.82,156.98 239.68,156.98 239.57,156.86 239.57,155.34 239.11,154.88 239.11,153.13 238.88,153.13 238.88,156.94 238.73,157.09 238.73,157.35 238.29,157.79 238.29,158.1 238.55,158.36 238.97,158.36 239.22,158.61 240.79,158.61
+VIN on TOP (solid shape): 261.07,156.13 263.01,156.13 263.06,156.07 263.06,154.68 262.94,154.55 261.59,154.55 261.51,154.47 261.51,152.82 261.03,152.34 261.03,150.69 260.8,150.69 260.8,154.6 260.66,154.74 260.66,154.85 260.04,155.47 260.04,156.24 260.19,156.39 260.81,156.39
+VIN on TOP (solid shape): 110.78,67.51 110.78,67.48 110.78,67.47 110.71,67.25 110.71,67.03 110.71,67.01 110.71,66.99 110.13,66.41 110.13,65.75 110,65.62 109.09,65.62 108.72,65.99 108.72,67.57 108.8,67.66 110.64,67.66
+VIN on TOP (solid shape): 269.2,155.83 270.2,155.83 270.2,155.01 269.97,154.78 268.9,154.78 268.55,154.43 268.55,152.52 268.45,152.42 268.45,151.92 268.43,151.92 268.43,150.67 268.42,150.66 268.19,150.66 268.17,150.69 268.17,154.42 268.05,154.54 268.05,154.65 267.86,154.83 267.86,155.79 268.28,156.21 268.82,156.21
+VIN on TOP (solid shape): 256.1,158.51 256.1,157.17 255.98,157.04 254.43,157.04 254.26,156.87 254.26,155.33 253.82,154.88 253.82,153.2 253.8,153.17 253.77,153.15 253.64,153.15 253.6,153.17 253.59,153.2 253.59,158.61 253.77,158.79 255.82,158.79
+VIN on TOP (solid shape): 130.7,74.26 130.7,72.61 130.75,72.56 130.75,71.95 131.11,71.59 131.85,71.59 132.05,71.39 132.05,71.11 131.98,71.01 131.94,70.89 131.94,70.87 131.24,70.17 128.32,70.17 127.83,70.65 127.83,71.34 128.39,71.9 128.39,72.05 128.42,72.08 128.5,72.08 128.56,72.13 128.64,72.05 129.16,72.05 129.46,72.35 129.46,73.99 129.36,74.09 129.36,74.31 129.43,74.39 130.58,74.39
+VIN on TOP (solid shape): 110.07,63.39 110.07,63.1 110.41,62.76 110.41,62.05 110.32,61.97 109.47,61.97 109.43,61.98 109.42,62.02 109.42,62.35 109.42,62.35 109.32,62.73 108.94,62.83 108.92,62.83 108.89,62.85 108.83,62.91 108.83,63.24 109.11,63.52 109.94,63.52
+VIN on TOP (solid shape): 213.95,171.64 213.97,171.64 214.23,171.42 214.55,171.34 215.44,171.34 215.44,171.34 215.69,171.34 216.05,170.98 216.05,170.37 216.12,170.3 216.35,170.3 216.56,170.1 216.56,169.18 216.33,168.95 213.96,168.95 213.75,168.74 211.77,168.74 211.47,168.44 210.18,168.44 209.9,168.72 209.9,169.16 209.89,169.17 209.89,170.17 209.63,170.43 209.34,170.43 208.43,171.34 206.75,171.34 206.62,171.47 206.62,172.13 206.75,172.25 213.34,172.25
+VIN on TOP (solid shape): 78.03,55.98 81.69,55.98 82.18,55.49 82.36,55.49 82.56,55.29 82.56,53.77 82.33,53.55 78.22,53.55 77.89,53.87 77.13,53.87 77.13,53.87 75.79,53.87 75.74,53.91 75.74,56.34 75.55,56.54 75.43,56.65 74.84,56.65 74.46,56.28 74.46,55.7 74.45,55.68 74.02,55.68 73.97,55.73 73.97,56.16 74.15,56.34 74.25,56.6 74.15,56.87 74.13,56.94 74.16,57.01 74.44,57.3 74.44,57.35 74.46,57.39 74.49,57.4 76.61,57.4
+VIN on TOP (solid shape): 184.78,80.96 185.23,80.51 186.36,80.51 186.54,80.69 186.83,80.69 186.88,80.64 188.58,80.64 189.38,79.84 189.38,78.6 188.92,78.15 186.56,78.15 186.08,77.66 186.08,75.94 185.72,75.58 182.47,75.58 181.53,76.52 181.53,78.2 181.53,78.2 182.81,78.2 182.81,78.14 182.82,78.09 182.83,78.03 182.86,77.98 182.89,77.94 182.93,77.89 182.97,77.86 183.02,77.83 183.07,77.8 183.12,77.79 183.18,77.78 183.23,77.78 183.29,77.79 183.34,77.8 183.39,77.83 183.44,77.86 183.48,77.89 183.52,77.94 183.55,77.98 183.57,78.03 183.59,78.09 183.6,78.14 183.6,78.2 183.59,78.26 183.57,78.31 183.55,78.36 183.52,78.41 183.48,78.45 183.44,78.49 183.39,78.52 183.34,78.54 183.29,78.56 183.23,78.57 183.18,78.57 183.12,78.56 183.07,78.54 183.02,78.52 182.97,78.49 182.93,78.45 182.89,78.41 182.86,78.36 182.83,78.31 182.82,78.26 182.81,78.2 181.53,78.2 181.15,78.58 179.34,78.58 179.24,78.68 179.24,79.57 179.34,79.67 180.08,79.67 181.05,80.64 181.93,80.64 182.54,81.25 184.78,81.25
+VIN on TOP (solid shape): outline of 137 points within 68.42,57.57 96.92,71.63
+VIN on BOTTOM (solid shape): 190.37,80.92 190.37,80.36 189.92,79.91 189.3,79.91 187.6,78.21 185.1,78.21 184.37,78.93 184.37,79.72 185.34,80.69 186.33,80.69 186.56,80.92 186.56,80.94 186.61,80.99 190.29,80.99
+VIN on BOTTOM (solid shape): outline of 307 points within 223.88,144.01 270.35,158.82
+VIN on IN1 (solid shape): 110.79,67.58 110.79,63.06 110.51,62.78 109.13,62.78 109.04,62.79 108.94,62.78 108.66,62.78 108.38,63.06 108.38,66.12 108.38,66.12 108.38,67.61 108.55,67.78 110.59,67.78
+VIN on IN1 (solid shape): 263.62,156.07 263.62,147.97 262.58,146.93 262.58,146.42 262.73,146.27 262.8,146.27 263.16,146.08 263.53,146.27 266.47,146.27 267.58,147.39 267.58,155.49 267.79,155.7 268.37,155.7 268.65,155.98 270.68,155.98 270.89,155.77 270.89,148.4 270.02,147.54 270.02,145.76 268.29,144.03 260.12,144.03 259.25,144.9 259.25,147.54 260.4,148.68 260.4,155.97 260.78,156.35 263.34,156.35
+VIN on IN1 (solid shape): outline of 99 points within 236.37,145.46 256.05,158.67
+VIN on IN2 (solid shape): 92.43,65.42 92.43,63.08 91.74,62.4 89.02,62.4 88.21,63.21 88.21,65.47 88.72,65.98 91.87,65.98
+VIN on IN2 (solid shape): outline of 1439 points within 104.74,92.88 216.38,181.99
+VIN on SGND3 (solid shape): 191.66,175.2 190.52,174.06 190.52,172.36 191.9,170.98 192.01,170.75 192.24,170.63 192.86,170.02 204.06,170.02 206.6,172.56 213.05,172.56 214.7,170.91 215.08,170.91 215.09,170.92 215.32,170.92 216.3,169.94 216.3,169.46 213.94,167.1 189.1,167.1 186.2,169.99 186.2,177.94 184.09,180.05 127.17,180.05 119.81,172.69 116.78,172.69 113.56,169.46 113.56,99.61 108.03,94.08 102.85,94.08 102.77,94.16 102.68,94.24 101.71,95.12 101.75,95.17 103,96.6 104.18,98.07 108.14,103.99 110.9,110.55 110.9,110.57 110.99,110.85 110.97,110.86 110.97,110.89 111,111.09 111.01,111.3 111.01,172.49 112,172.49 113.77,173.23 114.51,175 114.51,181 114.95,182.05 116,182.49 191.66,182.49
+VIN on SVCC (solid shape): outline of 1018 points within 78.76,53.31 229.2,182.49
+VIN on IN3 (solid shape): outline of 101 points within 236.37,146.17 256.05,158.67
+VIN on IN3 (solid shape): outline of 166 points within 280.36,85.08 294.05,96.23
+VIN on IN3 (solid shape): outline of 1616 points within 104.78,92.84 216.43,181.99
+VIN on IN4 (solid shape): outline of 104 points within 236.37,146.45 256.05,158.67
+VIN on IN4 (solid shape): outline of 2119 points within 104.67,92.79 228.15,181.99
+VIN on SGND5 (solid shape): 191.66,175.2 190.52,174.06 190.52,172.36 191.9,170.98 192.01,170.75 192.24,170.63 192.86,170.02 204.06,170.02 206.6,172.56 213.05,172.56 214.7,170.91 215.08,170.91 215.09,170.92 215.32,170.92 216.3,169.94 216.3,169.46 213.94,167.1 189.1,167.1 186.2,169.99 186.2,177.94 184.09,180.05 127.17,180.05 119.81,172.69 116.78,172.69 113.56,169.46 113.56,99.61 108.03,94.08 102.85,94.08 102.77,94.16 102.68,94.24 101.71,95.12 101.75,95.17 103,96.6 104.18,98.07 108.14,103.99 110.9,110.55 110.9,110.57 110.99,110.85 110.97,110.86 110.97,110.89 111,111.09 111.01,111.3 111.01,172.49 112,172.49 113.77,173.23 114.51,175 114.51,181 114.95,182.05 116,182.49 191.66,182.49
+VIN on IN5 (solid shape): 294.36,87.44 294.36,86.68 294.05,86.38 292.32,86.38 291.97,86.73 291.97,87.44 292.17,87.65 294.15,87.65
+VIN on IN5 (solid shape): 350.29,88.61 350.29,87.14 349.98,86.83 349.12,86.83 348.81,87.14 348.81,88.41 349.22,88.82 350.08,88.82
+VIN on IN5 (solid shape): outline of 106 points within 236.37,145.46 256.05,158.67
+VIN on IN5 (solid shape): outline of 1046 points within 104.64,93.97 191.84,181.99
+VIN_FBVDDQ on TOP (solid shape): 126.51,89.27 126.51,85.84 125.86,85.2 125.16,85.2 124.92,84.97 124.92,84.64 125.16,84.41 125.78,84.41 125.78,79.72 125.22,79.16 121.84,79.16 121.53,79.47 121.53,89.58 122.02,90.06 125.72,90.06
+VIN_FBVDDQ on TOP (solid shape): 107,85.28 107,82.31 107.97,81.35 108.3,81.35 108.4,81.33 108.51,81.35 108.63,81.35 108.78,81.2 108.78,78.25 108.48,77.94 106.01,77.94 105.04,78.92 105.04,80.04 104.54,80.53 102.08,80.53 101.72,80.89 101.72,85.3 102.09,85.67 106.62,85.67
+VIN_FBVDDQ on BOTTOM (solid shape): 108.22,81.02 108.22,78.58 107.74,78.1 106.17,78.1 105.94,78.32 105.94,81.07 106.14,81.27 107.97,81.27
+VIN_FBVDDQ on BOTTOM (solid shape): 124.52,84.28 124.52,82.22 124.1,81.8 122.65,81.8 122.45,82.01 122.45,84.4 122.75,84.7 124.1,84.7
+VIN_FBVDDQ on IN1 (solid shape): outline of 211 points within 102.59,77.59 126.05,90.52
+VIN_GPU_TOTAL on TOP (solid shape): 127.69,77.5 127.69,76.06 127.59,76.06 127.59,75.4 127.69,75.4 127.69,73.8 127.59,73.8 127.59,73.14 127.69,73.14 127.69,72.55 127.4,72.25 123.54,72.25 123.36,72.43 123.36,72.72 123.26,72.99 123.01,73.12 122.95,73.12 122.32,73.12 122.03,73.41 122.03,78.31 122.26,78.54 126.65,78.54
+VIN_VCCSA on TOP (solid shape): 235.68,149.7 235.68,148.17 235.35,147.84 233.42,147.84 232.94,147.36 232.94,145.69 232.68,145.43 229.23,145.43 228.75,145.91 227.12,145.91 227.07,145.97 227.07,146.14 227.1,146.17 231.08,146.17 231.3,146.38 231.57,146.5 231.68,146.77 231.87,146.96 231.87,149.78 231.97,149.88 235.5,149.88
+VIN_VCCSA on BOTTOM (solid shape): 232.66,147.64 232.66,145.69 232.18,145.2 229.09,145.2 228.91,145.38 228.91,145.95 229.13,146.17 231.08,146.17 231.3,146.38 231.57,146.5 231.68,146.77 231.86,146.95 231.86,147.67 232.1,147.91 232.4,147.91
+VIN_VGACORE on TOP (solid shape): 134.16,94.68 134.16,88.1 133.84,87.79 130.54,87.79 130.37,87.95 130.37,91.41 130.5,91.53 130.83,91.53 131.73,92.43 131.73,92.99 131.89,93.16 132.79,93.16 132.94,93.31 132.94,94.71 133.01,94.78 134.06,94.78
+VIN_VGACORE on TOP (solid shape): 172.5,71.48 172.5,68.66 172.33,68.5 169.06,68.5 168.85,68.7 168.85,69.31 168.65,69.51 167.84,69.51 167.79,69.46 167.25,69.46 167.2,69.51 167.2,70.07 167.23,70.1 167.23,70.4 167.18,70.45 165.65,70.45 165.65,71.57 172.41,71.57
+VIN_VGACORE on TOP (solid shape): 131.39,82.59 131.39,80.2 132.51,79.09 132.51,72.03 132.43,71.95 131.31,71.95 131.17,72.09 131.17,74.83 131.08,74.92 129.43,74.92 129.31,75.05 129.31,75.4 129.48,75.4 129.48,76.06 129.31,76.06 129.31,76.34 128.85,76.8 128.85,80.74 129.18,81.07 130.02,81.07 130.16,81.21 130.16,82.58 130.22,82.64 131.34,82.64
+VIN_VGACORE on TOP (solid shape): 160.85,71.31 160.85,68.83 160.6,68.57 157.47,68.57 156.84,69.2 156.58,69.49 156.19,69.41 155.49,69.41 155.47,69.43 155.47,70.32 155.42,70.37 153.94,70.37 153.84,70.48 153.84,71.52 153.88,71.56 160.61,71.56
+VIN_VGACORE on BOTTOM (solid shape): 160.32,71.01 160.32,69.97 160.01,69.66 156.92,69.66 156.53,70.04 156.53,70.68 157.02,71.16 160.17,71.16
+VIN_VGACORE on BOTTOM (solid shape): 131.85,92.33 132.72,92.33 133.4,91.66 133.4,88.26 132.96,87.82 131.85,87.82 130.88,88.79 130.88,91.39 131.83,92.35
+VIN_VGACORE on BOTTOM (solid shape): 131.74,79.82 131.74,76.8 131.67,76.72 129,76.72 128.65,77.08 128.65,80.15 129,80.51 131.06,80.51
+VIN_VGACORE on BOTTOM (solid shape): 171.86,71.07 171.86,70.94 171.98,70.83 171.98,69.92 171.62,69.56 169.18,69.56 168.93,69.82 168.93,71.09 169.06,71.21 171.72,71.21
+VIN_VGACORE on IN2 (solid shape): outline of 2996 points within 128.49,67.4 173.43,94.66
+VIN_VGACORE on IN5 (solid shape): outline of 2825 points within 128.67,69.31 174.14,92.93
DVDDL on TOP (solid shape): 342.48,72.02 342.48,70.71 342.6,70.58 343.87,70.58 344.42,70.04 344.42,68.88 345.15,68.14 345.15,67.38 345.03,67.26 343.45,67.26 343.38,67.33 342.54,67.33 342,67.87 342,72.18 342.31,72.18
GND on TOP (solid shape): 73.5,41.37 68.75,41.37 68.75,43.93 68.79,43.97 73.5,43.97
GND on TOP (solid shape): 28.9,51.15 28.9,46.35 28.81,46.27 27.08,46.27 27,46.35 27,51.07 27.1,51.18 28.87,51.18
GND on TOP (solid shape): 213.89,148.43 213.89,143.86 213.63,143.6 212.62,143.6 212.24,143.98 212.24,148.43 212.49,148.68 213.63,148.68
GND on TOP (solid shape): 274.34,141.82 274.34,140.43 274.09,140.17 273.45,140.17 273.07,140.55 273.07,141.95 273.2,142.08 274.09,142.08
GND on TOP (solid shape): 335.67,76.86 335.67,72.16 335.63,72.12 332.95,72.12 332.88,72.18 332.88,76.8 332.97,76.89 335.64,76.89
GND on TOP (solid shape): 364.51,52.17 364.51,50.56 364.48,50.52 362.76,50.52 362.73,50.55 362.73,52.24 362.78,52.28 364.4,52.28
GND on TOP (solid shape): 368.59,50.54 368.59,48.25 368.55,48.2 366.94,48.2 366.75,48.4 366.75,50.51 366.96,50.73 368.41,50.73
GND on TOP (solid shape): 32.15,33.37 32.15,29.56 32.08,29.48 27.83,29.48 27.83,29.62 27.74,29.71 27.74,33.47 27.84,33.57 31.95,33.57
GND on TOP (solid shape): 45.64,29.71 45.64,27.66 45.46,27.47 43.01,27.47 42.91,27.58 42.91,29.54 43.09,29.72 44.71,29.72 44.81,29.81 45.54,29.81
GND on TOP (solid shape): 210.1,113.15 208.9,113.15 208.9,164.56 210.1,164.56
GND on TOP (solid shape): 351.88,73.13 352.17,73.13 352.2,73.1 352.2,69.53 352.18,69.51 348.67,69.51 348.6,69.58 348.6,73.05 348.74,73.19 351.81,73.19
GND on TOP (solid shape): 363.62,34.62 363.62,31.99 363.35,31.73 363.1,31.73 361.68,33.15 361.68,34.25 361.68,34.59 361.79,34.7 363.53,34.7
GND on TOP (solid shape): 365.17,81.43 365.17,78.75 364.5,78.08 362.23,78.08 362.1,78.22 362.1,81.12 362.87,81.89 364.71,81.89
GND on TOP (solid shape): 114.57,122.01 114.57,109.95 114.32,109.69 113.36,109.69 112.67,110.39 112.67,111.17 112.7,111.29 112.67,111.32 112.67,122.19 112.87,122.39 114.19,122.39
GND on TOP (solid shape): 218.59,138.14 218.59,137.25 218.49,137.15 218.49,136.65 218.08,136.24 214.14,136.24 213.89,136.49 213.89,137.89 214.4,138.4 218.33,138.4
GND on TOP (solid shape): 245.51,143.22 245.51,138.78 244.62,137.89 244.62,134.56 244.37,134.31 242.39,134.31 242.08,134.61 242.08,143.09 242.34,143.35 245.38,143.35
GND on TOP (solid shape): 77.24,75.88 77.24,72.69 77.01,72.46 70.71,72.46 70.64,72.52 70.64,73.36 70.38,73.63 70.38,75.4 70.99,76.01 77.12,76.01
GND on TOP (solid shape): 118,171.8 118,167.48 117.72,167.2 117.72,159.22 117.34,158.84 112.95,158.84 112.69,159.1 112.69,168.65 116.23,172.18 117.62,172.18
GND on TOP (solid shape): 219.35,163.41 219.35,159.48 218.71,158.84 214.78,158.84 214.4,159.22 214.4,162.14 214.52,162.27 215.41,162.27 215.67,162.53 215.67,163.41 215.92,163.67 219.1,163.67
GND on TOP (solid shape): 224.92,154.13 224.92,150.02 224.66,149.75 220.7,149.75 219.96,150.49 219.96,152.16 220.21,152.42 221.23,152.42 221.69,152.87 221.69,153.74 222.27,154.32 224.73,154.32
GND on TOP (solid shape): 186.58,85.18 186.58,83.48 186.53,83.43 185.29,83.43 184.96,83.1 184.96,81.8 184.91,81.75 182.37,81.75 182.37,84.07 183.36,85.06 183.36,85.49 183.59,85.72 186.05,85.72
