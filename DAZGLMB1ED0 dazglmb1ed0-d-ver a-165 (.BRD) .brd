# Allegro board DAZGLMB1ED0 dazglmb1ed0-d-ver a-165 (.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
TBTA_ROSC: length 4.2
  TOP w0.081: 368.87,24.2 368.87,24.74 U13155.G2
  TOP w0.14: 368.87,24.2 368.87,23.27 369.45,22.69 369.45,22.39 368.7,21.63 R67128.1
TBTA_SBU1: length 27.4
  TOP w0.081: 372.49,29.18 372.49,29.15 372.45,29.11 371.58,28.24 370.87,28.24 U13155.K8
  TOP w0.14: 372.49,29.18 372.49,31.51 v1(372.33,31.67) ; v1(378.96,44.19) 378.96,44.2 379.14,44.38 CN18.A8
  IN2 w0.089: v1(372.33,31.67) 372.04,31.96 371.64,31.96 371.09,32.51 371.09,35.75 372.26,36.92 376.68,36.92 377.48,37.72 377.48,39.53 v1(377.21,39.79) 377.5,40.09 377.5,40.26 377.97,40.73 379.24,40.73 379.62,41.11 379.62,43.53 v1(378.96,44.19)
  BOTTOM w0.14: D13032.2 376.96,39.16 377.21,39.41 v1(377.21,39.79)
TBTA_SBU2: length 27.4
  TOP w0.081: U13155.L8 371.21,28.08 371.64,28.08 372.49,28.93 372.63,28.93 372.8,29.1
  TOP w0.14: v4(380.74,42.71) 380.83,42.63 CN18.B8 ; v1(372.33,32.33) 372.8,31.86 372.8,29.1
  IN2 w0.089: v4(380.74,42.71) 380.18,43.27 379.89,43.27 379.8,43.18 379.8,41.04 379.32,40.56 378.05,40.56 377.68,40.19 377.68,40.09 v1(377.97,39.79) 377.97,39.77 377.65,39.45 377.65,37.65 376.75,36.75 372.33,36.75 371.27,35.68 371.27,32.58 371.71,32.13 372.14,32.13 v1(372.33,32.33)
  BOTTOM w0.14: D13033.2 378.1,39.64 377.97,39.77 v1(377.97,39.79)
TBTA_SS: length 2
  TOP w0.14: U13155.H7 369.84,27.49 v1(370.07,27.73)
  BOTTOM w0.14: v1(370.07,27.73) 370.43,27.37 370.51,27.37 370.73,27.15 C96009.1
TBTA_TX0_N: length 3.3
  TOP w0.079: 356.22,50.08 356.21,50.08 356.15,50.03 arc(356.12,50.01) 356.09,50 355.58,50 arc(355.52,50.02) 355.47,50.05 arc(355.34,50.14) 355.18,50.17 355.05,50.17 arc(354.89,50.14) 354.75,50.04 U21.B19
  TOP w0.14: 356.22,50.08 357.1,50.08 arc(357.43,50.15) C94571.2
TBTA_TX0_P: length 3.3
  TOP w0.079: 356.22,49.77 356.21,49.77 356.15,49.82 arc(356.12,49.84) 356.09,49.85 355.57,49.85 arc(355.45,49.82) 355.34,49.75 arc(355.3,49.72) 355.25,49.71 355.01,49.71 arc(354.89,49.83) 355.01,49.94 U21.A19
  TOP w0.14: 356.22,49.77 357.24,49.77 arc(357.49,49.72) C94572.2
TBTA_TX1_N: length 3.3
  TOP w0.079: U21.B17 354.79,50.72 arc(354.88,50.66) 354.99,50.64 355.28,50.64 arc(355.4,50.66) 355.5,50.73 arc(355.61,50.8) 355.75,50.83 355.87,50.83 arc(356.05,50.81) 356.22,50.75
  TOP w0.14: v1(356.46,50.59) arc(356.35,50.68) 356.22,50.75
  BOTTOM w0.14: v1(356.46,50.59) arc(356.68,50.74) 356.95,50.79 357.31,50.79 arc(357.51,50.75) C94570.2
TBTA_TX1_P: length 3.3
  TOP w0.079: U21.A17 355.03,50.86 arc(354.91,50.98) 355.03,51.1 355.21,51.1 arc(355.31,51.08) 355.39,51.02 arc(355.43,51) 355.47,50.99 355.86,50.99 arc(356.04,51.01) 356.22,51.07
  TOP w0.14: v1(356.48,51.25) arc(356.36,51.15) 356.22,51.07
  BOTTOM w0.14: C13391.2 357.56,51.28 arc(357.37,51.15) 357.14,51.11 356.82,51.11 arc(356.64,51.15) v1(356.48,51.25)
TBTA_USB2_D_N: length 38.5
  TOP w0.081: U13155.K5 370.88,26.24 371.74,26.24 v1(371.88,26.1)
  TOP w0.14: v4(353.62,49.59) 354.05,49.59 354.15,49.5 354.15,49.39 354.02,49.26 U21.D20
  IN1 w0.089: v4(353.62,49.59) 353.4,49.59 353.3,49.49 353.3,49.36 354.75,47.9 355.14,47.9 355.8,47.24 357.52,47.24 362.53,42.23 362.53,41.15 363.76,39.92 363.85,39.92 365.35,38.42 365.35,37.48 365.98,36.85 366.36,36.85 366.81,36.4 368.66,36.4 370.38,34.68 370.38,31.14 369.83,30.59 369.83,29.49 370.71,28.62 370.71,26.28 371.5,25.49 371.82,25.49 372.14,25.82 372.14,25.91 371.95,26.1 v1(371.88,26.1)
TBTA_USB2_D_N_B: length 11.9
  TOP w0.14: v4(380.74,43.22) 380.84,43.13 CN18.B7
  IN4 w0.089: v4(380.74,43.22) 380.56,43.4 380.37,43.4 380.13,43.16 380.13,42.38 378.44,40.69 375.67,40.69 375.38,40.4 375.38,40.25 v1(375.89,39.74)
  BOTTOM w0.14: v1(375.89,39.74) 375.86,39.72 375.86,39.12 D13060.2 375.5,39.07 375.38,38.95 375.38,37.62 R67162.2
TBTA_USB2_D_N_T: length 14.5
  TOP w0.14: CN18.A7 379.31,43.87 379.19,43.75 378.45,43.75 378.24,43.54 378.08,43.54 377.97,43.65 377.97,43.98 v1(378.02,44.03)
  IN2 w0.089: v1(372.1,39.79) 372.18,39.79 372.88,40.49 374.28,40.49 375.77,41.99 375.77,43.51 376.54,44.28 377.41,44.28 377.66,44.03 378.02,44.03 v1(378.02,44.03)
  BOTTOM w0.14: R67160.2 372.83,37.63 372.83,38.87 372.63,39.07 D13036.2 372.38,39.28 372.1,39.56 v1(372.1,39.79)
TBTA_USB2_D_P: length 38.6
  TOP w0.081: 371.65,26.53 371.52,26.4 371.21,26.4 U13155.L5
  TOP w0.14: v1(372.54,26.15) 372.16,26.53 371.65,26.53 ; U21.E20 v4(352.97,49.59)
  IN1 w0.089: v1(372.54,26.15) 372.31,25.92 372.31,25.75 371.89,25.33 371.43,25.33 370.54,26.21 370.54,28.55 369.67,29.42 369.67,30.66 370.22,31.21 370.22,34.61 368.59,36.24 366.74,36.24 366.29,36.68 365.91,36.68 365.18,37.41 365.18,38.35 363.78,39.75 363.69,39.75 362.36,41.08 362.36,42.16 357.45,47.07 355.73,47.07 355.07,47.73 354.68,47.73 353.13,49.29 353.13,49.43 v4(352.97,49.59)
TBTA_USB2_D_P_B: length 12.2
  TOP w0.14: v4(380.74,43.73) 380.84,43.63 CN18.B6
  IN4 w0.089: v4(380.74,43.73) 380.58,43.57 380.3,43.57 379.96,43.23 379.96,42.45 378.37,40.86 375.6,40.86 375.15,40.41 v1(375.15,39.74)
  BOTTOM w0.127: 374.67,39.27 v1(375.15,39.74)
  BOTTOM w0.14: R67161.2 375.11,37.63 375.11,38.93 374.97,39.07 D13061.2 374.67,39.27
TBTA_USB2_D_P_T: length 14.5
  TOP w0.14: CN18.A6 379.24,43.38 379.14,43.48 378.56,43.48 378.35,43.27 377.97,43.27 377.67,43.58 v1(377.54,43.58)
  IN2 w0.089: v1(372.79,39.77) 372.71,39.85 372.71,40.08 372.95,40.33 374.35,40.33 375.94,41.92 375.94,43.44 376.61,44.12 377.34,44.12 377.54,43.91 v1(377.54,43.58)
  BOTTOM w0.14: v1(372.79,39.77) 373.28,39.77 373.53,39.52 D13037.2 373.26,39.07 373.1,38.9 373.1,37.62 R67159.2
TBTA_USB2_N_B: length 12.9
  TOP w0.081: U13155.L7 371.21,27.58 371.41,27.58 371.45,27.62 372.37,27.62 v1(372.51,27.48)
  IN1 w0.089: v1(375.62,35.6) 375.51,35.6 375.38,35.47 375.38,35.26 375.09,34.97 374.38,34.97 371.93,32.52 371.93,31.45 372.68,30.69 372.68,27.64 v1(372.51,27.48)
  BOTTOM w0.14: v1(375.62,35.6) 375.67,35.65 375.67,36.26 R67162.1
TBTA_USB2_N_T: length 16.4
  TOP w0.14: U13155.L6 371.18,26.93 371.49,26.93 371.77,27.22 v1(371.88,27.22)
  IN1 w0.089: v1(371.88,27.22) 371.88,27 371.79,26.91 371.59,26.91 371.47,27.03 371.47,28.95 370.66,29.77 370.66,30.33 371.15,30.83 371.15,35.67 371.51,36.03 372.71,36.03 372.77,35.97 372.77,35.89 372.49,35.61 v1(372.39,35.61)
  BOTTOM w0.14: v1(372.39,35.61) 372.49,35.51 372.49,35.17 372.42,35.1 371.73,35.1 371.59,35.23 371.59,35.26 371.59,35.26 371.59,36.17 371.83,36.41 R67160.1
TBTA_USB2_P_B: length 12.8
  TOP w0.081: U13155.K7 370.87,27.74 371.33,27.74 371.37,27.78 371.96,27.78 v1(372.26,28.08)
  IN1 w0.089: v1(372.26,28.08) 372.51,28.34 372.51,30.62 371.76,31.38 371.76,32.59 374.31,35.14 375.03,35.14 375.21,35.32 375.21,35.52 375.14,35.6 v1(374.93,35.6)
  BOTTOM w0.14: v1(374.93,35.6) 374.9,35.6 374.67,35.83 R67161.1
TBTA_USB2_P_T: length 16.5
  TOP w0.081: U13155.K6 370.87,26.74 371.61,26.74 371.63,26.76
  TOP w0.14: 371.63,26.76 372,26.76 372.05,26.81 v1(372.51,26.81)
  IN1 w0.089: v1(372.51,26.81) 372.44,26.74 371.66,26.74 371.52,26.74 371.3,26.96 371.3,28.88 370.49,29.7 370.49,30.4 370.99,30.9 370.99,35.74 371.44,36.19 372.78,36.19 372.94,36.04 372.94,35.64 v1(373.04,35.54)
  BOTTOM w0.14: R67159.1 373.53,36.19 373.04,35.7 v1(373.04,35.54)
TBTB_HPD: length 9.5
  TOP w0.079: U21.G2 352.11,58 352.11,58.42 352.19,58.5 352.19,58.95 351.91,59.22 349.45,59.22 348.38,60.29
  TOP w0.14: 348.38,60.29 347.87,60.8 347.87,62.17 347.42,62.63 v1(347.09,62.63) R67045.1
TBTB_I2C_INT: length 4.8
  TOP w0.079: 351.21,60.23 351.21,60.03 351.35,59.89 352.14,59.89 353.03,59 353.03,58 U21.E2
  TOP w0.14: 351.21,60.23 351.21,61.01 R67153.2
TBTB_LSRX: length 3.1
  TOP w0.079: U21.B5 354.7,56.38 354.93,56.15 355.87,56.15
  TOP w0.14: 355.87,56.15 355.9,56.15 355.98,56.07 356.41,56.07 v1(356.76,55.72)
  BOTTOM w0.14: R67044.1 356.7,55.79 v1(356.76,55.72)
TBTB_LSTX: length 3.6
  TOP w0.079: v1(356.64,57.24) 356.47,57.08 354.88,57.08 U21.B4
  BOTTOM w0.14: v1(356.64,57.24) 356.64,57.75 356.25,58.14 R67043.1
TEMP_MBAT#: length 156.3
  TOP w0.14: v1(189.91,64.61) 189.91,63.31 189.96,63.26 189.96,60.79 188.97,59.8 188.97,58.83 189.46,58.34 191.45,58.34 192.3,57.5 192.3,56.59 192.61,56.27 193.08,56.27 193.21,56.4 U49.73
  IN1 w0.089: v1(189.91,64.61) 189.91,64.59 189.63,64.31 185.26,64.31 184.64,64.93 182.89,64.93 182.4,65.41 182.4,65.51 181.96,65.96 179.8,65.96 178.71,64.86 174.01,64.86 170.91,61.76 168.3,61.76 167.79,61.26 162.88,61.26 159.89,58.26 v1(159.89,57.67)
  IN5 w0.089: v1(67.1,61.38) 66.82,61.1 66.82,60.49 68.14,59.16 68.14,58.11 67.86,57.82 67.86,57.12 68.51,56.47 68.51,54.1 69.47,53.15 72.7,53.15 73.46,52.39 76.86,52.39 77.73,51.52 82.36,51.52 84.92,54.07 90.69,54.07 92.86,56.23 106.88,56.23 108.03,57.38 111.11,57.38 112.94,59.22 117.73,59.22 118.82,58.13 125.53,58.13 125.64,58.23 133.53,58.23 134.18,58.88 142.58,58.88 143.08,58.38 149.31,58.38 149.98,57.71 159.86,57.71 v1(159.89,57.67)
  BOTTOM w0.14: PR8.2 67.57,62.28 67.1,61.81 v1(67.1,61.38) ; PR18.1 PR14.2 160.37,57.19 v1(159.89,57.67)
TEMP_MBAT#_CONN: length 3.9
  TOP w0.14: PJ1.5 162.35,55.03 v1(162.4,54.98)
  BOTTOM w0.14: PR14.1 160.37,55.74 161.13,54.98 v1(162.4,54.98)
TERM9:
  vias: v1(367.43,77.94) v1(368.19,77.94) v1(368.96,77.94) v1(369.62,78.38)
THER_ALERT#: length 16
  TOP w0.127: v2(144.31,115.26) 144.66,115.61 U13114.BJ3
  BOTTOM w0.14: v2(144.31,115.26) 144.2,115.15 143.96,115.15 143.02,114.22 142.29,114.22 142.04,113.97 141.16,113.97 140.49,113.3 139.4,113.3 138.08,111.98 R21592.2 135.25,112.26 135.12,112.39 134.46,112.39 133.7,111.62 132.71,111.62 v1(132.48,111.4) 132.05,111.4 131.59,111.85 R67327.1
THERMDN: length 6.9
  TOP w0.14: U13114.BJ1 142.39,115.61 140.66,113.88 140.66,111.95 140.23,111.52 139.39,111.52 TP13108.1
THERMDP: length 10.3
  TOP w0.112: 143.63,115.28 U13114.BJ2
  TOP w0.14: 143.63,115.28 142.49,115.28 140.94,113.73 140.94,111.8 139.95,110.81 139.95,110.15
  TOP w0.254: 139.95,110.15 139.95,108.47 TP13109.1
TMU_CLK_OUT: length 4.5
  TOP w0.079: 346.25,60.49 346.37,60.37 346.37,59.93 346.65,59.66 346.86,59.66 347.2,59.32 347.2,58.59 347.05,58.45 347.05,58 U21.V2
  TOP w0.14: R20866.1 345.78,60.6 346.15,60.6 346.25,60.49
TOBII_WAKE#_EC: length 182.6
  TOP w0.14: v1(31.59,85.39) 31.59,86.53 30.62,87.5 CN2079.6
  IN4 w0.089: v1(31.59,85.39) 38.98,77.99 42.31,77.99 46.53,73.78 49.17,73.78 56.03,66.92 v1(56.03,66.82)
  IN5 w0.089: v1(182.57,57.62) 182.1,57.15 177.98,57.15 176.91,56.08 174.68,56.08 173.16,54.56 170.24,54.56 169.05,53.37 155.58,53.37 154.92,54.03 129.15,54.03 128.54,54.63 125.64,54.63 125.16,54.15 118.99,54.15 118.09,55.05 112.38,55.05 111.23,53.9 101.12,53.9 100.49,53.26 93.7,53.26 91.92,51.48 90.79,51.48 89.37,50.06 84.09,50.06 83.28,49.25 73.93,49.25 72.76,50.41 70.75,50.41 66.99,54.17 66.52,54.17 65.77,54.92 65.77,59.12 64.54,60.36 62.36,60.36 60.98,61.74 60.98,65.85 59.52,67.32 57.03,67.32 56.54,66.82 v1(56.03,66.82)
  BOTTOM w0.14: R67166.2 182.57,56.37 v1(182.57,57.62)
TP_LED_ON: length 69.4
  TOP w0.14: U49.113 186,68.77 v1(185.9,68.88) ; CN2078.1 133,52.74 133.32,52.42 142.23,52.42 142.95,53.13 142.95,55.08 142.1,55.93 v1(142.1,57.78)
  IN5 w0.089: v1(185.9,68.88) 185.31,68.29 184.94,68.29 184.67,68.02 179.97,68.02 178.32,66.36 176.4,66.36 175.43,65.4 175.43,64.71 173.87,63.14 173.87,60.82 173.11,60.06 173.11,59.33 172.02,58.23 171.66,58.23 170.29,56.86 169.27,56.86 168.87,56.47 157.11,56.47 156.52,57.06 149.66,57.06 148.98,57.73 142.15,57.73 v1(142.1,57.78)
TP_ON_OFF: length 14.9
  TOP w0.14: v1(136.72,59.3) 136.55,59.47 CN2076.9 v1(136.55,62.83) 136.55,62.84 R67281.1 ; CN2078.3 135,53.89 135.43,54.32 135.63,54.32 135.86,54.55 135.86,55.01 134.26,56.61 134.26,59.26 v1(134.27,59.27)
  BOTTOM w0.14: v1(136.72,59.3) 136.72,59.07 136.42,58.77 134.77,58.77 134.51,59.02 134.51,59.03 v1(134.27,59.27)
TP_PWR_EN: length 3.5
  TOP w0.14: R21065.2 135.28,65.62 135.27,65.62 C94788.1 133.89,65.62 v1(133.52,65.98) 133.5,66.01 Q7838.2
TPCLK: length 68.7
  TOP w0.14: v1(191.26,62.61) 191.56,62.91 193.06,62.91 193.17,62.8 U49.89 ; v1(140.69,59.3) 140.69,58.39 140.28,57.98 140.28,56.25 141,55.53 CN2078.9
  IN2 w0.089: v1(191.26,62.61) 190.63,63.24 185.95,63.24 184.91,64.28 180.45,64.28 178.82,62.65 177.08,62.65 177.06,62.68 176.07,62.68 174.85,61.46 172.21,61.46 170,59.25 168.47,59.25 167.52,58.3 163.81,58.3 163.29,57.78 162.35,57.78 161.49,56.91 157.68,56.91 157.24,57.35 150.66,57.35 149.22,58.8 146.95,58.8 145.59,60.16 141.55,60.16 v1(140.69,59.3)
  BOTTOM w0.14: R21063.2 C94790.2 139.33,57.89 139.57,58.13 139.85,58.13 140.69,58.97 v1(140.69,59.3)
TPD_INT#: length 147
  TOP w0.14: v1(309.47,78.68) 309.49,78.71 309.49,78.99 309.5,79 309.5,79.38 309.49,79.39 309.49,79.44 309.38,79.56 v1(309.38,80.49) ; v1(179.06,71.8) 177.69,70.43 R20905.1
  IN3 w0.079: v1(309.47,78.68) 309.16,78.38 308.1,78.38 307.53,78.94 304.65,78.94 304.41,78.71 302.11,78.71 300.27,80.54 299.16,80.54 298.4,81.29 298.4,81.72 298.14,81.98 288.85,81.98 288.41,82.42 286.03,82.42 284.85,83.61 283.48,83.61 280.01,87.07 279.27,87.07 279.01,87.33 211.04,87.33 206.37,82.66 204.97,82.66 202.87,80.55 201.67,80.55 198.37,77.25 197.59,77.25 194.96,74.62 193.34,74.62 190.52,71.8 v1(179.06,71.8)
  BOTTOM w0.14: v1(309.38,80.49) 309.34,80.53 R67273.2 ; v1(309.47,78.68) 309.47,78.41 309.31,78.25 R67271.1
TPD_INT#_PCH: length 3.4
  TOP w0.14: U13113.AV43 309.9,72.86 310.03,72.74 310.03,72.43 310.1,72.35 310.1,72.2 v2(310.18,72.13)
  BOTTOM w0.14: R21283.2 310.1,72.05 v2(310.18,72.13) 310.1,72.2 310.1,72.35 309.9,72.56 309.9,73.19 R67272.1
TPD_INT#_R: length 223.8
  TOP w0.14: CN2076.7 135.55,56 136.47,55.08 v1(136.47,54.7) 136,54.23 CN2078.4
  IN3 w0.079: v1(298.24,74.87) 297.74,74.37 292.9,74.37 292.33,74.94 284.25,74.94 282.97,76.22 282.97,77 281.75,78.22 276.35,83.61 212.56,83.61 206.9,77.96 205.76,77.96 205.38,77.57 205.24,77.57 203.66,75.99 203.66,75.53 203.5,75.37 203.5,72.88 200.54,69.92 198.09,69.92 194.15,65.98 193.68,65.98 192.06,67.6 183.29,67.6 182.57,66.88 179.8,66.88 177.84,64.92 175.37,64.92 175.37,64.92 172.36,64.92 170.7,63.27 169.74,63.27 166.52,60.05 166.52,55.98 164.65,54.11 162.03,54.11 160.26,55.88 148.29,55.88 146.59,54.18 136.99,54.18 v1(136.47,54.7)
  BOTTOM w0.14: R67255.2 309.73,76.68 310.26,77.21 311.35,77.21 311.55,77.41 R67257.1 311.55,78.33 311.51,78.36 Q7843.1 311.96,79.16 311.96,79.54 312.08,79.67 312.08,80.38 311.6,80.86 310.94,80.86 310.1,80.03 309.09,80.03 308.53,80.59 308.53,81.96 308.09,82.4 301.04,82.4 300.38,81.73 300.38,81.52 299.64,80.79 297.5,80.79 297.07,80.36 297.07,76.93 298.24,75.76 v1(298.24,74.87)
TPD_RST: length 64.3
  IN2 w0.089: v1(135.02,59.27) 135.79,60.04 137.69,60.04 138.28,60.63 145.78,60.63 147.15,59.27 149.43,59.27 150.87,57.82 159.35,57.82 159.77,58.25 163.09,58.25 163.61,58.77 167.32,58.77 168.32,59.77 169.84,59.77 172,61.93 174.65,61.93 176.22,63.49 178.99,63.49 180.25,64.75 185.11,64.75 186.14,63.71 191.02,63.71 191.03,63.72 v1(191.56,63.72)
  BOTTOM w0.14: v1(135.02,59.27) 135.39,59.64 R67339.1 v1(134.56,60.04) ; v1(191.56,63.72) 191.79,63.95 R20902.1
TPDATA: length 70.7
  TOP w0.14: CN2078.8 140,55.44 139.72,55.72 139.72,58.18 140.02,58.49 v1(140.02,59.27) ; v1(192.22,63.72) 192.74,63.2 U49.90
  IN2 w0.089: v1(140.02,59.27) 140.56,58.74 143.24,58.74 144.19,59.69 145.32,59.69 146.69,58.33 149.02,58.33 150.47,56.88 157.05,56.88 157.49,56.44 162.62,56.44 164,57.83 167.71,57.83 168.66,58.77 170.19,58.77 172.41,60.99 175.04,60.99 175.71,61.66 178.61,61.66 179.45,62.5 179.72,62.5 180.49,63.27 181.22,63.27 181.76,63.81 184.68,63.81 185.72,62.77 190.2,62.77 190.75,62.22 191.58,62.22 191.79,62.44 191.79,62.54 192.17,62.92 192.17,63.67 v1(192.22,63.72)
  BOTTOM w0.14: v1(140.02,59.27) 140.02,59.12 139.72,58.82 139.31,58.82 v1(138.96,58.46) 138.33,57.84 C94789.2 138.33,56.85 R21064.2
TS_DETECT: length 54.1
  TOP w0.102: 315.74,63.62 315.41,63.29 315.41,63.08 315.28,62.96 U13113.BD22
  TOP w0.14: 315.74,63.62 318.84,63.62 R21303.1 319.45,64.41 319.76,64.71 324.28,64.71 324.91,65.35 324.91,66.26 324.71,66.46 324.71,66.95 324.99,67.23 328.44,67.23 328.98,66.69 v1(330.09,66.69) ; v1(354.05,79.82) 354.35,80.13 CN2042.31
  IN5 w0.089: v1(354.05,79.82) 353.05,78.83 351.18,78.83 348.26,75.92 346.88,75.92 346.64,76.16 346.22,76.16 345.7,75.64 344.13,75.64 343.63,75.14 343.63,74.11 340.68,71.16 339.55,71.16 338.65,72.05 338.65,72.46 338.37,72.74 336.7,72.74 335.55,71.59 334.03,71.59 330.65,68.22 330.65,67.58 330.09,67.02 v1(330.09,66.69)
TS_EN: length 210.2
  TOP w0.14: CN2042.30 v1(353.85,82.39)
  IN3 w0.079: v1(184.96,73.4) 185.44,72.91 187.19,72.91 187.8,73.52 189.73,73.52 194.2,77.99 198.06,77.99 201.36,81.3 202.56,81.3 204.67,83.4 206.06,83.4 211.42,88.76 279.77,88.76 281.63,86.9 281.63,86.51 283.79,84.35 285.16,84.35 285.64,83.87 288.01,83.87 289.14,82.74 298.72,82.74 299.28,82.18 301.09,82.18 302.92,80.35 308.55,80.35 309.16,80.97 309.62,80.97 310.92,79.67 313.82,79.67 315.09,80.94 333.19,80.94 334.06,81.81 335.99,81.81 338.6,84.42 351.82,84.42 v1(353.85,82.39)
  BOTTOM w0.14: R807.2 191.44,60.38 C887.1 191.2,60.62 191.2,61.89 191.76,62.45 191.76,62.62 192.37,63.24 195.39,63.24 195.68,63.53 195.68,63.76 196.19,64.26 196.19,66.63 194.63,68.2 194.63,68.81 194.13,69.3 193.3,69.3 193.08,69.52 193.08,70.03 192.02,71.09 190.55,71.09 189.89,71.75 186.84,71.75 185.19,73.4 v1(184.96,73.4)
TS_EN_R: length 4.3
  TOP w0.14: U49.81 192.78,59.6 v1(192.7,59.53)
  BOTTOM w0.14: R807.1 v1(192.7,59.53) R67313.2 193.29,59.05 193.55,58.79 v1(194.21,58.79)
TS_PWR: length 5.8
  TOP w0.254: v1(356.35,79.85) CN2042.35
  TOP w0.508: R22007.2 355.91,77.65 356.28,77.28 v1(357.07,77.28)
  IN1 w0.508: v1(357.07,77.28) 356.74,77.28 356.35,77.67 v1(356.35,79.85)
TS_VREF: length 7.4
  TOP w0.14: v2(150.6,118.07) U13114.BF12
  BOTTOM w0.14: v2(150.6,118.07) 150.6,115.22 151.06,114.77 151.06,114.54 151.3,114.29 151.3,111.57 TP13107.1
TST: length 3.1
  TOP w0.14: v1(25.34,48.73) U13124.22
  BOTTOM w0.14: R21695.1 26.31,48.44 R21685.1 25.67,48.4 v1(25.34,48.73)
TX0_HDMI+: length 5.4
  TOP w0.102: R22122.2 223.36,168.54 223.36,168.79 R21016.2 223.15,169.34 222.91,169.59 D13075.2 223.15,169.9 223.39,170.15 223.39,172.38 CN2044.7
TX0_HDMI-: length 5.4
  TOP w0.102: CN2044.9 223.67,172.44 223.67,170.15 223.91,169.9 D13076.2 224.18,169.66 223.93,169.42 R21016.1 223.64,168.71 223.64,168.49 R22123.2
TX1_HDMI+: length 11.9
  TOP w0.102: v1(220.46,171.02) 220.72,170.75 220.72,170.15 220.48,169.9 D13073.2 220.73,169.41 220.73,169.13 R21013.2 220.72,168.64 220.72,168.31 R22120.2
  IN1 w0.089: v1(220.46,171.02) 220.72,171.28 220.72,171.68 220.63,171.77 219.4,171.77 218.74,172.43 218.74,173.45 218.97,173.68 221.73,173.68 221.87,173.81 221.87,173.9 CN2044.4
TX1_HDMI-: length 11.9
  TOP w0.102: v1(221.32,171.02) 221,170.7 221,170.15 221.24,169.9 D13074.2 221.01,169.41 221.01,169.17 221.26,168.92 R21013.1 221,168.61 221,168.34 R22121.2
  IN1 w0.089: CN2044.6 222.13,173.9 222.13,173.7 221.84,173.41 219.08,173.41 219.01,173.34 219.01,172.54 219.51,172.04 220.74,172.04 220.99,171.79 220.99,171.34 v1(221.32,171.02)
TX2_HDMI+: length 6.9
  TOP w0.102: CN2044.1 220.37,172.41 220.37,172.09 220.2,171.92 219.51,171.92 218.41,170.82 218.41,170.3 218.02,169.9 D13071.2 217.95,169.64 218.05,169.54 218.28,169.54 218.38,169.44 218.38,169.18 218.08,168.88 R21012.2 218.32,168.63 218.32,168.33 R22118.2
TX2_HDMI-: length 6.8
  TOP w0.102: R22119.2 218.6,168.33 218.6,168.63 R21012.1 218.66,169.06 218.66,169.44 218.76,169.54 218.99,169.54 219.1,169.64 D13072.2 219.03,169.9 218.69,170.25 218.69,170.7 219.63,171.64 220.31,171.64 220.64,171.97 220.64,172.41 CN2044.3
TXC_HDMI+: length 14.7
  TOP w0.102: R22124.2 225.8,168.57 225.8,168.77 R21018.2 225.8,169.24 225.8,169.52 D13077.2 225.58,169.9 225.8,170.12 225.8,170.7 v1(225.54,170.97)
  IN1 w0.089: v1(225.54,170.97) 225.81,171.25 225.81,171.55 225.97,171.71 226.12,171.86 228.97,171.86 229.52,172.42 229.52,173.13 229.32,173.33 225.24,173.33 224.86,173.71 224.86,173.91 CN2044.10
TXC_HDMI-: length 14.7
  TOP w0.102: R22125.2 226.08,168.47 226.08,168.74 R21018.1 226.08,169.27 226.08,169.52 D13078.2 226.32,169.9 226.08,170.15 226.08,170.65 v1(226.4,170.97)
  IN1 w0.089: CN2044.12 225.13,173.9 225.13,173.82 225.35,173.6 229.43,173.6 229.79,173.24 229.79,172.3 229.08,171.59 226.23,171.59 226.16,171.52 226.08,171.44 226.08,171.28 v1(226.4,170.97)
TYPEC_VBUS: length 27.1
  TOP w0.254: U13155.B10 U13155.A10 365.63,28.99 ; v1(378.35,42.38) v1(379.04,42.38) 379.05,42.38 CN18.A4 380.39,42.38 380.56,42.2 v4(380.74,42.2) 380.82,42.13 CN18.B9 ; CN18.B4 381.05,44.63 380.98,44.69 380.86,44.69 v4(380.74,44.81) 380.67,44.87 CN18.A9 379.37,44.87 379.34,44.85 v1(379.04,44.85)
  TOP w0.305: v1(364.89,40.53) 364.89,39.87 364.61,39.59 Q7923.5
  TOP w0.508: v1(379.04,44.85) 378.63,44.85 378.43,44.64 v1(378.43,44.57) ; v1(365.19,29.46) 365.19,29.44 365.63,28.99
  IN1 w0.508: v1(364.89,40.53) 365.75,39.67 367.43,39.67 370.33,36.77 v1(371.47,36.77) ; v1(365.19,29.46) 367.35,29.46 368.59,30.69 368.59,31.22 369.31,31.94 v1(369.56,31.94)
  BOTTOM w0.381: C94626.1 381.42,44.81 v4(380.74,44.81) ; C94624.1 381.46,42.2 v4(380.74,42.2)
  BOTTOM w0.508: C94625.1 C94626.1 ; C961.1 C94624.1
  vias: v1(371.11,38.83) v1(371.19,38.17) v1(371.16,37.43) v1(371.19,35.22)
U3_CE: length 4.6
  TOP w0.14: U13124.12 28.76,52.38 28.9,52.52 29,52.52 29.92,51.6 v1(30.2,51.6) 30.2,52.38 30.05,52.52 30.05,53.1 R22048.1
U3_OS: length 4
  TOP w0.14: U13124.30 27.96,44.8 v1(27.81,44.64)
  BOTTOM w0.14: v1(27.96,47.03) 27.81,46.88 27.81,45.73 R21679.1 27.31,45.14 v1(27.81,44.64)
UART2_CTS#: length 26.1
  TOP w0.102: U13113.AN43 307.66,73.58 307.41,73.83 307.41,74.51 307.51,74.61 307.51,75.28 v1(307.21,75.58)
  IN1 w0.089: v1(287.47,78.22) 288.18,77.51 302.33,77.51 302.79,77.05 302.79,76.15 303.47,75.47 303.47,74.85 303.91,74.41 306.55,74.41 306.65,74.51 306.65,75.02 v1(307.21,75.58)
  BOTTOM w0.14: v1(287.47,78.22) 287.64,78.05 R21326.1
UART2_TXD: length 33.4
  TOP w0.14: v2(308.12,71.26) 308.58,71.72 U13113.AR39
  IN1 w0.089: v1(309.04,79.19) 308.43,79.8 306.37,79.8 305.86,80.31 297.91,80.31 297.68,80.53 290.82,80.53 289.88,79.59 288.47,79.59 287.53,78.66 287.09,78.66 v1(286.81,78.38)
  BOTTOM w0.14: v1(286.81,78.38) 287.31,78.87 R21324.1 ; v2(308.12,71.26) 308.14,71.26 308.63,71.75 v1(308.63,71.78) 308.63,72.81 308.57,72.87 308.57,73.49 308.78,73.7 308.78,77.49 308.78,77.49 308.78,78.17 308.78,78.93 v1(309.04,79.19)
UART_MISO: length 6.9
  TOP w0.081: 368.37,24.08 368.37,24.74 U13155.F2
  TOP w0.14: 368.37,24.08 368.37,23.05 368.52,22.91 368.52,22.14 368.22,21.84 368.22,19.83 R67119.1 v1(369.51,19.36)
UART_MOSI: length 6.3
  TOP w0.081: U13155.E2 367.87,24.74 367.87,24.08
  TOP w0.14: R67118.1 367.19,19.72 367.19,20.3 367.05,20.44 367.05,21.69 367.87,22.51 367.87,24.08
UIF_RST#_R: length 21.6
  TOP w0.14: R67035.2 379.19,5.4 378.99,5.2 378.53,5.2 v1(378.51,5.21) 378.51,5.27 378.43,5.35 v1(378.43,5.86) 378.3,5.99 U13152.24
  IN4 w0.089: v1(375.91,16.54) 375.91,16.6 375.54,16.97 375.06,16.97 374.9,16.82 374.32,16.82 372.85,15.35 372.85,13.69 377.19,9.35 377.19,7.23 378.58,5.84 378.58,5.28 v1(378.51,5.21)
  BOTTOM w0.14: Q7948.1 374.97,15.99 375.41,15.99 375.91,16.5 v1(375.91,16.54) ; R67386.2 378.29,5.49 378.51,5.27 v1(378.51,5.21)
USB2_COMP: length 9.7
  TOP w0.102: 302.69,50.69 303.27,50.69 303.57,50.99 303.89,50.99 304.29,51.39 304.29,51.91 304.21,51.99 304.21,52.84 304.41,53.03 304.41,53.47 304.69,53.75 U13113.AG3
  TOP w0.14: R21085.1 301.52,47.37 v1(300.55,48.34) 300.55,48.96 301.59,50 302,50 302.69,50.69
USB3_RXN1: length 99.3
  TOP w0.104: 291.52,56.51 291.58,56.45 291.84,56.45 291.93,56.54 292.25,56.54 U13113.C8
  TOP w0.14: v1(290.47,55.76) 290.56,55.86 290.56,56.2 290.87,56.51 291.52,56.51 ; R21700.1 365.57,60.95 L4256.2 364.94,61.03 364.67,61.3 363.99,61.3 363.78,61.51 v1(363.52,61.51)
  IN5 w0.089: v1(290.47,55.76) 290.66,55.96 290.66,56.27 290.85,56.46 291.74,56.46 292.09,56.1 292.09,55.08 292.88,54.3 292.88,54.12 293.31,53.69 293.5,53.69 293.68,53.51 294.36,53.51 295.3,54.45 295.3,55.96 296.08,56.74 296.08,57.34 296.5,57.77 297.59,57.77 297.71,57.89 298.11,57.89 298.59,57.42 299.96,57.42 300.46,57.92 301.69,57.92 302.28,58.51 302.66,58.51 303.17,58 303.17,54.19 304.44,52.92 305.21,52.92 305.52,52.61 316.44,52.61 319.01,55.17 322.38,55.17 322.6,54.96 325.54,54.96 327.26,56.68 327.26,57.44 327.74,57.92 329.72,57.92 332.37,60.57 334.68,60.57 336.75,62.64 338.33,62.64 339.06,63.38 339.06,64.81 339.61,65.36 342.24,65.36 343.97,63.63 345.28,63.63 345.78,63.13 346.67,63.13 347.94,61.86 359.37,61.86 360.62,60.61 363.4,60.61 363.86,61.07 363.86,61.41 363.76,61.51 v1(363.52,61.51)
USB3_RXN1_R: length 19.6
  TOP w0.14: CN2067.5 374.6,63.56 374.91,63.25 375.69,63.25 376.05,62.89 376.49,62.89 377.16,63.56 377.16,64.61 376.34,65.43 TP61.1 373.31,65.43 372.32,64.45 372.32,63.83 v1(372.89,63.26) 372.32,62.69 372.32,62.11 371.47,61.26 371.13,61.26 U13127.5 371.03,61.26 368.87,61.26 368.82,61.32 367.9,61.32 367.62,61.03 L4256.1 367.26,60.95 R21700.2
USB3_RXN2: length 277.4
  TOP w0.104: 291.66,56.75 U13113.A9
  TOP w0.14: v1(290.16,57.19) 290.6,56.75 291.66,56.75 ; C95511.1 32.5,45.82 33.35,45.82 33.5,45.97 v1(33.5,46.11)
  IN1 w0.089: v1(290.16,57.19) 290.41,56.95 290.41,56.5 290.32,56.41 288.24,56.41 287.72,55.89 283.25,55.89 283.04,56.1 282.61,56.1 281.13,54.62 281.13,53.74 278.17,50.78 269.64,50.78 269.53,50.88 265.51,50.88 264.85,50.23 261.08,50.23 260.7,49.85 242.47,49.85 241.89,50.44 234.67,50.44 234.4,50.17 196.48,50.17 194.64,52.01 179.95,52.01 179.69,52.27 176.89,52.27 174.03,49.41 99.54,49.41 97.06,46.92 86.28,46.92 85.62,46.27 84.84,46.27 83.4,44.82 73.09,44.82 72.85,44.59 69.11,44.59 69.02,44.49 67.4,44.49 66.11,43.2 65.78,43.2 63.6,45.38 61.95,45.38 61.54,45.79 61.54,48.07 60.75,48.86 52.12,48.86 51.67,49.31 48.14,49.31 47.42,48.58 46.3,48.58 44.52,46.8 36.67,46.8 36.34,46.47 36.34,45.03 35.71,44.4 34.83,44.4 34.43,44.8 34.43,45.5 34.17,45.76 33.75,45.76 33.5,46.02 v1(33.5,46.11)
USB3_RXN2_C: length 3.1
  TOP w0.14: U13124.2 30.09,47.13 30.83,46.4 30.83,45.99 30.97,45.85 31.58,45.85 C95511.2
USB3_RXN2_C_RE: length 13.5
  TOP w0.14: R21675.1 22.17,37.94 L4248.2 22.83,37.83 23.1,37.56 23.24,37.56 23.4,37.73 23.4,40.26 24.65,41.51 24.65,41.8 24.5,41.95 v1(24.12,41.95) 24.65,42.48 24.65,44.94 25.31,45.6 25.31,46.77 25.57,47.03 25.72,47.03 25.82,47.13 U13124.26
USB3_RXN2_C_RE_R: length 11.9
  TOP w0.14: R21675.2 20.54,37.94 L4248.1 19.71,37.83 19.3,38.23 17.99,38.23 17.94,38.18 17.03,38.18 U13122.5 16.77,38.18 14.87,38.18 14.36,37.67 14.36,37 v1(14.14,36.79)
  BOTTOM w0.14: v1(14.14,36.79) 14.42,37.07 14.42,37.32 14.06,37.68 TP13163.1 12.9,37.68 12.68,37.91 12.54,37.91 12.4,37.76 CN2064.5
USB3_RXN3: length 283
  TOP w0.14: U13113.G11 294.51,57.68 v2(294.86,58.03) ; C95515.1 32.5,49.12 33.15,49.12 v1(33.45,49.41)
  IN1 w0.089: v2(294.86,58.03) 294.58,57.75 294.58,57.59 294.39,57.4 291.6,57.4 291.29,57.71 289.21,57.71 288.32,56.82 282.71,56.82 280.66,54.78 280.66,53.83 278,51.17 270.24,51.17 270.13,51.28 265.2,51.28 264.54,50.62 260.92,50.62 260.56,50.27 242.61,50.27 241.93,50.95 234.37,50.95 234.11,50.69 229.41,50.69 229.17,50.93 208.66,50.93 207.96,51.63 196.99,51.63 195.64,52.98 191.17,52.98 190.89,53.26 190.01,53.26 189.65,53.62 184.06,53.62 183.71,53.27 180.71,53.27 180.11,52.67 176.7,52.67 173.87,49.84 99.41,49.84 96.89,47.31 86.11,47.31 85.46,46.66 81.8,46.66 80.35,45.21 75.78,45.21 75.11,45.88 73.59,45.88 72.69,44.98 68.95,44.98 68.85,44.88 67.89,44.88 67.59,45.18 67.41,45.36 65.2,45.36 63.76,46.8 63.76,48.23 61.93,50.06 60.01,50.06 59.2,49.25 54.03,49.25 53.32,49.96 48.67,49.96 48.17,50.46 46.59,50.46 43.32,47.19 35.56,47.19 34.75,46.38 33.83,46.38 32.31,47.9 32.31,48.82 32.62,49.13 33.16,49.13 v1(33.45,49.41)
USB3_RXN3_C: length 2.5
  TOP w0.14: C95515.2 31.56,49.13 31.22,49.13 30.88,49.47 30.36,49.47 30.3,49.53 U13124.8
USB3_RXN3_C_RE: length 6.4
  TOP w0.14: R21682.1 21.85,46.98 L4252.2 22.61,46.98 22.87,46.71 23.14,46.71 23.88,47.45 23.88,48.03 24.44,48.59 24.44,48.9 25.02,49.47 25.74,49.47 25.8,49.53 U13124.20
USB3_RXN3_C_RE_R: length 19.9
  TOP w0.14: v1(13.03,51.1) 13.03,50.91 13.23,50.72 13.69,50.72 13.99,50.41 13.99,47.56 15.01,46.54 16.61,46.54 U13123.5 16.98,46.74 20,46.74 20.23,46.98 L4252.1 20.54,47.08 R21682.2
  BOTTOM w0.14: v1(13.03,51.1) 13.03,50.91 13.23,50.71 13.48,50.71 13.56,50.79 13.56,55.67 13.31,55.92 TP13175.1 12.49,55.92 12.24,55.66 12.24,55.16 CN2065.5
USB3_RXP1: length 99.3
  TOP w0.104: U13113.B8 292.2,56.31 292.32,56.18 292.32,55.92 292.27,55.87 291.89,55.87 291.52,56.25
  TOP w0.14: v1(364.08,61.89) 364.08,61.64 364.15,61.57 364.67,61.57 364.94,61.83 L4256.3 365.6,61.94 R21701.1 ; 291.52,56.25 290.98,56.25 290.83,56.09 290.83,55.94 291.01,55.76 v1(291.15,55.76)
  IN5 w0.089: v1(291.15,55.76) 291.08,55.76 290.83,56.01 290.83,56.2 290.92,56.29 291.67,56.29 291.93,56.03 291.93,55.01 292.71,54.23 292.71,54.05 293.24,53.52 293.43,53.52 293.61,53.34 294.42,53.34 295.46,54.38 295.46,55.89 296.25,56.67 296.25,57.27 296.57,57.6 297.66,57.6 297.78,57.73 298.04,57.73 298.52,57.25 300.03,57.25 300.53,57.75 301.76,57.75 302.35,58.35 302.59,58.35 303,57.94 303,54.13 304.37,52.75 305.14,52.75 305.45,52.44 316.51,52.44 319.08,55.01 322.31,55.01 322.53,54.79 325.61,54.79 327.43,56.61 327.43,57.37 327.81,57.75 329.79,57.75 332.44,60.4 334.75,60.4 336.82,62.48 338.4,62.48 339.23,63.31 339.23,64.74 339.68,65.19 342.17,65.19 343.9,63.47 345.21,63.47 345.71,62.96 346.6,62.96 347.87,61.69 359.3,61.69 360.55,60.44 363.47,60.44 364.03,61 364.03,61.48 363.9,61.61 363.9,61.71 v1(364.08,61.89)
USB3_RXP1_R: length 19.6
  TOP w0.14: CN2067.6 375.08,62.98 375.58,62.98 375.94,62.63 376.6,62.63 377.43,63.45 377.43,64.72 376.45,65.7 TP66.1 373.2,65.7 372.05,64.56 372.05,63.79 v1(371.49,63.22) 372.05,62.66 372.05,62.22 371.36,61.53 369.36,61.53 U13127.6 369.2,61.53 368.98,61.53 368.93,61.59 367.86,61.59 367.62,61.83 L4256.4 367.23,61.94 R21701.2
USB3_RXP2: length 277.4
  TOP w0.104: U13113.B10 292.16,56.96 291.72,56.96 291.66,57.02
  TOP w0.14: v1(33.5,45.26) 33.21,45.55 32.5,45.55 C95512.1 ; v1(290.82,57.19) 291,57.02 291.66,57.02
  IN1 w0.089: v1(33.5,45.26) 33.83,45.59 34.1,45.59 34.26,45.43 34.26,44.73 34.76,44.23 35.78,44.23 36.51,44.96 36.51,46.4 36.74,46.63 44.59,46.63 46.37,48.41 47.49,48.41 48.21,49.14 51.6,49.14 52.05,48.69 60.68,48.69 61.37,48 61.37,45.72 61.88,45.21 63.53,45.21 65.71,43.03 66.18,43.03 67.47,44.32 69.08,44.32 69.18,44.42 72.92,44.42 73.16,44.65 83.47,44.65 84.91,46.1 85.69,46.1 86.34,46.75 97.13,46.75 99.61,49.24 174.09,49.24 176.96,52.11 179.62,52.11 179.88,51.84 194.57,51.84 196.41,50 234.47,50 234.73,50.27 241.82,50.27 242.4,49.68 260.77,49.68 261.15,50.06 264.92,50.06 265.58,50.72 269.46,50.72 269.57,50.61 278.24,50.61 281.3,53.67 281.3,54.55 282.68,55.93 282.97,55.93 283.18,55.72 287.79,55.72 288.31,56.24 290.39,56.24 290.58,56.43 290.58,56.95 v1(290.82,57.19)
USB3_RXP2_C: length 3
  TOP w0.14: U13124.1 30.12,46.73 30.56,46.29 30.56,45.88 30.86,45.58 31.52,45.58 C95512.2
USB3_RXP2_C_RE: length 13.5
  TOP w0.14: R21676.1 22.17,36.92 L4248.3 22.83,37.03 23.1,37.3 23.35,37.3 23.67,37.62 23.67,40.15 24.92,41.4 24.92,41.8 25.07,41.95 v1(25.42,41.95) 24.92,42.45 24.92,44.83 25.57,45.49 25.57,46.65 25.68,46.77 25.79,46.77 25.82,46.73 U13124.27
USB3_RXP2_C_RE_R: length 11.8
  TOP w0.14: v1(14.86,36.79) 14.63,37.03 14.63,37.56 14.98,37.92 18.05,37.92 18.1,37.97 18.65,37.97 U13122.6 18.75,37.97 19.19,37.97 20.13,37.03 L4248.4 20.54,36.92 R21676.2
  BOTTOM w0.14: v1(14.86,36.79) 14.69,36.96 14.69,37.43 14.17,37.95 TP13160.1 13.01,37.95 12.4,38.56 CN2064.6
USB3_RXP3: length 283
  TOP w0.14: C95517.1 32.5,48.85 33.33,48.85 33.57,48.61 v1(33.57,48.44) ; U13113.E11 293.62,57.53 v2(294.13,58.03)
  IN1 w0.089: v2(294.13,58.03) 294.41,57.75 294.41,57.66 294.32,57.57 291.67,57.57 291.36,57.88 289.14,57.88 288.25,56.99 282.64,56.99 280.5,54.85 280.5,53.9 277.93,51.34 270.31,51.34 270.2,51.45 265.13,51.45 264.47,50.79 260.85,50.79 260.49,50.44 242.68,50.44 242,51.12 234.3,51.12 234.04,50.86 229.48,50.86 229.24,51.1 208.73,51.1 208.03,51.8 197.06,51.8 195.71,53.14 191.24,53.14 190.96,53.43 190.08,53.43 189.72,53.79 183.99,53.79 183.64,53.43 180.64,53.43 180.04,52.84 176.63,52.84 173.8,50 99.34,50 96.82,47.48 86.04,47.48 85.39,46.83 81.73,46.83 80.28,45.38 75.85,45.38 75.18,46.05 73.52,46.05 72.62,45.15 68.88,45.15 68.78,45.05 67.96,45.05 67.71,45.3 67.48,45.53 65.27,45.53 63.93,46.87 63.93,48.3 61.99,50.23 59.94,50.23 59.13,49.42 54.1,49.42 53.39,50.13 48.74,50.13 48.24,50.63 46.52,50.63 43.25,47.36 35.5,47.36 34.68,46.55 33.9,46.55 32.48,47.97 32.48,48.75 32.69,48.96 33.22,48.96 33.57,48.61 v1(33.57,48.44)
USB3_RXP3_C: length 2.5
  TOP w0.14: C95517.2 31.55,48.86 31.11,48.86 30.77,49.2 30.36,49.2 30.3,49.13 U13124.7
USB3_RXP3_C_RE: length 6.4
  TOP w0.14: R21683.1 21.85,46.17 L4252.3 22.61,46.17 22.88,46.44 23.25,46.44 24.15,47.34 24.15,47.92 24.71,48.48 24.71,48.78 25.13,49.2 25.7,49.2 25.77,49.13 U13124.21
USB3_RXP3_C_RE_R: length 19.9
  TOP w0.14: R21683.2 20.54,46.07 L4252.4 20.31,46.17 20.01,46.48 18.75,46.48 U13123.6 18.65,46.48 16.94,46.48 16.73,46.27 14.9,46.27 13.72,47.45 13.72,50.3 13.57,50.45 13.2,50.45 v1(13.03,50.29)
  BOTTOM w0.14: v1(13.03,50.29) 13.19,50.45 13.59,50.45 13.67,50.52 13.82,50.68 13.82,55.78 13.42,56.18 TP13172.1 12.79,56.18 12.4,56.57 CN2065.6
USB3_TXN1: length 102
  TOP w0.104: U13113.B12 291.85,57.62
  TOP w0.14: C95538.1 364.01,57.14 363.82,57.32 363.52,57.32 363.42,57.22 v1(363.42,57.05) ; v1(288.03,58.34) 288.36,58.34 289.08,57.62 291.85,57.62
  IN5 w0.089: v1(363.42,57.05) 363.42,57.37 363.34,57.45 362.94,57.45 362.66,57.16 362.66,56.48 363.27,55.87 364.59,55.87 365.31,56.59 365.31,62.03 361.95,65.39 354.5,65.39 353.29,66.6 347.68,66.6 346.64,67.64 341.96,67.64 341.38,68.23 338.09,68.23 336.4,66.54 336.17,66.54 334.09,64.47 332.17,64.47 329.98,62.28 326.98,62.28 326.78,62.08 323.5,62.08 322.18,60.76 321.53,60.76 320.76,60 319.89,60 319.76,59.86 313.51,59.86 312.76,60.61 306.39,60.61 305.91,60.12 305.13,60.12 304.12,61.14 301.59,61.14 300.7,60.25 299.4,60.25 299.11,60.54 296.18,60.54 296.06,60.42 295.3,60.42 295.17,60.54 293.52,60.54 291.38,58.41 288.56,58.41 288.42,58.55 288.24,58.55 v1(288.03,58.34)
USB3_TXN1_C: length 1.9
  TOP w0.14: R21704.1 365.6,56.86 L4257.2 365.21,56.97 364.9,57.28 364.72,57.28 C95538.2
USB3_TXN1_R: length 18.9
  TOP w0.14: CN2067.8 374.94,58.16 376.91,58.16 377.39,57.67 377.39,56.3 376.3,55.21 TP69.1 372.62,55.21 372.1,55.72 372.1,56.46 v1(371.6,56.96) 372.1,57.47 372.1,57.83 371.88,58.06 371.13,58.06 U13127.1 371.03,58.06 368.89,58.06 367.98,57.14 367.71,57.14 367.54,56.97 L4257.1 367.23,56.86 R21704.2
USB3_TXN2: length 276.3
  TOP w0.081: 291.49,58.17 291.54,58.22 292.8,58.22 U13113.D13
  TOP w0.14: v1(34.59,47.97) 34.44,47.82 33.5,47.82 33.15,47.47 32.5,47.47 C95513.1 ; 291.49,58.17 289.23,58.17 288.96,58.44 288.96,58.81 v1(288.74,59.02)
  IN1 w0.089: v1(34.59,47.97) 34.82,47.73 35.01,47.73 35.75,48.47 43.47,48.47 46.42,51.42 50.89,51.42 51.12,51.19 60.22,51.19 60.59,50.81 62.21,50.81 63.87,49.16 65.55,47.47 65.55,47.11 66.03,46.63 67.18,46.63 68.19,45.61 68.55,45.61 68.65,45.71 72.39,45.71 73.33,46.65 75.38,46.65 75.54,46.49 80.35,46.49 81.49,47.62 83.09,47.62 83.51,48.04 96.54,48.04 99.11,50.61 129.86,50.61 130.95,51.7 174.64,51.7 176.34,53.4 179.81,53.4 180.4,53.99 183.33,53.99 183.73,54.39 190.79,54.39 191.39,53.79 196.27,53.79 197.68,52.38 208.34,52.38 208.91,51.81 229.54,51.81 229.85,51.5 233.74,51.5 234.03,51.78 242.13,51.78 242.84,51.07 260.18,51.07 260.46,51.35 264.13,51.35 265.28,52.5 270.85,52.5 271.46,51.9 277.7,51.9 279.81,54.01 279.81,54.97 282.47,57.62 287.97,57.62 288.9,58.56 288.9,58.86 v1(288.74,59.02)
USB3_TXN2_C: length 2.8
  TOP w0.14: C95513.2 31.57,47.49 31.49,47.49 31.43,47.55 31.43,47.81 31.01,48.23 30.2,48.23 30.09,48.33 U13124.5
USB3_TXN2_C_RE: length 7
  TOP w0.14: C95506.1 23.13,44.63 23.31,44.81 23.31,45.74 v1(23.36,45.79) 23.39,45.81 23.77,45.81 24.59,46.64 24.59,47.73 25.12,48.25 25.75,48.25 25.83,48.33 U13124.23
USB3_TXN2_C_RE_C: length 3
  TOP w0.14: C95506.2 23.31,43.05 23.5,42.85 23.5,42.43 23.07,41.99 22.94,41.99 22.53,42.4 L4249.2 21.85,42.4 R21677.1
USB3_TXN2_C_RE_C_R: length 13.8
  TOP w0.14: R21677.2 20.86,42.4 L4249.1 20.01,42.4 19.74,42.14 18.85,42.14 18.1,41.38 17.03,41.38 U13122.1 16.77,41.38 16.39,41.38 16.28,41.49 14.37,41.49 14.1,41.23 14.1,40.9 v1(13.89,40.68)
  BOTTOM w0.14: v1(13.89,40.68) 14.1,40.9 14.1,43.64 13.92,43.82 TP13162.1 12.54,43.82 12.4,43.68 CN2064.8
USB3_TXN3: length 275.6
  TOP w0.14: U13113.B13 291.99,58.73 290.74,58.73 v1(290.24,59.22) ; v1(33.68,51.1) 33.68,51.12 33.03,51.76 32.4,51.76 C95518.1
  IN1 w0.089: v1(33.68,51.1) 33.62,51.1 33.4,51.32 33.4,51.58 33.49,51.67 35.88,51.67 36.41,52.2 40.17,52.2 41.61,50.77 44.63,50.77 45.77,51.91 49.29,51.91 51.02,53.65 52.45,53.65 53.14,52.96 59.01,52.96 60.76,51.21 62.37,51.21 65.18,48.4 67.29,48.4 69.59,46.1 72.23,46.1 73.17,47.04 75.54,47.04 75.7,46.88 78.65,46.88 79.78,48.02 82.93,48.02 83.34,48.44 95.49,48.44 98.13,51.08 128.23,51.08 129.25,52.1 174.33,52.1 176.72,54.48 183.07,54.48 183.53,54.94 191.14,54.94 191.75,54.33 196.52,54.33 198.07,52.78 208.84,52.78 209.22,52.4 264.15,52.4 264.64,52.9 277.67,52.9 279.33,54.56 279.33,55.05 283.28,58.99 284.08,58.99 284.84,59.76 286.63,59.76 287.13,60.25 289.63,60.25 290.24,59.65 v1(290.24,59.22)
USB3_TXN3_C: length 3
  TOP w0.14: U13124.11 30.3,50.73 30.36,50.67 30.5,50.67 30.59,50.75 30.59,51.17 31.1,51.68 31.57,51.68 C95518.2
USB3_TXN3_C_RE: length 2.8
  TOP w0.14: U13124.17 25.62,50.73 25.56,50.67 25.42,50.67 25.01,51.07 24.2,51.07 C95520.1
USB3_TXN3_C_RE_C: length 1.9
  TOP w0.14: C95520.2 23.11,51.09 22.81,51.09 22.61,51.29 L4253.2 21.85,51.29 R21684.1
USB3_TXN3_C_RE_C_R: length 22.5
  TOP w0.14: v1(15.26,50.84) 15.34,50.76 15.34,50.56 15.45,50.45 15.95,50.45 16.51,49.89 16.77,49.89 U13123.1 17.03,49.89 18.12,49.89 19.06,50.83 19.84,50.83 19.98,50.97 19.98,51.2 20.08,51.29 L4253.1 20.86,51.29 R21684.2
  BOTTOM w0.14: CN2065.8 12.28,61.12 12.28,61.62 12.49,61.84 TP13174.1 13.99,61.84 14.5,61.33 14.5,54.29 15.85,52.93 15.85,50.64 15.69,50.47 15.37,50.47 15.26,50.59 v1(15.26,50.84)
USB3_TXP1: length 102.1
  TOP w0.104: 291.61,57.89 U13113.A12
  TOP w0.14: v1(288.06,59.05) 288.06,59.02 289.19,57.89 291.61,57.89 ; v1(363.49,57.8) 363.54,57.75 C95539.1
  IN5 w0.089: v1(363.49,57.8) 363.31,57.61 362.87,57.61 362.49,57.23 362.49,56.41 363.2,55.7 364.66,55.7 365.48,56.52 365.48,62.1 362.02,65.56 354.57,65.56 353.36,66.77 347.75,66.77 346.7,67.81 342.03,67.81 341.45,68.39 338.02,68.39 336.33,66.71 336.1,66.71 334.02,64.63 332.1,64.63 329.91,62.44 326.91,62.44 326.71,62.24 323.43,62.24 322.11,60.93 321.46,60.93 320.7,60.16 319.82,60.16 319.69,60.03 313.58,60.03 312.83,60.77 306.32,60.77 305.84,60.29 305.2,60.29 304.19,61.31 301.52,61.31 300.63,60.42 299.47,60.42 299.17,60.71 296.11,60.71 295.99,60.59 295.36,60.59 295.24,60.71 293.45,60.71 291.31,58.58 288.63,58.58 288.44,58.77 288.34,58.77 v1(288.06,59.05)
USB3_TXP1_C: length 1.8
  TOP w0.14: R21706.1 365.57,57.85 L4257.3 365.19,57.77 364.97,57.55 364.66,57.55 C95539.2
USB3_TXP1_R: length 19
  TOP w0.14: CN2067.9 374.6,57.36 375.13,57.89 376.79,57.89 377.12,57.56 377.12,56.41 376.19,55.48 TP71.1 372.73,55.48 372.37,55.83 372.37,56.44 v1(372.89,56.96) 372.37,57.48 372.37,57.94 371.99,58.32 369.37,58.32 U13127.10 369.19,58.32 368.78,58.32 368.01,57.55 367.74,57.55 367.51,57.77 L4257.4 367.26,57.85 R21706.2
USB3_TXP2: length 276.2
  TOP w0.081: U13113.C13 292.58,58.47 292.5,58.38 291.54,58.38 291.49,58.44
  TOP w0.14: 291.49,58.44 289.34,58.44 289.22,58.55 289.22,58.84 v1(289.4,59.02) ; C95514.1 32.5,47.2 33.26,47.2 33.61,47.55 34.37,47.55 34.59,47.34 v1(34.59,47.11)
  IN1 w0.089: v1(34.59,47.11) 34.59,47.33 34.82,47.57 35.08,47.57 35.82,48.3 43.54,48.3 46.49,51.25 50.82,51.25 51.05,51.02 60.15,51.02 60.53,50.65 62.14,50.65 63.75,49.04 65.38,47.4 65.38,47.04 65.97,46.46 67.11,46.46 68.12,45.44 68.62,45.44 68.72,45.54 72.46,45.54 73.4,46.48 75.31,46.48 75.47,46.32 80.42,46.32 81.56,47.46 83.16,47.46 83.58,47.88 96.61,47.88 99.18,50.45 129.93,50.45 131.02,51.54 174.71,51.54 176.41,53.23 179.88,53.23 180.47,53.83 183.4,53.83 183.8,54.22 190.72,54.22 191.32,53.62 196.2,53.62 197.61,52.21 208.27,52.21 208.84,51.64 229.47,51.64 229.78,51.33 233.81,51.33 234.1,51.61 242.06,51.61 242.77,50.9 260.25,50.9 260.53,51.18 264.2,51.18 265.35,52.33 270.78,52.33 271.39,51.73 277.77,51.73 279.98,53.94 279.98,54.9 282.54,57.46 288.04,57.46 289.07,58.49 289.07,58.82 289.28,59.02 v1(289.4,59.02)
USB3_TXP2_C: length 2.8
  TOP w0.14: C95514.2 31.53,47.22 31.38,47.22 31.16,47.44 31.16,47.7 30.9,47.96 30.2,47.96 30.17,47.93 U13124.4
USB3_TXP2_C_RE: length 7
  TOP w0.14: U13124.24 25.78,47.93 25.72,47.98 25.23,47.98 24.86,47.62 24.86,46.52 24.02,45.69 v1(24.02,44.67) 23.55,44.67 23.4,44.52 23.4,43.84 23.55,43.69 23.55,43.55 23.61,43.5 C95507.1
USB3_TXP2_C_RE_C: length 3.1
  TOP w0.14: R21678.1 21.85,41.6 L4249.3 22.66,41.6 22.78,41.72 23.18,41.72 23.77,42.32 23.77,42.92 C95507.2
USB3_TXP2_C_RE_C_R: length 13.9
  TOP w0.14: v1(14.63,40.68) 14.37,40.94 14.37,41.12 14.48,41.23 16.17,41.23 16.28,41.12 U13122.10 18.7,41.61 18.96,41.87 19.74,41.87 20.01,41.6 L4249.4 20.86,41.6 R21678.2
  BOTTOM w0.14: v1(14.63,40.68) 14.37,40.94 14.37,43.75 14.03,44.09 TP13167.1 12.9,44.09 12.4,44.58 CN2064.9
USB3_TXP3: length 275.5
  TOP w0.14: v1(290.95,59.25) 290.95,59.07 291.03,59 291.68,59 U13113.A14 ; C95519.1 32.25,51.37 32.37,51.5 32.92,51.5 33.17,51.25 33.17,51.12 v1(32.99,50.94)
  IN1 w0.089: v1(290.95,59.25) 290.88,59.17 290.72,59.17 290.65,59.25 290.65,59.48 289.7,60.42 287.06,60.42 286.56,59.93 284.77,59.93 284.01,59.16 283.21,59.16 279.17,55.12 279.17,54.63 277.6,53.06 264.57,53.06 264.08,52.57 209.29,52.57 208.91,52.95 198.14,52.95 196.59,54.5 191.82,54.5 191.21,55.11 183.46,55.11 183,54.65 176.65,54.65 174.26,52.26 129.18,52.26 128.16,51.25 98.06,51.25 95.42,48.6 83.28,48.6 82.86,48.19 79.71,48.19 78.58,47.05 75.77,47.05 75.61,47.21 73.1,47.21 72.16,46.27 69.65,46.27 67.36,48.57 65.25,48.57 62.44,51.38 60.83,51.38 59.08,53.13 53.21,53.13 52.52,53.81 50.95,53.81 49.22,52.08 45.7,52.08 44.56,50.93 41.68,50.93 40.24,52.37 36.34,52.37 35.81,51.83 33.42,51.83 33.23,51.65 33.23,51.05 33.13,50.94 v1(32.99,50.94)
USB3_TXP3_C: length 3
  TOP w0.14: U13124.10 30.3,50.33 30.36,50.4 30.61,50.4 30.86,50.64 30.86,51.06 31.21,51.41 31.53,51.41 C95519.2
USB3_TXP3_C_RE: length 2.8
  TOP w0.14: C95521.1 23.87,50.52 24.15,50.8 24.9,50.8 25.31,50.4 25.56,50.4 25.62,50.33 U13124.18
USB3_TXP3_C_RE_C: length 2
  TOP w0.14: C95521.2 23.11,50.82 22.94,50.82 22.61,50.49 L4253.3 21.85,50.49 R21688.1
USB3_TXP3_C_RE_C_R: length 22.4
  TOP w0.14: v1(15.26,50.02) 15.43,50.18 15.84,50.18 16.4,49.63 U13123.10 18.7,50.09 19.17,50.56 19.98,50.56 20.05,50.49 L4253.4 20.86,50.49 R21688.2
  BOTTOM w0.14: CN2065.9 12.4,62.74 13.04,62.11 TP13179.1 14.1,62.11 14.77,61.44 14.77,54.4 16.12,53.04 16.12,50.53 15.8,50.21 15.45,50.21 v1(15.26,50.02)
USB_BC_ON: length 209.8
  TOP w0.14: U13128.4 361.85,50.65 361.69,50.49 361.69,50.19 361.8,50.08 v1(361.84,50.08) ; v1(192.32,68.44) 192.4,68.37 U49.97
  IN3 w0.079: v1(361.84,50.08) 361.91,50.15 361.91,57.68 358.5,61.09 354.83,61.09 354.44,61.48 341.54,61.48 341.36,61.65 336.93,61.65 334.16,64.43 334.16,65 331.65,67.5 331.65,69.62 331.15,70.12 331.15,71.12 330.5,71.77 330.5,75.89 330.08,76.31 328.92,76.31 327.76,75.15 323.8,75.15 321.67,77.28 318.11,77.28 316.32,75.49 312.68,75.49 312,74.82 311.25,74.82 310.61,74.18 301.91,74.18 300.71,75.38 300.71,76.49 300.2,77 295.35,77 294.89,76.54 291.05,76.54 290.76,76.83 285.74,76.83 284.7,77.87 284.7,79.19 280.44,83.46 278.65,83.46 277.41,84.7 211.32,84.7 206.59,79.97 205.42,79.97 202.57,77.12 202.57,75.31 200.74,73.48 200.74,72.77 199,71.03 197.14,71.03 196.08,69.97 196.08,69.01 195.01,67.94 192.83,67.94 v1(192.32,68.44)
USB_CHARGE_ON: length 213.2
  TOP w0.14: v1(363.75,48.53) 363.16,49.11 362.99,49.11 362.87,49.23 U13128.5 ; v1(195.09,68.57) 194.91,68.39 v1(194.91,67.35) 194.91,65.73 194.79,65.6 U49.96
  IN3 w0.079: v1(195.09,68.57) 195.09,69.28 197,71.19 198.93,71.19 200.58,72.83 200.58,73.58 202.41,75.41 202.41,77.18 205.36,80.13 206.53,80.13 211.26,84.86 277.61,84.86 278.85,83.62 280.5,83.62 284.86,79.26 284.86,77.93 285.8,77 290.84,77 291.14,76.7 294.83,76.7 295.29,77.16 300.27,77.16 300.93,76.5 300.93,75.38 301.98,74.33 310.53,74.33 311.17,74.98 311.94,74.98 312.61,75.65 316.01,75.65 317.8,77.44 321.73,77.44 323.86,75.31 327.58,75.31 328.74,76.47 330.14,76.47 330.66,75.95 330.66,71.84 331.31,71.18 331.31,70.47 333.01,68.78 333.01,66.52 334.36,65.17 334.36,64.45 337,61.81 341.43,61.81 341.6,61.64 354.51,61.64 354.89,61.25 358.57,61.25 362.07,57.75 362.07,50.51 363.75,48.83 v1(363.75,48.53)
  BOTTOM w0.14: R21705.1 363.47,48.85 363.75,48.57 v1(363.75,48.53)
USB_CLT1: length 228.3
  TOP w0.14: v1(193.67,68.5) 193.67,68.15 192.71,67.2 192.71,66.22 192.53,66.03 192.53,65.57 192.22,65.26 191.66,65.26 190.24,63.85 190.24,60.67 189.25,59.68 189.25,58.95 189.58,58.62 191.01,58.62 191.41,59.02 193.06,59.02 193.28,58.8 U49.79 ; U13128.6 363.37,49.52 363.8,49.09 363.89,49.09 364.37,48.61 v1(364.37,48.21)
  IN3 w0.079: v1(364.37,48.21) 364.37,48.44 362.23,50.58 362.23,57.81 358.63,61.41 354.96,61.41 354.57,61.79 343.5,61.79 342.71,62.59 336.45,62.59 334.52,64.52 334.52,65.27 333.16,66.62 333.16,68.84 331.47,70.54 331.47,71.26 330.81,71.91 330.81,76.75 329.65,77.91 328.92,77.91 328.06,77.05 328.06,76.01 327.52,75.46 323.93,75.46 321.8,77.6 317.73,77.6 315.94,75.81 312.44,75.81 311.77,75.13 311.05,75.13 310.41,74.49 305.76,74.49 304.92,75.33 303.58,75.33 302.97,75.94 301.75,75.94 300.37,77.31 295.22,77.31 294.76,76.85 291.21,76.85 290.39,77.67 289.46,77.67 288.02,79.11 285.34,79.11 280.63,83.82 278.94,83.82 277.74,85.02 211.19,85.02 206.46,80.29 205.29,80.29 202.25,77.25 202.25,75.47 200.42,73.64 200.42,72.9 198.87,71.34 196.94,71.34 194.09,68.5 v1(193.67,68.5)
USB_OC0#: length 88.4
  TOP w0.102: 303.47,75.78 303.47,74.14 303.45,74.12 303.45,73.79 U13113.AD43
  TOP w0.14: v1(364.76,53.69) 364.37,53.29 U13128.13 ; 303.47,75.78 303.22,76.04 v1(303.22,76.52) 303.22,76.85 302.62,77.45 302.17,77.45 301.93,77.7 301.61,77.7 301.45,77.86 301.45,80.07 R21077.1
  IN1 w0.089: v1(364.76,53.69) 362.76,55.69 362.76,62.55 359.13,66.18 354.02,66.18 353.34,66.86 348.55,66.86 347.92,67.5 342.02,67.5 341.23,68.29 339.59,68.29 338.65,67.35 338.14,67.35 337.81,67.68 337.81,69 337.31,69.5 334.49,69.5 334.23,69.24 333.58,69.24 333.31,69.5 332.7,69.5 331.61,70.6 331.61,70.66 331.01,71.26 329.94,71.26 329.73,71.05 329.01,71.05 328.43,71.63 328.43,72.22 325.51,75.14 320.95,75.14 320.58,74.77 316.87,74.77 315.35,76.29 308.25,76.29 308.1,76.45 306.34,76.45 305.63,75.73 304.01,75.73 v1(303.22,76.52)
  BOTTOM w0.14: v1(303.22,76.52) 303.17,76.47 C96247.1
USB_OC1#: length 328.1
  TOP w0.102: 302.86,74.32 302.86,73.1 U13113.AD42
  TOP w0.14: U13121.3 20.76,62.77 21.91,61.61 v1(23.64,61.61) ; 302.86,74.32 303.04,74.5 303.04,75.12 v2(302.61,75.56) 301.78,76.38 301.42,76.38 300.3,77.5 300.3,77.67 299.84,78.13 R67212.2
  IN1 w0.089: v2(302.61,75.56) 302.2,75.96 300.96,75.96 300.65,75.66 v1(299.03,75.66)
  IN3 w0.079: v1(23.64,61.61) 23.87,61.84 24.18,61.84 25.06,60.95 28.8,60.95 29.71,61.87 37.76,61.87 40.99,58.64 46.91,58.64 48.56,56.99 51.85,56.99 52.21,57.35 56.32,57.35 56.94,56.72 59.79,56.72 61.49,55.03 61.99,55.03 64.18,52.84 64.38,52.84 65.87,51.35 68.26,51.35 69.86,49.75 73.48,49.75 74.21,49.01 88.92,49.01 92.81,52.9 92.81,52.9 92.82,52.9 100.83,52.9 103.14,55.22 117.41,55.22 118.15,54.48 133.91,54.48 134.79,55.36 140.45,55.36 141.48,54.34 146.53,54.34 147.04,54.85 148.22,56.04 160.33,56.04 162.1,54.27 164.55,54.27 166.37,56.09 166.37,60.11 169.68,63.42 170.63,63.42 173.06,65.85 176.14,65.85 176.42,66.13 178.83,66.13 179.73,67.04 182.5,67.04 183.22,67.76 192.13,67.76 193.74,66.14 194.09,66.14 198.03,70.08 200.48,70.08 203.34,72.94 203.34,76.58 205.1,78.34 206.61,78.34 212.2,83.93 276.48,83.93 283.28,77.13 283.28,76.35 284.38,75.25 292.82,75.25 293.14,75.58 296.41,75.58 296.97,76.14 298.55,76.14 v1(299.03,75.66)
  BOTTOM w0.14: R21078.1 297.94,76.75 v1(299.03,75.66) 298.78,75.41 C96248.1
USB_OC2#: length 329.9
  TOP w0.14: v2(302.48,71.51) 302.71,71.74 U13113.AD39 ; v1(27.07,83.1) 27.51,83.54 U13125.3 27.51,84.86 v1(27.78,85.13) ; R21079.1 299.46,80.02 299.11,79.67 299.11,79.19 299.58,78.73 300,78.73 300.17,78.55 300.17,78.38 300.42,78.13 C96033.1 300.6,77.64 301.58,76.66 301.94,76.66 302.08,76.52 v1(302.33,76.52)
  IN1 w0.089: v1(283.47,78.73) 284.98,77.21 286.68,77.21 286.86,77.03 301.82,77.03 v1(302.33,76.52)
  IN2 w0.089: v1(55.7,71.8) 57.4,70.1 59.62,70.1 62.4,67.32 65.32,67.32 66.55,66.09 66.55,62.7 67.91,61.34 67.91,60.28 69.89,58.3 71.77,58.3 73.37,56.7 73.37,53.29 73.86,52.79 80.91,52.79 83.05,54.93 89.86,54.93 98.49,63.56 102.21,63.56 104.9,60.88 114.4,60.88 v1(115.46,61.94)
  IN4 w0.089: v1(115.46,61.94) 115.97,62.45 121.81,62.45 121.99,62.27 134.26,62.27 134.75,61.79 155.18,61.79 156.1,62.7 163.72,62.7 164.74,63.72 164.74,65.12 165.07,65.45 165.45,65.45 168.55,68.55 171.22,68.55 177.11,74.43 181.28,74.43 181.82,74.97 188.06,74.97 189.02,75.94 189.89,75.94 190.88,76.93 193.64,76.93 195.55,78.83 202.04,78.83 208.74,85.54 274.58,85.54 281.39,78.73 v1(283.47,78.73) ; v1(27.78,85.13) 28.52,85.87 31.95,85.87 39.54,78.27 42.51,78.27 45.64,75.15 52.34,75.15 v1(55.7,71.8)
  BOTTOM w0.14: v2(302.48,71.51) 302.92,71.95 302.92,72.96 302.64,73.24 301.91,73.24 301.39,73.76 301.39,74.44 302.15,75.2 302.15,76.34 v1(302.33,76.52)
USB_OC3#: length 8.5
  TOP w0.102: 302.18,74.33 302.6,73.9 U13113.AC44
  TOP w0.14: 302.18,74.33 302.18,75.07 302.13,75.12 302.13,75.68 301.71,76.1 301.3,76.1 300.02,77.39 300.02,77.56 299.71,77.87 299.65,77.87 299.39,78.13 R67212.1 299.13,78.56 299.13,78.78 298.83,79.08 298.83,79.6 298.67,79.76 R21080.1
USB_OC4#: length 6.1
  TOP w0.102: 300.5,75.15 300.5,74.9 300.68,74.72 300.68,74.2 300.6,74.06 300.6,73.7 U13113.Y43
  TOP w0.14: 300.5,75.15 300.01,75.64 299.66,75.64 298.97,76.33 298.76,76.33 297.58,77.51 R21081.1
