# Allegro board DAZGLMB1ED0 dazglmb1ed0-d-ver a-165 (.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_DQ44: length 51.2
  TOP w0.14: CN2062.195 227.69,73.68 v1(227.17,73.17) ; U41.W11 237.87,110.92 v1(237.54,111.25)
  IN2 w0.089: v1(227.17,73.17) 227.17,75.4 226.67,75.9 226.67,78.09 226.76,78.18 227.19,78.18 227.28,78.27 227.28,78.45 227.19,78.53 226.76,78.53 226.67,78.62 226.67,78.8 226.76,78.89 227.19,78.89 227.28,78.98 227.28,79.16 227.19,79.25 226.76,79.25 226.67,79.33 226.67,79.51 226.76,79.6 227.19,79.6 227.28,79.69 227.28,79.87 227.19,79.96 226.76,79.96 226.67,80.05 226.67,80.22 226.76,80.31 227.19,80.31 227.28,80.4 227.28,80.58 227.19,80.67 226.76,80.67 226.67,80.76 226.67,80.93 226.76,81.02 227.19,81.02 227.28,81.11 227.28,81.29 227.19,81.38 226.76,81.38 226.67,81.47 226.67,81.65 226.76,81.73 227.19,81.73 227.28,81.82 227.28,87.55 234.92,95.19 234.92,98.75 235.26,99.09 235.26,100.56 237.21,102.51 237.21,104.31 237.35,104.45 237.35,107.56 237.65,107.86 237.77,107.86 238.29,108.38 238.29,110.13 237.99,110.43 237.99,110.81 237.82,110.99 237.79,110.99 v1(237.54,111.25)
M_B_DQ45: length 51.9
  TOP w0.14: U41.W10 237.95,110.27 237.62,110.6 v1(237.52,110.6) ; CN2062.191 228.69,73.18 v1(227.17,71.67)
  IN2 w0.089: v1(227.17,71.67) 226.78,72.06 226.78,75.38 226.37,75.79 226.37,82.1 226.46,82.18 226.9,82.18 226.99,82.27 226.99,82.45 226.9,82.54 226.46,82.54 226.37,82.63 226.37,82.81 226.46,82.9 226.9,82.9 226.99,82.98 226.99,83.16 226.9,83.25 226.46,83.25 226.37,83.34 226.37,83.52 226.46,83.61 226.9,83.61 226.99,83.7 226.99,83.87 226.9,83.96 226.59,83.96 226.5,84.05 226.5,84.23 226.59,84.32 226.9,84.32 226.99,84.41 226.99,88.02 234.61,95.65 234.61,98.87 234.96,99.22 234.96,100.57 237.04,102.65 237.04,104.52 237.18,104.66 237.18,107.63 237.58,108.03 237.7,108.03 238.12,108.45 238.12,110.02 237.79,110.35 237.77,110.35 v1(237.52,110.6)
M_B_DQ46: length 51.9
  TOP w0.14: U41.V7 236.85,108.32 v1(236.57,108.6) ; v1(223.95,73.12) 224.69,73.86 CN2062.207
  IN2 w0.079: 234.95,106.57 234.95,107.42 236.13,108.6 v1(236.57,108.6)
  IN2 w0.089: 234.95,106.57 234.92,106.55 234.92,103.4 234.5,102.98 234.5,101.95 232.39,99.84 232.39,96.85 224.14,88.61 224.14,81.16 224.06,81.07 223.86,81.07 223.77,80.98 223.77,80.8 223.86,80.71 224.06,80.71 224.14,80.63 224.14,80.45 224.06,80.36 223.61,80.36 223.52,80.27 223.52,80.09 223.61,80 224.06,80 224.14,79.91 224.14,79.74 224.06,79.65 223.61,79.65 223.52,79.56 223.52,79.38 223.61,79.29 224.06,79.29 224.14,79.2 224.14,79.02 224.06,78.94 223.61,78.94 223.52,78.85 223.52,78.67 223.61,78.58 224.06,78.58 224.14,78.49 224.14,78.31 224.06,78.22 223.61,78.22 223.52,78.14 223.52,77.96 223.61,77.87 224.06,77.87 224.14,77.78 224.14,77.49 224.05,77.39 223.67,77.39 223.53,77.25 223.53,75.77 223.62,75.68 224.06,75.68 224.15,75.59 224.15,75.42 224.06,75.33 223.62,75.33 223.53,75.24 223.53,75.06 223.62,74.97 224.06,74.97 224.15,74.88 224.15,74.71 224.06,74.62 223.62,74.62 223.53,74.53 223.53,74.35 223.62,74.26 224.06,74.26 224.15,74.17 224.15,73.99 224.06,73.91 223.62,73.91 223.53,73.82 223.53,73.52 223.94,73.12 v1(223.95,73.12)
M_B_DQ47: length 52
  TOP w0.14: v1(236.57,109.25) 236.85,108.97 U41.V8 ; CN2062.203 225.69,73.43 v1(223.92,71.67)
  IN2 w0.079: 234.75,106.6 234.75,106.63 234.79,106.67 234.79,107.48 236.29,108.98 236.31,108.98 v1(236.57,109.25)
  IN2 w0.089: 234.75,106.6 234.75,103.47 234.25,102.96 234.25,102.11 232.08,99.95 232.08,96.98 223.85,88.75 223.85,84.42 223.76,84.33 223.44,84.33 223.35,84.24 223.35,84.07 223.44,83.98 223.76,83.98 223.85,83.89 223.85,83.71 223.76,83.62 223.31,83.62 223.22,83.53 223.22,83.36 223.31,83.27 223.76,83.27 223.85,83.18 223.85,83 223.76,82.91 223.31,82.91 223.22,82.82 223.22,82.64 223.31,82.56 223.76,82.56 223.85,82.47 223.85,82.29 223.76,82.2 223.31,82.2 223.22,82.11 223.22,81.93 223.31,81.84 223.76,81.84 223.85,81.76 223.85,81.58 223.76,81.49 223.31,81.49 223.22,81.4 223.22,72.37 v1(223.92,71.67)
M_B_DQ48: length 54.1
  TOP w0.14: v1(218.16,70.98) 218.64,71.47 218.64,72.39 220.18,73.93 CN2062.225 ; U41.R11 234.9,111.25 v1(234.78,111.25)
  IN2 w0.079: 231.69,104.11 231.83,104.26 231.83,107.76 233.08,109 233.08,109.61 233.53,110.06 233.97,110.06 234.33,110.42 234.33,110.81 v1(234.78,111.25)
  IN2 w0.089: 231.69,104.11 231.05,103.48 229.76,103.48 224.77,98.49 224.77,96.35 218.33,89.91 218.33,82.34 217.25,81.27 217.25,71.89 v1(218.16,70.98)
M_B_DQ49: length 54
  TOP w0.14: U41.P11 234.25,110.92 233.95,111.21 v1(233.86,111.21) ; CN2062.228 219.43,67.82 v1(219.6,67.99)
  IN2 w0.089: v1(233.86,111.21) 233.36,110.71 233.36,110.39 232.64,109.67 232.64,109.01 231.45,107.82 231.2,107.82 230.88,107.5 230.88,105.04 230.53,104.69 230.14,104.69 223.38,97.93 223.38,96.34 217.75,90.71 217.75,82.58 216.64,81.48 216.64,71.53 219.02,69.16 219.02,68.57 v1(219.6,67.99)
M_B_DQ50: length 54
  TOP w0.14: v1(233.86,108.55) 234.09,108.32 U41.P7 ; CN2062.216 222.43,67.7 v1(222.14,67.99)
  IN2 w0.079: v1(233.86,108.55) 233.58,108.27 233.12,107.82 232.81,107.82 232.46,107.47 232.46,103.72 232.35,103.6
  IN2 w0.089: v1(222.14,67.99) 221.69,67.99 220.33,69.35 220.33,84.52 220.42,84.61 220.93,84.61 221.02,84.7 221.02,84.99 220.93,85.08 220.33,85.08 220.24,85.17 220.24,85.35 220.33,85.44 220.93,85.44 221.02,85.53 221.02,85.7 220.93,85.79 220.33,85.79 220.24,85.88 220.24,86.06 220.33,86.15 220.93,86.15 221.02,86.24 221.02,86.42 220.93,86.5 220.33,86.5 220.24,86.59 220.24,86.77 220.33,86.86 220.93,86.86 221.02,86.95 221.02,89.28 226.93,95.2 226.93,96.42 227.4,96.89 227.82,96.89 229.78,98.85 229.78,100.78 231.71,102.71 231.71,102.96 232.35,103.6
M_B_DQ51: length 54.1
  TOP w0.14: CN2062.215 222.69,73.1 v1(222.14,72.56) ; U41.R8 235.64,109.37 v1(235.64,109.93)
  IN2 w0.079: 234.25,106.54 234.25,106.93 234.32,107 234.32,107.69 235.35,108.72 235.35,109.64 v1(235.64,109.93)
  IN2 w0.089: 234.25,106.54 234.25,104.43 233.99,104.17 233.7,104.17 233.49,103.96 233.49,102.8 232.56,101.87 232.16,101.87 230.67,100.38 230.67,97.47 228,94.8 227.77,94.8 221.89,88.92 221.89,78.81 221.8,78.72 221.32,78.72 221.24,78.63 221.24,78.45 221.32,78.36 221.8,78.36 221.89,78.28 221.89,78.1 221.8,78.01 221.32,78.01 221.24,77.92 221.24,77.74 221.32,77.65 221.8,77.65 221.89,77.56 221.89,77.27 221.8,77.18 221.34,77.18 221.25,77.09 221.25,76.18 221.34,76.09 221.71,76.09 221.8,76 221.8,75.83 221.71,75.74 221.34,75.74 221.25,75.65 221.25,75.47 221.34,75.38 221.71,75.38 221.8,75.29 221.8,75.11 221.71,75.03 221.34,75.03 221.25,74.94 221.25,74.76 221.34,74.67 221.71,74.67 221.8,74.58 221.8,74.4 221.71,74.31 221.34,74.31 221.25,74.23 221.25,74.05 221.34,73.96 221.71,73.96 221.8,73.87 221.8,73.69 221.71,73.6 221.34,73.6 221.25,73.51 221.25,73.12 221.81,72.56 v1(222.14,72.56)
M_B_DQ52: length 54.2
  TOP w0.14: v1(234.77,110.6) 234.9,110.6 U41.R10 ; v1(218.18,72.36) 218.18,72.48 219.18,73.48 CN2062.229
  IN2 w0.079: v1(234.77,110.6) 234.74,110.6 234.04,109.9 233.6,109.9 233.28,109.58 233.28,108.98 231.99,107.69 231.99,104.17 231.84,104.01
  IN2 w0.089: 231.84,104.01 230.92,103.09 229.8,103.09 225.06,98.35 225.06,96.21 218.62,89.78 218.62,81.62 218.53,81.53 217.93,81.53 217.84,81.44 217.84,81.26 217.93,81.18 218.53,81.18 218.62,81.09 218.62,80.91 218.53,80.82 217.93,80.82 217.84,80.73 217.84,80.55 217.93,80.46 218.53,80.46 218.62,80.38 218.62,80.2 218.53,80.11 217.93,80.11 217.84,80.02 217.84,79.84 217.93,79.75 218.53,79.75 218.62,79.66 218.62,79.49 218.53,79.4 217.93,79.4 217.84,79.31 217.84,72.69 v1(218.18,72.36)
M_B_DQ53: length 54.1
  TOP w0.14: CN2062.224 220.43,68.6 v1(219.63,69.41) ; U41.P10 234.12,110.27 v1(233.82,110.56)
  IN2 w0.079: 231.31,104.28 231.47,104.28 231.68,104.49 231.68,107.82 232.82,108.97 232.82,109.58 233.81,110.56 v1(233.82,110.56)
  IN2 w0.089: v1(219.63,69.41) 219.18,69.41 216.95,71.64 216.95,81.37 218.04,82.46 218.04,90.04 224.47,96.47 224.47,98.61 230.15,104.28 231.31,104.28
M_B_DQ54: length 54.2
  TOP w0.14: v1(234.72,108.65) 235.05,108.32 U41.R7 ; CN2062.211 223.69,73.88 223.07,73.27 223.07,72.14 v1(222.14,71.21)
  IN2 w0.079: 233.33,104.07 233.44,104.18 233.44,107.09 233.44,107.09 233.44,107.54 233.71,107.82 233.99,107.82 234.56,108.38 234.56,108.49 v1(234.72,108.65)
  IN2 w0.089: 233.33,104.07 233.23,103.98 233.23,102.95 232.51,102.23 232.05,102.23 230.37,100.54 230.37,97.61 227.87,95.11 227.67,95.11 221.6,89.04 221.6,82.29 221.51,82.21 221.01,82.21 220.92,82.12 220.92,81.94 221.01,81.85 221.51,81.85 221.6,81.76 221.6,81.58 221.51,81.49 221.01,81.49 220.92,81.41 220.92,81.23 221.01,81.14 221.51,81.14 221.6,81.05 221.6,80.87 221.51,80.78 221.01,80.78 220.92,80.69 220.92,80.52 221.01,80.43 221.51,80.43 221.6,80.34 221.6,80.16 221.51,80.07 221.01,80.07 220.92,79.98 220.92,79.81 221.01,79.72 221.51,79.72 221.6,79.63 221.6,79.34 221.51,79.25 221.03,79.25 220.94,79.16 220.94,72.01 221.74,71.21 v1(222.14,71.21)
M_B_DQ55: length 53.7
  TOP w0.14: v1(234.78,109.3) 234.57,109.3 234.32,109.05 U41.P8 ; CN2062.212 223.43,67.5 223.08,67.86 223.08,68.37 v1(222.14,69.31)
  IN2 w0.079: v1(234.78,109.3) 234.7,109.3 234.32,108.93 234.32,108.38 234.02,108.07 233.74,108.07 233.28,107.61 233.28,107.04 233.28,107.04 233.28,104.29 233.12,104.13
  IN2 w0.089: v1(222.14,69.31) 221.76,69.31 220.63,70.44 220.63,82.56 220.72,82.65 221.22,82.65 221.31,82.74 221.31,82.92 221.22,83.01 220.72,83.01 220.63,83.1 220.63,83.28 220.72,83.36 221.22,83.36 221.31,83.45 221.31,83.63 221.22,83.72 220.72,83.72 220.63,83.81 220.63,83.99 220.72,84.08 221.22,84.08 221.31,84.16 221.31,89.16 227.22,95.08 227.22,95.56 227.55,95.88 228.02,95.88 230.07,97.94 230.07,100.66 231.87,102.46 231.87,102.89 233.12,104.13
M_B_DQ56: length 58.5
  TOP w0.14: U41.L11 231.5,110.92 v1(231.16,111.25) ; CN2062.246 214.94,68.11 v1(213.61,69.43)
  IN2 w0.089: v1(213.61,69.43) 212.87,69.43 212.58,69.73 212.58,92.48 215.36,95.27 215.36,95.39 214.66,96.1 214.66,96.23 219.77,101.34 220.05,101.34 225.74,107.02 225.74,110.88 226.18,111.32 228.77,111.32 229.31,110.79 230.7,110.79 v1(231.16,111.25)
M_B_DQ57: length 58.6
  TOP w0.14: CN2062.250 213.94,67.74 v1(213.61,68.06) ; U41.M11 232.39,110.92 v1(232.03,111.28)
  IN2 w0.089: v1(232.03,111.28) 231.76,111.28 231.39,111.65 230.94,111.65 230.36,111.07 229.3,111.07 228.75,111.61 226.05,111.61 225.39,110.95 225.39,107.39 214.36,96.37 214.36,94.68 212.27,92.58 212.27,69.4 v1(213.61,68.06)
M_B_DQ58: length 58.4
  TOP w0.102: v1(230.35,108.11) 230.45,108.01 230.94,108.01 231.18,108.25 231.58,108.25 U41.L7
  TOP w0.14: v1(216.2,71.59) 218.18,73.58 CN2062.233
  IN2 w0.079: 228.96,105.44 229.21,105.69 229.21,106.89 230.07,107.75 230.07,107.83 v1(230.35,108.11)
  IN2 w0.089: v1(216.2,71.59) 215.55,72.24 215.55,85.96 215.64,86.05 216.59,86.05 216.73,86.18 216.73,86.35 216.64,86.44 215.64,86.44 215.55,86.53 215.55,86.7 215.64,86.79 216.64,86.79 216.73,86.88 216.73,87.06 216.64,87.15 215.64,87.15 215.55,87.24 215.55,87.42 215.64,87.5 216.64,87.5 216.73,87.59 216.73,87.77 216.64,87.86 215.64,87.86 215.55,87.95 215.55,88.13 215.64,88.22 216.64,88.22 216.73,88.3 216.73,88.48 216.64,88.57 215.64,88.57 215.55,88.66 215.55,88.84 215.64,88.93 216.64,88.93 216.73,89.02 216.73,89.18 216.64,89.27 216.39,89.27 216.3,89.36 216.3,89.54 216.39,89.63 216.64,89.63 216.73,89.71 216.73,91.13 221.7,96.11 221.7,98.47 226.86,103.63 227.12,103.63 228.93,105.44 228.96,105.44
M_B_DQ59: length 58.5
  TOP w0.14: CN2062.237 217.18,73.93 v1(216.2,72.94) ; v1(232.93,110.58) 232.93,109.4 U41.M8
  IN2 w0.089: v1(232.93,110.58) 232.65,110.3 232.47,110.12 232.47,109.08 231.38,107.99 231.13,107.99 230.84,107.71 230.25,107.71 230.02,107.48 230.02,105.59 222.66,98.23 222.66,96.64 217.02,91.01 217.02,85.84 216.93,85.75 215.93,85.75 215.84,85.67 215.84,85.49 215.93,85.4 216.93,85.4 217.02,85.31 217.02,85.13 216.93,85.04 215.93,85.04 215.84,84.95 215.84,84.78 215.93,84.69 216.93,84.69 217.02,84.6 217.02,84.42 216.93,84.33 215.93,84.33 215.84,84.24 215.84,84.07 215.93,83.98 216.93,83.98 217.02,83.89 217.02,83.71 216.93,83.62 215.93,83.62 215.84,83.53 215.84,83.35 215.93,83.27 216.93,83.27 217.02,83.18 217.02,82.88 216.91,82.77 216.05,82.77 215.84,82.57 215.84,73.3 v1(216.2,72.94)
M_B_DQ60: length 58.3
  TOP w0.14: v1(231.15,110.56) 231.45,110.27 U41.L10 ; v1(213.61,71.87) 213.63,71.87 215.18,73.42 CN2062.245
  IN2 w0.089: v1(213.61,71.87) 212.88,72.6 212.88,92.37 215.87,95.36 215.87,95.48 215.2,96.16 215.2,96.29 215.32,96.41 215.45,96.41 216.12,95.74 216.25,95.74 216.37,95.86 216.37,95.99 215.7,96.66 215.7,96.79 215.83,96.91 215.95,96.91 216.63,96.24 216.75,96.24 216.88,96.37 216.88,96.49 216.2,97.17 216.2,97.29 216.41,97.5 216.54,97.5 216.66,97.37 216.81,97.37 216.91,97.48 216.91,97.62 216.79,97.75 216.79,97.88 219.96,101.05 220.17,101.05 226.03,106.9 226.03,109.33 226.9,110.2 228.92,110.2 229.29,110.56 v1(231.15,110.56)
M_B_DQ61: length 58.3
  TOP w0.14: v1(213.61,73.24) 213.63,73.24 214.18,73.8 CN2062.249 ; v1(232.02,110.63) 232.38,110.27 U41.M10
  IN2 w0.089: v1(232.02,110.63) 231.98,110.63 231.45,110.1 230.94,110.1 230.69,110.36 229.41,110.36 228.96,109.91 227.02,109.91 226.32,109.21 226.32,106.78 220.29,100.75 220.15,100.75 218.97,99.57 218.97,99.31 219.51,98.77 219.51,98.58 219.3,98.37 219.17,98.37 218.5,99.05 218.37,99.05 218.25,98.92 218.25,98.8 218.92,98.12 218.92,97.99 218.8,97.87 218.67,97.87 217.99,98.54 217.87,98.54 217.74,98.42 217.74,98.29 218.42,97.62 218.42,97.49 218.29,97.37 218.17,97.37 217.49,98.04 217.37,98.04 217.24,97.92 217.24,97.79 217.92,97.11 217.92,96.99 217.79,96.86 217.66,96.86 217.31,97.22 217.16,97.22 217.06,97.11 217.06,96.97 217.41,96.61 217.41,96.49 213.19,92.26 213.19,73.67 v1(213.61,73.24)
M_B_DQ62: length 58.5
  TOP w0.14: v1(218.21,69.28) 217.43,68.51 CN2062.236 ; U41.M7 231.98,108.83 v1(231.98,109.31)
  IN2 w0.079: 228.77,105.68 229.05,105.96 229.05,107.04 229.94,107.93 229.94,108.26 230.21,108.53 230.62,108.53 230.89,108.25 231.35,108.25 231.98,108.88 v1(231.98,109.31)
  IN2 w0.089: v1(218.21,69.28) 217.87,69.28 215.26,71.89 215.26,89.22 215.35,89.31 215.79,89.31 215.88,89.4 215.88,89.57 215.79,89.66 215.35,89.66 215.26,89.75 215.26,89.93 215.35,90.02 216.35,90.02 216.44,90.11 216.44,90.29 216.35,90.37 215.35,90.37 215.26,90.46 215.26,90.64 215.35,90.73 216.35,90.73 216.44,90.82 216.44,91 216.35,91.09 216.06,91.09 215.97,91.18 215.97,91.35 216.06,91.44 216.63,91.44 221.41,96.23 221.41,98.59 226.83,104.01 227.09,104.01 228.76,105.68 228.77,105.68
M_B_DQ63: length 58.5
  TOP w0.14: v1(218.21,67.89) 218.43,67.66 CN2062.232 ; U41.L8 231.49,108.97 v1(231.19,108.66)
  IN2 w0.079: v1(231.19,108.66) 231.17,108.68 230.14,108.68 229.64,108.18 229.64,107.85 228.89,107.11 228.89,106.23 228.56,105.89
  IN2 w0.089: v1(218.21,67.89) 218.68,67.89 218.97,67.6 218.97,67.02 218.84,66.89 217.12,66.89 216.97,67.04 216.97,67.33 217.06,67.42 217.36,67.42 217.44,67.51 217.44,67.69 217.36,67.78 217.06,67.78 216.97,67.87 216.97,68.05 217.06,68.13 217.54,68.13 217.63,68.22 217.63,68.4 217.54,68.49 217.06,68.49 216.97,68.58 216.97,68.76 217.06,68.85 217.54,68.85 217.63,68.93 217.63,69.11 217.54,69.2 217.06,69.2 216.97,69.29 216.97,69.77 214.97,71.77 214.97,90.76 221.12,96.92 221.12,98.88 226.67,104.43 227.1,104.43 228.56,105.89
M_B_DQSN0: length 50.9
  TOP w0.14: v1(264.91,110.46) 264.91,110.39 U41.BP9 ; v1(274.29,71.24) 274.48,71.43 275.2,71.43 275.58,71.81 275.58,73.6 275.68,73.7 CN2062.11
  IN2 w0.089: v1(274.29,71.24) 274.29,71.62 274.17,71.74 273.8,71.74 273.51,72.03 273.51,74.31 273.66,74.46 273.66,75.44 273.51,75.59 273.51,79.47 273.23,79.75 273.23,97.41 272.82,97.82 272.82,98.51 273.23,98.92 273.23,99.5 272.56,100.17 272.56,102.32 271.8,103.08 271.8,104.16 270.57,105.39 270.57,106.75 268.99,108.33 268.99,108.67 268.56,109.1 268.56,109.38 267.66,110.29 267.12,110.29 266.91,110.49 266.43,110.49 265.82,109.88 265.36,109.88 265.21,110.03 265.21,110.17 v1(264.91,110.46)
M_B_DQSN1: length 49.4
  TOP w0.14: v1(269.13,70.07) 269.13,69.43 269.27,69.29 269.91,69.29 270.34,68.86 270.34,67.62 270.44,67.52 270.44,66.58 CN2062.32 ; v1(262.25,109.74) 262.57,110.07 U41.BL9
  IN2 w0.089: v1(269.13,70.07) 269.13,69.56 269.01,69.43 268.93,69.43 268.28,70.08 268.28,71.25 268.6,71.57 268.6,74.06 268.16,74.49 268.16,75.58 268.6,76.01 268.6,77.4 268.31,77.69 268.31,98.21 267.36,99.15 267.36,101.87 266.54,102.68 266.54,103.13 265.5,104.18 265.5,105 264.64,105.86 264.64,106.36 263.25,107.74 263.25,108.73 v1(262.25,109.74)
M_B_DQSN2: length 48.8
  TOP w0.14: U41.BG9 259.69,109.62 v1(259.46,109.85) ; v1(263.9,71.47) 263.9,71.8 264.21,72.1 264.76,72.1 265.08,72.42 265.08,73.71 265.19,73.82 CN2062.53
  IN2 w0.089: v1(263.9,71.47) 263.65,71.72 263.65,72.05 263.12,72.57 263.12,73.73 263.34,73.94 263.56,73.94 263.65,74.03 263.65,74.58 263.56,74.66 263.34,74.66 263.15,74.85 263.15,75.54 263.34,75.72 263.56,75.72 263.65,75.81 263.65,81.78 263.56,81.87 263.29,81.87 263.1,82.06 263.1,82.74 263.29,82.93 263.56,82.93 263.65,83.02 263.65,83.56 263.56,83.65 263.29,83.65 263.1,83.84 263.1,84.52 263.29,84.71 263.56,84.71 263.65,84.8 263.65,85.35 263.56,85.43 263.29,85.43 263.1,85.62 263.1,86.12 263.56,86.58 263.56,87.09 263.1,87.55 263.1,99.31 261.73,100.68 261.73,100.9 261.45,101.18 261.45,102.97 260.86,103.55 260.86,104.03 259.55,105.34 259.55,107.94 259.9,108.29 259.9,109.73 259.79,109.85 v1(259.46,109.85)
M_B_DQSN3: length 49.6
  TOP w0.14: v1(258.89,70.08) 258.9,70.07 258.9,69.68 259.23,69.35 259.75,69.35 260.12,68.98 260.12,68.11 259.82,67.82 259.82,67.65 259.93,67.54 CN2062.74 ; U41.BC9 257.11,109.62 v1(256.72,110.01)
  IN2 w0.079: v1(256.72,110.01) 256.83,110.01 257.3,109.54 257.3,109.52
  IN2 w0.089: v1(258.89,70.08) 258.89,69.61 258.72,69.43 258.59,69.43 258.1,69.92 258.1,70.83 258.31,71.04 258.31,78.84 259.06,79.59 259.06,85.01 258.65,85.42 258.65,98.29 258.12,98.81 258.12,101.45 256.69,102.88 256.34,102.88 256.03,103.19 256.03,107.48 256.28,107.72 256.68,107.72 257.3,108.34 257.3,109.52
M_B_DQSN4: length 51.5
  TOP w0.14: CN2062.177 232.18,73.7 232.08,73.6 232.08,73.25 231.77,72.94 231.77,71.85 231.05,71.12 230.66,71.12 v1(230.42,70.88) ; v1(240.28,109.97) 240.28,109.96 240.62,109.62 U41.AC9
  IN2 w0.089: v1(230.42,70.88) 230.45,70.88 230.68,71.11 231.16,71.11 231.5,71.45 231.5,72.37 231.1,72.77 231.1,73.51 230.77,73.84 230.03,73.84 229.81,74.05 229.81,74.57 230,74.76 230.14,74.76 230.32,74.95 230.32,75.63 230.14,75.82 230,75.82 229.92,75.91 229.92,76.36 230.09,76.54 230.09,77 229.92,77.18 229.92,85.74 237.45,93.27 237.45,101.06 238.85,102.47 238.97,102.47 239.63,103.13 239.63,108.12 239.9,108.39 239.9,109.59 v1(240.28,109.97)
M_B_DQSN5: length 51.8
  TOP w0.14: U41.W9 237.85,109.62 v1(237.52,109.95) ; v1(225.3,70.5) 225.3,70.35 226.33,69.31 226.33,68.55 226.83,68.05 226.83,67.73 226.94,67.62 CN2062.198
  IN2 w0.079: 235.9,105.89 235.9,106.38 235.95,106.44 235.95,107.58 236.27,107.89 236.67,107.89 237.13,108.35 237.13,109.56 v1(237.52,109.95)
  IN2 w0.089: 235.9,105.89 235.9,105.81 236.44,105.26 236.44,105.01 235.53,104.09 235.53,102 233.8,100.28 233.8,99.99 233.28,99.47 233.28,96.4 225.04,88.15 225.04,72.68 224.71,72.36 224.71,71.38 224.6,71.27 224.6,70.37 224.83,70.14 224.93,70.14 v1(225.3,70.5)
M_B_DQSN6: length 54
  TOP w0.14: v1(234.79,109.95) 234.9,109.95 U41.R9 ; CN2062.219 221.69,73.7 221.58,73.6 221.58,73.19 220.87,72.48 220.87,71.54 220.29,70.96 219.83,70.96 v1(219.6,70.73)
  IN2 w0.079: v1(234.79,109.95) 234.77,109.97 234.34,109.97 234.1,109.74 233.67,109.74 233.45,109.52 233.45,108.92 232.15,107.63 232.15,104.04 231.96,103.85
  IN2 w0.089: v1(219.6,70.73) 219.29,71.05 219.12,71.05 218.57,71.6 218.57,78.16 219.35,78.94 219.35,89.15 226.04,95.84 226.04,98.3 227.65,99.91 227.91,99.91 228.17,99.66 228.42,99.66 228.68,99.92 228.68,100.17 228.42,100.42 228.42,100.69 230.09,102.35 230.46,102.35 230.73,102.63 230.82,102.72 231.96,103.85
M_B_DQSN7: length 58.3
  TOP w0.14: v1(232.02,109.98) 232.39,109.62 U41.M9 ; v1(216.21,67.94) 216.43,67.71 CN2062.240
  IN2 w0.079: v1(232.02,109.98) 231.91,109.87 230.83,109.87 229.67,108.72 228.93,108.72 228.65,108.44 228.65,107.47 228.56,107.38 228.56,106.52 228.4,106.36
  IN2 w0.089: 228.4,106.36 228.22,106.18 227.13,106.18 220.23,99.28 220.23,97.29 219.25,96.3 219.12,96.3 218.89,96.54 218.5,96.54 218.14,96.18 218.14,95.79 218.37,95.56 218.37,95.43 217.99,95.04 217.86,95.04 217.62,95.28 217.23,95.28 216.85,94.9 216.85,94.56 217.11,94.29 217.11,94.17 216.73,93.78 216.6,93.78 216.37,94.01 215.98,94.01 215.62,93.66 215.62,93.26 215.85,93.03 215.85,92.91 215.46,92.52 215.34,92.52 215.11,92.75 214.85,92.75 214.36,92.26 214.36,92 214.59,91.77 214.59,91.64 214.08,91.13 214.08,71.4 214.74,70.74 214.74,68.92 215.06,68.6 215.7,68.6 216.21,68.1 v1(216.21,67.94)
M_B_DQSN8: length 7.5
  TOP w0.14: CN2062.95 254.69,76.72 253.36,78.04 v1(253.26,78.04)
  BOTTOM w0.14: v1(253.26,78.04) 253.46,77.84 253.91,77.84 254.25,77.5 254.25,75.54 R21431.2
M_B_DQSP0: length 50.9
  TOP w0.14: CN2062.13 275.19,73.7 275.29,73.6 275.29,71.93 275.08,71.72 274.54,71.72 274.33,71.94 274.33,72.48 v1(274.3,72.51) ; U41.BR9 265.24,110.13 v1(265.56,110.46)
  IN2 w0.089: v1(265.56,110.46) 265.37,110.27 265.37,110.1 265.42,110.05 265.75,110.05 266.36,110.66 266.98,110.66 267.19,110.46 267.73,110.46 268.73,109.45 268.73,109.16 269.16,108.73 269.16,108.4 270.73,106.82 270.73,105.46 271.97,104.23 271.97,103.15 272.73,102.39 272.73,100.24 273.39,99.57 273.39,98.85 272.98,98.44 272.98,97.89 273.39,97.48 273.39,79.82 273.68,79.54 273.68,75.66 273.83,75.51 273.83,74.39 273.68,74.24 273.68,72.1 273.87,71.91 274.24,71.91 274.4,72.08 274.4,72.41 v1(274.3,72.51)
M_B_DQSP1: length 49.3
  TOP w0.14: v1(269.13,68.8) 269.33,68.99 269.79,68.99 270.05,68.74 270.05,67.6 269.93,67.49 CN2062.34 ; U41.BJ9 261.66,109.62 v1(261.3,109.98)
  IN2 w0.089: v1(269.13,68.8) 269.13,69 268.12,70.01 268.12,71.32 268.43,71.64 268.43,73.99 268,74.42 268,75.65 268.43,76.08 268.43,77.33 268.14,77.62 268.14,98.14 267.19,99.08 267.19,101.8 266.37,102.61 266.37,103.06 265.33,104.11 265.33,104.93 264.47,105.79 264.47,106.29 263.09,107.67 263.09,108.66 262.43,109.32 261.91,109.32 261.59,109.64 261.59,109.69 v1(261.3,109.98)
M_B_DQSP2: length 48.7
  TOP w0.14: CN2062.55 264.69,73.81 264.79,73.7 264.79,72.54 264.64,72.39 264.22,72.39 v1(263.88,72.74) ; U41.BF9 258.98,109.62 258.66,109.93 v1(258.56,109.93)
  IN2 w0.079: 260.07,109.29 260.07,109.8 259.63,110.24 258.88,110.24 v1(258.56,109.93)
  IN2 w0.089: v1(263.88,72.74) 263.63,72.48 263.45,72.48 263.29,72.64 263.29,73.66 263.41,73.77 263.63,73.77 263.82,73.96 263.82,74.65 263.63,74.83 263.41,74.83 263.32,74.92 263.32,75.47 263.41,75.56 263.63,75.56 263.82,75.74 263.82,81.85 263.63,82.04 263.36,82.04 263.27,82.13 263.27,82.67 263.36,82.76 263.63,82.76 263.82,82.95 263.82,83.63 263.63,83.82 263.36,83.82 263.27,83.91 263.27,84.45 263.36,84.54 263.63,84.54 263.82,84.73 263.82,85.42 263.63,85.6 263.36,85.6 263.27,85.69 263.27,86.05 263.73,86.51 263.73,87.16 263.27,87.62 263.27,99.38 261.89,100.75 261.89,100.97 261.61,101.25 261.61,103.04 261.03,103.62 261.03,104.1 259.72,105.41 259.72,107.87 260.07,108.22 260.07,109.29
M_B_DQSP3: length 49.6
  TOP w0.14: CN2062.76 259.43,66.58 259.43,67.54 259.53,67.64 259.53,67.94 259.82,68.24 259.82,68.86 259.63,69.05 259.15,69.05 v1(258.9,68.8) ; U41.BB9 256.18,109.62 v1(255.79,110.01)
  IN2 w0.079: v1(255.79,110.01) 256.05,110.01 256.44,109.61 257,109.61 257.13,109.48 257.13,109.48
  IN2 w0.089: 257.13,109.48 257.13,108.41 256.61,107.89 256.21,107.89 255.86,107.55 255.86,103.12 256.27,102.71 256.63,102.71 257.95,101.38 257.95,98.74 258.48,98.22 258.48,85.35 258.89,84.94 258.89,79.66 258.15,78.91 258.15,71.11 257.94,70.9 257.94,69.85 258.52,69.27 258.73,69.27 258.9,69.1 v1(258.9,68.8)
M_B_DQSP4: length 51.5
  TOP w0.14: v1(230.45,72.16) 230.45,71.52 230.55,71.42 230.92,71.42 231.48,71.97 231.48,73.06 231.79,73.37 231.79,73.6 231.69,73.7 CN2062.179 ; v1(239.34,109.33) 239.51,109.33 U41.AA9
  IN2 w0.089: v1(239.34,109.33) 239.66,109.33 239.73,109.25 239.73,108.46 239.46,108.19 239.46,103.2 238.9,102.63 238.78,102.63 237.28,101.13 237.28,93.34 229.75,85.81 229.75,77.11 229.93,76.93 229.93,76.61 229.75,76.43 229.75,75.84 229.93,75.65 230.07,75.65 230.16,75.56 230.16,75.02 230.07,74.93 229.93,74.93 229.64,74.64 229.64,73.98 229.96,73.67 230.7,73.67 230.93,73.44 230.93,72.7 231.34,72.3 231.34,71.52 231.09,71.28 230.55,71.28 230.45,71.38 v1(230.45,72.16)
M_B_DQSP5: length 51.7
  TOP w0.14: CN2062.200 226.43,67.62 226.54,67.73 226.54,67.93 226.04,68.43 226.04,69.19 225.73,69.5 225.58,69.5 v1(225.29,69.21) ; v1(236.62,109.89) 236.9,109.62 U41.V9
  IN2 w0.079: 235.73,105.89 235.73,105.91 235.73,105.91 235.73,105.93 235.74,105.93 235.74,106.45 235.79,106.5 235.79,107.64 236.2,108.05 236.61,108.05 236.98,108.42 236.98,109.58 236.9,109.65 236.86,109.65 v1(236.62,109.89)
  IN2 w0.089: v1(225.29,69.21) 225.29,69.85 225.17,69.97 224.76,69.97 224.43,70.3 224.43,71.34 224.54,71.45 224.54,72.43 224.87,72.75 224.87,88.22 233.11,96.47 233.11,99.54 233.63,100.06 233.63,100.35 235.36,102.07 235.36,104.16 236.28,105.08 236.28,105.19 235.73,105.74 235.73,105.89
M_B_DQSP6: length 54.1
  TOP w0.14: v1(233.86,109.35) 234.13,109.62 U41.P9 ; CN2062.221 221.18,73.7 221.29,73.6 221.29,73.31 220.58,72.6 220.58,71.66 220.17,71.25 219.73,71.25 219.58,71.4 v1(219.58,72.02)
  IN2 w0.079: v1(233.86,109.35) 233.86,109.43 234.02,109.59 234.26,109.59 234.34,109.51 234.34,109.19 234.1,108.95 233.69,108.95 232.31,107.56 232.31,103.96 232.03,103.69
  IN2 w0.089: v1(219.58,72.02) 219.58,71.34 219.45,71.21 219.19,71.21 218.74,71.67 218.74,78.09 219.51,78.87 219.51,89.08 226.21,95.77 226.21,98.23 227.72,99.74 227.84,99.74 228.1,99.49 228.49,99.49 228.85,99.85 228.85,100.24 228.59,100.49 228.59,100.62 230.16,102.19 230.53,102.19 232.03,103.69
M_B_DQSP7: length 58.5
  TOP w0.14: v1(231.16,109.32) 231.46,109.62 U41.L9 ; v1(216.25,69.23) 216.25,68.67 215.74,68.16 215.74,67.71 215.94,67.51 CN2062.242
  IN2 w0.079: v1(231.16,109.32) 231.16,109.59 231.03,109.71 230.9,109.71 229.74,108.56 228.99,108.56 228.81,108.38 228.81,107.4 228.72,107.31 228.72,106.45 228.57,106.3 228.57,106.29 228.53,106.25 228.53,106.25 228.52,106.24
  IN2 w0.089: v1(216.25,69.23) 216.25,69.22 215.79,68.76 215.13,68.76 214.9,68.99 214.9,70.81 214.24,71.47 214.24,91.06 214.76,91.58 214.76,91.84 214.53,92.07 214.53,92.19 214.92,92.58 215.04,92.58 215.27,92.35 215.53,92.35 216.02,92.84 216.02,93.1 215.78,93.33 215.78,93.59 216.05,93.85 216.3,93.85 216.53,93.61 216.79,93.61 217.28,94.1 217.28,94.36 217.02,94.63 217.02,94.83 217.3,95.11 217.55,95.11 217.79,94.88 218.06,94.88 218.54,95.36 218.54,95.62 218.31,95.86 218.31,96.11 218.57,96.37 218.82,96.37 219.05,96.14 219.32,96.14 220.4,97.22 220.4,99.21 227.2,106.01 228.29,106.01 228.52,106.24
M_B_DQSP8: length 6.2
  TOP w0.14: v1(253.26,77.39) 254.18,76.47 CN2062.97
  BOTTOM w0.14: v1(253.26,77.39) 253.43,77.56 253.79,77.56 253.97,77.39 253.97,75.72 R21427.2
M_B_EVENT#: length 4.2
  TOP w0.14: CN2062.134 244.93,65.17 243.97,64.2 v1(243.68,64.2)
  BOTTOM w0.14: v1(243.68,64.2) 244.11,64.63 R21414.2
M_B_ODT0_CPU: length 48.6
  TOP w0.102: U41.AF7 243.36,108.32 243.01,108.66 v1(242.12,108.66)
  TOP w0.216: CN2062.155 237.69,72.56 236.52,71.39 v1(235.12,71.39)
  IN2 w0.079: v1(242.12,108.66) 241.88,108.42 241.88,108.33 241.73,108.18 241.73,107.73 241.92,107.54 241.92,103.24 241.84,103.16
  IN2 w0.14: v1(235.12,71.39) 235.56,71.83 235.56,74.44 234.34,75.66 234.34,79.51 233.67,80.18 233.67,85.34 240.26,91.93 240.26,101.58 241.84,103.16
M_B_ODT1_CPU: length 48
  TOP w0.216: U41.AE8 242.55,109.04 242.2,109.39 v1(242.09,109.39) ; v1(235.15,72.71) 236.18,73.75 CN2062.161
  IN2 w0.079: 241.68,103.31 241.76,103.39 241.76,107.48 241.56,107.68 241.56,108.23 241.73,108.4 241.73,109.03 v1(242.09,109.39)
  IN2 w0.14: 241.68,103.31 239.8,101.43 239.8,92.12 233.19,85.52 233.19,79.52 233.33,79.38 233.76,79.38 233.9,79.25 233.9,78.97 233.76,78.83 233.33,78.83 233.19,78.69 233.19,78.41 233.33,78.27 233.76,78.27 233.9,78.13 233.9,77.85 233.76,77.71 233.33,77.71 233.19,77.57 233.19,77.29 233.33,77.15 233.76,77.15 233.9,77.01 233.9,76.73 233.76,76.59 233.33,76.59 233.19,76.45 233.19,76.05 233.32,75.92 233.69,75.92 233.9,75.72 233.9,75.47 234.74,74.64 234.74,73.12 v1(235.15,72.71)
M_B_PARITY: length 50.3
  TOP w0.216: U41.AJ7 246.35,108.32 v1(246.67,108.63) ; v1(242.39,77.31) 242.31,77.23 242.31,76.12 242.69,75.74 CN2062.143
  IN2 w0.14: v1(246.67,108.63) 246.67,108.21 246.82,108.06 246.82,103.13 246.53,102.84 246.53,101.54 246.88,101.18 246.88,87.36 246.25,86.73 246.25,86.07 246.88,85.44 246.88,85.2 246.47,84.79 246.27,84.79 245.41,85.65 245.17,85.65 245.01,85.49 245.01,85.26 245.88,84.39 245.88,84.2 245.68,84 245.48,84 244.61,84.86 244.38,84.86 244.22,84.7 244.22,84.47 245.09,83.6 245.09,83.4 244.89,83.21 244.69,83.21 243.82,84.07 243.59,84.07 243.43,83.91 243.43,83.68 244.3,82.81 244.3,82.61 244.1,82.42 243.9,82.42 243.03,83.28 242.8,83.28 242.64,83.12 242.64,82.89 243.51,82.02 243.51,81.82 243.31,81.63 243.11,81.63 242.5,82.24 242.26,82.24 242.1,82.08 242.1,81.84 242.71,81.23 242.71,81.03 242.18,80.5 242.18,77.52 v1(242.39,77.31)
M_B_RAS#: length 52
  TOP w0.216: v1(244.85,109.93) 245.19,110.27 U41.AH10 ; CN2062.152 238.44,67.8 238.04,68.19 238.04,71.26 v1(238.78,72)
  IN2 w0.079: v1(244.85,109.93) 244.44,109.52 244.44,108.23 244.27,108.06 244.27,103.85
  IN2 w0.14: v1(238.78,72) 239.22,72.44 239.22,74.5 238.27,75.45 238.27,77.19 238.65,77.57 238.65,80.51 238.51,80.65 237.9,80.65 237.76,80.79 237.76,81.07 237.9,81.21 238.51,81.21 238.65,81.35 238.65,81.63 238.51,81.77 237.9,81.77 237.76,81.91 237.76,82.19 237.9,82.33 238.51,82.33 238.65,82.47 238.65,82.75 238.51,82.89 237.9,82.89 237.76,83.03 237.76,83.31 237.9,83.45 238.51,83.45 238.65,83.59 238.65,85.67 243.34,90.36 243.34,102.73 244.27,103.65 244.27,103.85
M_B_WE#: length 48
  TOP w0.216: U41.AH11 245.17,110.92 v1(244.85,110.59) ; v1(238.78,73.35) 238.69,73.44 CN2062.151
  IN2 w0.079: v1(244.85,110.59) 244.39,110.14 244.39,109.83 243.44,108.88 243.44,103.16
  IN2 w0.14: 243.44,103.16 242.89,102.61 242.89,90.88 237.11,85.1 237.11,80.25 237.29,80.07 238.06,80.07 238.2,79.93 238.2,79.65 238.06,79.51 237.25,79.51 237.11,79.37 237.11,79.09 237.25,78.95 238.06,78.95 238.2,78.81 238.2,78.53 238.06,78.39 237.22,78.39 237.11,78.28 237.11,78 237.28,77.84 237.74,77.84 237.88,77.7 237.88,77.42 237.74,77.28 237.66,77.28 237.52,77.14 237.52,76.86 237.82,76.55 237.82,76.3 237.68,76.16 237.53,76.16 237.39,76.02 237.39,75.7 238.78,74.31 v1(238.78,73.35)
MAIND: length 214.8
  TOP w0.14: v1(200.96,67.4) 201.54,67.99 PQ40.2
  TOP w0.254: PQ9056.4 218.79,142 219.12,141.67 v1(219.12,141.42) ; PR59.2 111.53,66.13 111.65,66.25 PC51.1 112.42,66.51 113.04,66.51 113.68,65.88 PQ6.3 115.21,65.88 115.79,65.29 115.79,64.15 116.1,63.85 PQ9.2 118.79,63.24 118.49,62.93 117.22,62.93 114.92,60.63 114.92,55.53 116.23,54.22 v1(116.23,53.18)
  IN3 w0.254: v1(219.12,141.42) 219.12,140.22 218.36,139.46 215.39,139.46 211.48,135.55 211.48,112.87 203.98,105.38 203.98,102.53 199.44,97.99 199.44,94.96 197.17,92.7 v1(197.17,92.42) ; v1(200.96,67.4) 200.5,66.94 199.02,66.94 198.43,67.53 197.61,67.53 194.71,64.64 191.27,64.64 190.78,64.15 187.5,64.15 184.98,61.63 184.31,61.63 183.63,62.3 182.28,62.3 181.53,63.05 181.53,63.95 181.25,64.23 180.26,64.23 179.75,63.72 172.86,63.72 171.22,62.08 170.24,62.08 167.91,59.75 167.91,54.97 165.45,52.51 116.9,52.51 v1(116.23,53.18)
  IN5 w0.089: v1(200.96,67.4) 200.96,69.26 203.65,71.94 203.65,78.39 205.26,80.01 205.26,85.3 204.11,86.45 201.06,86.45 197.84,89.68 197.84,91.76 v1(197.17,92.42)
MAINON: length 490.3
  TOP w0.14: v1(352.98,62.56) 352.98,62.19 353.12,62.05 R20849.2 ; v1(327.81,77.44) 328.14,77.44 328.87,78.17 331.26,78.17 331.85,78.76 331.85,79.34 331.79,79.39 331.79,80.26 331.91,80.37 331.91,85.17 332.1,85.36 334.49,85.36 336.02,86.9 339.1,86.9 340.66,88.46 341.32,88.46 343.07,90.21 343.07,91.38 343.3,91.61 345.71,91.61 346.2,92.09 PR67223.1 347.03,92.76 v1(347.26,92.52) 348.13,92.52 348.43,92.22 348.43,91.81 348.71,91.53 353.56,91.53 353.74,91.71 354.6,91.71 PR67175.1 ; v1(39.48,74.27) PR176.1 ; v1(179.51,53.81) 179.45,53.81 179.27,54 U49.30
  TOP w0.254: v1(37.41,71.06) 36.47,70.12 PR120.1 36.03,70.11 35.73,70.4 PQ16.2
  IN2 w0.089: v1(176.47,78.86) 176.47,77.23 175.41,76.17 175.41,73.47 175.15,73.22 v1(174.72,73.22)
  IN3 w0.079: v1(37.41,71.06) 37.41,72.81 38.87,74.27 v1(39.48,74.27) 40.05,73.7 40.76,73.7 41.04,73.98 41.04,74.16 41.37,74.49 41.73,74.49 43.15,73.07 43.15,64.92 44.17,63.9 44.83,63.9 47.53,61.2 49.25,61.2 49.74,60.7 55.21,60.7 55.92,59.99 59.41,59.99 59.86,59.54 59.86,59.42 62.37,56.91 62.77,56.91 64.46,55.22 65.71,55.22 66.68,54.26 68.02,54.26 69.68,52.6 72.73,52.6 73.62,51.71 86.27,51.71 88.18,53.62 100.32,53.62 102.69,55.99 102.69,59.2 102.94,59.45 v1(103.14,59.45) 103.6,59 105.55,59 107.91,56.64 110.61,56.64 111.43,55.82 117.48,55.82 118.34,54.96 133.62,54.96 134.69,56.02 140.46,56.02 141.66,54.82 145.75,54.82 146.13,55.2 146.13,55.81 146.85,56.53 147.72,56.53 147.86,56.67 160.4,56.67 162.1,58.36 162.99,58.36 163.32,58.03 163.32,55.85 v1(164.18,54.98) 165.86,56.66 165.86,60.3 171.88,66.33 175.83,66.33 176.13,66.63 178.65,66.63 179.54,67.51 182.22,67.51 183.06,68.35 188.42,68.35 189.33,69.26 190.98,69.26 191.36,68.88 194.25,68.88 196.87,71.5 198.76,71.5 200.23,72.98 200.23,73.69 202.09,75.55 202.09,77.31 205.23,80.45 206.4,80.45 211.12,85.18 277.83,85.18 279.01,84 280.76,84 285.48,79.27 288.08,79.27 289.52,77.83 290.45,77.83 291.27,77.01 294.61,77.01 295.12,77.52 300.4,77.52 301.81,76.12 303.04,76.12 303.37,75.78 305.86,75.78 306.06,75.99 310.51,75.99 310.82,76.3 311.54,76.3 311.87,75.97 315.88,75.97 317.67,77.75 321.86,77.75 323.99,75.62 327.45,75.62 327.78,75.95 327.78,77.41 v1(327.81,77.44) 328.44,78.07 329.77,78.07 330.97,76.86 330.97,71.98 331.63,71.33 331.63,70.6 333.46,68.77 333.84,68.77 334.02,68.59 334.41,68.2 334.41,66.53 336.32,64.62 336.32,63.72 336.98,63.06 344.71,63.06 346.88,65.24 349.23,65.24 350.44,66.45 353.22,66.45 353.82,65.85 353.82,63.52 352.98,62.68 v1(352.98,62.56)
  BOTTOM w0.14: v1(179.51,53.81) R812.1 178.84,52.87 177.95,51.97 177.95,51.4 177.64,51.09 177.2,51.09 176.73,51.55 166.69,51.55 164.18,54.07 v1(164.18,54.98) 164.28,55.08 165.22,55.08 166.4,56.27 166.4,62.07 164.76,63.72 164.76,66.96 166.18,68.38 171.87,68.38 173.01,69.52 173.01,70.36 173.76,71.11 175.01,71.11 175.24,70.88 175.65,70.88 175.92,71.14 175.92,72.03 v1(174.72,73.22) ; v1(103.14,59.45) 103.73,60.04 PR132.1 ; v1(176.47,78.86) PR2020.2
MAINON_ON_G: length 115.2
  TOP w0.14: v1(104.13,58.16) 104.06,58.16 102.71,56.81 102.71,52.86 102.85,52.72 PQ41.2 103.6,53.26 104.13,53.79 107.39,53.79 PQ9050.2 109.34,53.71 110.79,53.71 112.97,55.9 112.97,58.87 113.25,59.15 113.25,62.86 112.97,63.14 PQ6.2
  TOP w0.254: v1(36.95,64.48) 36.65,64.79 PQ12.2 36.65,66.26 36.95,66.56 36.95,67.49 PR116.2 PR118.1 33.35,68.43 PQ19.2 32.74,68.75 v1(31.97,69.51) 31.52,69.97 PQ14.2 32.1,70.58 32.58,71.06 PQ16.3
  IN3 w0.079: v1(36.95,64.48) 39.03,64.48 40.2,63.31 44.9,63.31 47.37,60.84 49.03,60.84 49.6,60.27 55.18,60.27 55.77,59.67 59.28,59.67 59.55,59.4 59.55,59.29 62.24,56.59 62.64,56.59 64.33,54.91 65.58,54.91 66.54,53.94 67.89,53.94 70.51,51.32 86.37,51.32 88.35,53.3 100.45,53.3 104.13,56.99 v1(104.13,58.16)
MARCO_1: length 120.9
  TOP w0.14: v1(173.69,56.29) 173.67,56.28 173.67,55.6 174.58,54.69 174.91,54.69 176.5,53.1 T9029.1 177.06,52.87 180.24,52.87 180.78,52.33 180.8,52.33 180.8,52.33 U49.35
  IN2 w0.089: v1(165.44,66.01) 163.29,66.01 161.82,64.53 156.88,64.53 155.05,66.37 153.78,66.37 153.29,65.88 152.17,65.88 151.79,66.25 146.75,66.25 146.14,66.86 140.05,66.86 139.33,66.14 133.59,66.14 133.09,66.64 130.2,66.64 127.3,69.54 126.56,69.54 125.55,70.55 125.55,72.05 126.26,72.77 126.26,83.91 127.13,84.77 127.13,87.86 129,89.73 129,93.82 128.47,94.35 128.47,98.59 128.04,99.03 128.04,110.07 127.58,110.53 127.12,110.53 126.77,110.89 126.77,112.72 127.93,113.88 127.93,114.82 129.09,115.98 129.09,117.23 v1(128.21,118.1)
  BOTTOM w0.14: R67395.2 128.57,117.74 v1(128.21,118.1) ; v1(173.69,56.29) 173.67,56.29 173.06,56.91 173.06,57.66 172.54,58.18 171.54,58.18 169.84,59.88 168.48,59.88 167.91,60.44 167.91,61.85 166.06,63.7 166.06,65.39 v1(165.44,66.01)
MARCO_2: length 5.7
  TOP w0.14: v1(181.83,70.81) 181.84,70.8 T9030.1 181.63,69.55 181.63,69.05 181.19,68.61 181.19,68.23 181.2,68.22 U49.125
  BOTTOM w0.14: v1(181.83,70.81) 182.19,70.81 182.39,70.6 R67365.2 R67364.1
MARCO_3: length 21.9
  TOP w0.14: U49.76 195.24,57.6 v1(195.29,57.55) 195.64,57.2 T9031.1
  IN5 w0.089: v1(195.29,57.55) 193.76,57.55 193.4,57.92 192.41,57.92 191.39,56.9 189.1,56.9 187.78,58.22 180.76,58.22 v1(180.21,57.67)
  BOTTOM w0.14: R67394.1 180.01,58.31 180.21,58.11 v1(180.21,57.67)
MARCO_4: length 223.1
  TOP w0.14: U49.16 177.08,59.6 176.72,59.24 176.72,58.82 176.93,58.61 176.93,58.13 T9032.1 176.27,57.75 175.61,57.09 v1(175.61,56.86)
  IN1 w0.089: v1(203.75,54.04) 203.47,54.04 202.84,53.41 199.31,53.41 197.2,55.52 196.01,55.52 195.5,56.02 192.04,56.02 191.38,56.68 189.43,56.68 188.67,55.92 178.81,55.92 178.53,56.2 176.27,56.2 v1(175.61,56.86)
  IN3 w0.079: v1(363.88,41.37) 364.05,41.19 364.05,40.33 363.93,40.2 361.97,40.2 359.38,42.79 359.38,47.24 359.23,47.39 359.23,49.42 358.03,50.61 358.03,54.01 357.73,54.31 357.73,55.86 357.18,56.41 356.45,56.41 354.83,58.03 348.36,58.03 348.13,58.26 346.53,58.26 345.38,57.11 344.83,56.56 344.19,56.56 340.59,52.96 335.13,52.96 334.47,52.3 333.74,52.3 333.08,51.63 329.42,51.63 329,52.06 325.03,52.06 324.4,52.69 322.96,52.69 322.14,51.87 322.14,51.52 321.72,51.1 318.95,51.1 317.48,52.57 314.18,52.57 313.93,52.83 313.44,52.83 312.69,52.08 312.69,51.82 312.5,51.63 308.81,51.63 307.59,52.85 302,52.85 301.54,53.31 299.99,53.31 299.61,52.92 298.32,52.92 296.34,50.94 292.48,50.94 291.87,51.55 290.29,51.55 289.53,52.32 278.71,52.32 277.34,53.69 270.73,53.69 270.25,54.17 225.88,54.17 225.67,53.97 209.77,53.97 209.19,54.55 209.19,55.39 208.2,56.38 206.42,56.38 205.25,55.21 205.25,55.06 204.24,54.04 v1(203.75,54.04)
  BOTTOM w0.14: v1(363.88,41.37) 364.33,41.82 R67385.2
MARCO_5: length 6.8
  TOP w0.14: R67367.2 180.51,72.99 180.96,72.54 T9033.1 181.35,71.59 181.35,69.18 180.8,68.63 U49.126
MARCO_P: length 1
  BOTTOM w0.14: T9028.1 192.58,61 R67294.1
MB_THRMTRIP#: length 5
  TOP w0.14: U13092.4 357.24,41.97 356.23,40.96 R21039.2 356.94,40.61 v1(357.02,40.53) 357.26,40.28 D13070.1
MBCLK: length 154.5
  TOP w0.14: v1(66.52,58.59) 66.97,59.04 68.23,59.04 69.03,58.24 PD4.1 ; R388.1 187.6,69.41 v1(187.22,69.03) 187.22,68.99 187.2,68.98 U49.110
  IN2 w0.089: v1(187.22,69.03) 187.22,69.28 186.67,69.84 178.07,69.84 174.59,66.35 171.62,66.35 167.74,62.47 157.49,62.47 156.48,61.46 151.71,61.46 v1(151.45,61.21) 149.94,62.72 149.38,62.72 148.05,64.06 139.98,64.06 139.67,64.36 136.04,64.36 135.09,63.42 131.11,63.42 130.79,63.1 129.19,63.1 128.05,61.96 126.33,61.96 122.52,58.15 118.5,58.15 117.65,59.01 115.26,59.01 114.13,57.88 107.89,57.88 106.36,56.35 95.9,56.35 92.65,53.1 84.53,53.1 82.35,50.92 77.57,50.92 77.2,50.56 73.42,50.56 73.01,50.97 71.34,50.97 67.43,54.89 67.43,55.08 66.52,55.99 v1(66.52,58.59)
  BOTTOM w0.14: v1(187.22,69.03) 186.49,69.76 R22061.1 ; PR17.1 66.52,58.06 v1(66.52,58.59) 66.11,59 v1(65.91,59) ; v1(151.45,61.21) 151.45,60.6 152.19,59.86 153.23,59.86 154.59,58.5 PC11.1 PR12.2
MBCLK_CONN: length 6.7
  TOP w0.14: PJ1.4 160.35,55.09 v1(160.24,54.98)
  BOTTOM w0.14: v1(160.24,54.98) 158.9,56.33 156.74,56.33 156.42,56.65 PR12.1
MBDATA: length 154.1
  TOP w0.14: PD3.1 62.81,57.22 v1(63.49,57.9) ; U49.111 186.8,68.1 186.56,68.34 v1(186.56,68.99) 186.56,69.83 R20894.1
  IN2 w0.089: v1(63.49,57.9) 64.22,57.9 65.78,56.34 65.78,55.57 70.85,50.5 72.81,50.5 73.24,50.07 77.38,50.07 77.76,50.45 82.54,50.45 84.71,52.63 92.94,52.63 95.48,55.17 99.67,55.17 100.38,55.88 106.56,55.88 108.09,57.41 114.33,57.41 115.46,58.54 117.44,58.54 118.3,57.68 122.73,57.68 126.54,61.49 128.25,61.49 129.07,62.32 135.45,62.32 137.03,63.89 139.27,63.89 139.88,63.28 141.95,63.28 142.03,63.36 148.08,63.36 149.25,62.2 149.65,62.2 150.64,61.21 150.64,61.15 ; 150.64,61.15 151.15,60.65 151.61,60.65 151.95,60.99 157.63,60.99 158.59,61.95 167.88,61.95 171.81,65.88 174.78,65.88 176.43,67.53 177.83,67.53 178.79,68.48 179.41,68.48 180.3,69.37 186.18,69.37 v1(186.56,68.99) ; 150.64,61.15 v1(150.62,61.18)
  BOTTOM w0.14: PR13.2 PC10.1 152,59.23 150.62,60.62 v1(150.62,61.18) ; v1(186.56,68.99) 186.56,68.95 186.96,68.55 187.52,68.55 187.7,68.72 187.7,69.32 R22062.1 ; PR19.1 65.68,58.25 65.38,58.54 64.4,58.54 64.15,58.29 63.88,58.29 v1(63.49,57.9) v1(64.64,57.9)
MBDATA_CONN: length 8
  TOP w0.14: PJ1.3 158.35,55.4 158.66,55.1 v1(158.66,54.98)
  BOTTOM w0.14: v1(158.66,54.98) 158.66,55.24 157.95,55.95 156.64,55.95 155.8,56.79 PR13.1
MDI_0+: length 7.9
  TOP w0.102: U13112.12 357.27,65.5 356.92,65.85 356.62,65.85 356.34,66.13 356.34,67.02 356.29,67.07 v1(355.54,67.07) 355.54,67.82 353.82,69.54 U13143.11
MDI_0-: length 7.9
  TOP w0.102: U13143.12 353.64,69.94 353.69,69.89 353.87,69.89 355.77,67.99 v1(356.43,67.99) 356.43,67.33 356.62,67.14 356.62,66.25 356.74,66.13 356.89,66.13 357.26,66.5 U13112.11
MDI_1+: length 6.6
  TOP w0.102: U13112.9 357.11,68.5 356.75,68.86 356.31,68.86 355.97,69.2 v1(355.29,69.2) 355.29,69.87 354.36,70.81 353.72,70.81 353.65,70.74 U13143.14
MDI_1-: length 6.7
  TOP w0.102: U13112.8 357.11,69.5 356.75,69.14 356.42,69.14 356.29,69.27 v1(356.29,70.03) 355.54,70.03 354.48,71.09 353.72,71.09 353.66,71.14 U13143.15
MDI_2+: length 5.5
  TOP w0.102: U13112.6 357.04,71.5 356.66,71.87 356.1,71.87 355.99,71.99 353.72,71.99 353.67,71.94 U13143.17
MDI_2-: length 5.5
  TOP w0.102: U13112.5 357.03,72.5 356.69,72.15 356.22,72.15 356.1,72.27 353.72,72.27 353.64,72.34 U13143.18
MDI_3+: length 7.1
  TOP w0.102: U13143.20 353.01,73.6 353.96,74.55 354.39,74.55 v1(354.89,74.05) 355.39,74.55 356.03,74.55 356.52,75.05 356.82,75.05 356.94,74.92 356.94,74.67 357.11,74.5 U13112.3
MDI_3-: length 7.2
  TOP w0.102: U13143.21 352.96,73.94 353.85,74.83 354.36,74.83 v1(354.9,75.37) 355.44,74.83 355.91,74.83 356.41,75.33 356.89,75.33 357.06,75.5 U13112.2
ME_WR#: length 147.7
  TOP w0.14: U49.109 187.6,66.44 187.4,66.23 187.4,65.73 186.96,65.29 186.96,64.24 187.8,63.4 187.8,60.4 186.89,59.48 186.89,57.62 190.24,54.27 v1(190.24,53.81)
  IN3 w0.079: v1(314.98,47.59) 314.14,46.75 289.19,46.75 286.95,48.99 269.41,48.99 268.41,49.99 266.6,49.99 266.54,50.05 238.65,50.05 237.97,50.74 229.15,50.74 228.77,51.12 203.55,51.12 203.42,50.99 199.21,50.99 198.95,51.25 198.19,51.25 197.63,51.81 193.97,51.81 192.73,53.06 191.3,53.06 190.54,53.81 v1(190.24,53.81)
  BOTTOM w0.14: R21098.1 R21279.2 R21272.1 314.97,48.73 314.6,48.35 314.6,47.97 v1(314.98,47.59)
MEM_VDD_CTRL: length 84.9
  TOP w0.127: v2(145.01,116.66) U13114.BH4
  TOP w0.203: PR9141.2 109.86,73.01 v1(109.49,73.37)
  IN1 w0.089: v2(145.01,116.66) 144.54,117.13 144.25,117.13 143.2,118.18 v1(140.36,118.18)
  IN5 w0.254: v1(140.36,118.18) 139.67,118.86 137.21,118.86 136.62,118.28 134.74,118.28 133.95,117.49 132.38,117.49 132.15,117.72 131.08,117.72 131.01,117.8 130.32,117.8 129.38,118.74 128.14,118.74 127.34,119.54 126.7,119.54 126.21,119.04 124.43,119.04 120.54,115.15 120.54,114.67 119.91,114.04 119.91,110.81 122.8,107.92 122.8,99.35 122.27,98.81 122.27,78.22 121.79,77.74 118.51,77.74 117.88,77.11 117.88,76 116.61,74.73 115.17,74.73 114.37,73.93 110.05,73.93 v1(109.49,73.37)
  BOTTOM w0.14: R21576.2 140.2,118.33 v1(140.36,118.18)
MEM_VPP: length 418.2
  TOP w0.2: v4(206.77,152.09) 205.87,152.09 U13138.W3 ; U13142.W3 114.92,150.97 v1(114.83,150.88)
  TOP w0.25: U13138.A3 v4(193.74,151.66)
  TOP w0.254: v4(115.64,126.29) 115.86,126.07 U13141.A3 ; U13136.A3 193.83,116.7 193.05,116.7 v4(192.43,116.07) ; v4(193.64,141.65) 193.82,141.83 U13135.W3 ; U13140.W3 154.33,177.01 154.33,177.64 154.07,177.89 v4(154.07,178.15) ; v4(128.88,126.17) 128.78,126.07 U13141.W3 ; U13135.A3 207.14,141.83 v4(207.49,141.49) ; v4(128.62,151.3) U13142.A3
  TOP w0.28: U13137.W3 173.46,164.97 v4(173.46,164.52)
  TOP w0.3: U13139.W3 130.11,164.88 v4(130.11,164.62) ; v4(173.76,178.4) 173.37,178.02 U13137.A3 ; U13139.A3 129.94,177.64 v1(129.69,177.89) ; v4(154.4,164.73) U13140.A3
  TOP w0.305: U13136.W3 206.03,117.19 v4(206.48,117.19)
  TOP w0.508: v1(120.8,122.19) 120.83,122.16 R67309.1
  IN1 w0.508: v4(193.74,151.66) 193.44,151.66 193.09,151.3 193.09,148.66 194,147.74 v1(206.85,147.74) ; v4(128.88,126.17) 129.07,126.36 129.94,126.36 131.19,125.11 131.19,122.83 130.7,122.34 120.95,122.34 v1(120.8,122.19) 117.5,122.19 115.37,124.31 115.37,125.91 115.64,126.18 v4(115.64,126.29) 114.45,127.48 114.45,150.5 v1(114.83,150.88) 114.83,155.38 118.31,158.86 118.31,168.6 127.6,177.89 v1(129.69,177.89) 131.57,179.77 152.45,179.77 v4(154.07,178.15) 155.26,179.34 172.82,179.34 v4(173.76,178.4) 174.67,179.32 183.51,179.32 185.92,176.91 185.92,167.43 186.2,167.15 201.76,167.15 208.09,160.82 208.09,153.37 206.8,152.09 v4(206.77,152.09) 206.77,151.61 207.52,150.86 207.52,149.1 206.85,148.43 v1(206.85,147.74) ; v1(206.85,147.74) 208.12,146.47 208.12,142.73 207.49,142.09 v4(207.49,141.49) 208.08,140.89 208.08,133.7 207.13,132.75 207.13,131.61 208.08,130.67 208.08,117.55 207.72,117.19 v4(206.48,117.19) 206.48,116.55 206.88,116.15 206.88,114.29 206.22,113.63 193.26,113.63 192.43,114.47 v4(192.43,116.07)
  IN5 w0.508: v4(130.11,164.62) 130.11,163 129.31,162.2 ; v4(193.64,141.65) 192.76,141.65 192.45,141.96 192.45,143.4 194.13,145.08 204.19,145.08 v1(206.85,147.74) ; 129.31,162.2 130.11,161.39 130.11,151.83 129.58,151.3 v4(128.62,151.3) ; 129.31,162.2 126.82,162.2 126.26,162.75 126.26,176.5 127.66,177.89 v1(129.69,177.89)
  BOTTOM w0.203: v4(207.49,141.49) 207.49,141.22 207.54,141.16 C95693.2 ; C95752.2 193.74,151.65 v4(193.74,151.66) ; C95732.2 173.41,178.75 v4(173.76,178.4) ; C95812.2 115.64,125.97 v4(115.64,126.29) ; C95832.2 114.46,151.25 v1(114.83,150.88) ; v4(154.4,164.73) 154.74,164.4 C95792.2 ; C95713.2 192.24,115.88 v4(192.43,116.07) ; C95692.2 193.58,141.71 193.63,141.65 v4(193.64,141.65) ; v4(206.48,117.19) 206.48,117.35 206.73,117.59 C95712.2 ; v1(129.69,177.89) 129.69,178.51 129.28,178.91 C95772.2 ; C95773.2 130.25,163.91 130.11,164.05 v4(130.11,164.62)
  BOTTOM w0.254: v4(128.62,151.3) 129.13,151.3 129.32,151.49 C95833.2 ; C95732.2 173.41,179.49 173.07,179.82 ; C95793.2 153.77,177.84 v4(154.07,178.15) ; v4(128.88,126.17) 129.44,126.73 C95813.2 v1(131.59,126.73) ; v4(173.46,164.52) 173.41,164.47 C95733.2 173.41,162 ; C95753.2 207.34,152.66 v4(206.77,152.09) ; 154.74,162 C95792.2
  BOTTOM w0.381: C96210.1 206.7,116.97 v4(206.48,117.19)
  BOTTOM w0.508: 172.04,179.75 169.11,179.75 167.36,177.99 ; 172.04,179.75 172.46,179.75 172.54,179.82 173.07,179.82 ; 172.04,179.75 C96213.1 ; 173.41,162 172.66,161.26 169.95,161.26 167.36,163.85 167.36,177.99 ; 167.36,177.99 162.73,177.99 160.65,175.91 160.65,165.68 159.28,164.3 158.26,164.3 155.6,161.64 154.93,161.64 154.74,161.84 154.74,162 ; v4(206.77,152.09) 206.92,151.93 C96212.1 ; C96216.1 115.06,151.11 v1(114.83,150.88) ; v4(154.07,178.15) 154.07,178.38 C96214.1 ; v4(115.64,126.29) 115.63,126.31 114.88,126.31 114.37,125.8 C96217.1 ; v1(129.69,177.89) 129.66,177.92 C96215.1 ; C96211.1 208.16,141.33 208,141.49 v4(207.49,141.49)
MEM_VREF_CTL: length 233.2
  TOP w0.14: Q7876.2 v1(206.47,127.61) ; U13114.BD3 144.31,119.46 143.78,119.46 143.42,119.83 142.34,119.83 141.55,119.04 141.12,119.04 v1(140.79,118.71) 140.1,118.71 139.8,118.41 R21577.2
  IN1 w0.089: v1(141.39,178.54) 141.53,178.4 151.28,178.4 152.09,177.59 169.39,177.59 169.57,177.77 173.88,177.77 174.95,178.83 182.09,178.83 184.22,176.7 v1(184.68,176.7)
  IN4 w0.089: v1(115.98,137.26) 115.72,137 115.72,132.05 115.84,131.92 115.84,129.51 115.97,129.38 115.97,128.87 116.35,128.49 116.35,126.2 115.72,125.57 115.72,123.92 116.86,122.77 136.42,122.77 139.34,119.85 139.64,119.85 v1(140.79,118.71)
  IN5 w0.089: v1(184.68,176.7) 185.97,176.7 189,173.68 189,165.19 190.49,163.69 201.29,163.69 202.25,162.73 206.47,162.73 208.81,160.39 208.81,134.51 207.32,133.02 207.32,128.46 v1(206.47,127.61) ; v1(141.39,178.54) 140.97,178.96 129.23,178.96 128.67,178.4 127.62,178.4 125.87,176.66 125.87,163.33 115.39,152.85 115.39,148.15 114.75,147.51 114.75,140.38 115.21,139.92 115.21,138.03 v1(115.98,137.26)
  BOTTOM w0.14: v1(184.68,176.7) 184.68,175.38 185.06,175 185.06,172.89 185.41,172.53 187.32,172.53 187.68,172.17 Q7877.2 ; Q7878.2 v1(141.39,178.54) ; Q7879.2 v1(115.98,137.26)
MIC2-L: length 11.5
  IN5 w1.016: 23.08,32 21.18,32 20.37,31.18 20.37,29.99 19.51,29.14 19.51,27.87 21.71,25.67 21.71,25.54 22.83,24.43
  vias: v1(24.02,31.61) v1(24.58,24.88) v1(24.61,24.22) v1(24.68,31.61)
MIC2-L_1: length 11.4
  TOP w1.016: CN2059.1 12.35,26.47 13.17,25.65 13.81,25.65 15.49,23.97 v1(15.95,23.97) 18.99,23.97 20.21,25.19 20.87,25.19
MIC2-R: length 10.9
  IN5 w1.016: 25.9,22.62 25.71,22.81 25.71,25.63 24.77,26.57 23.48,26.57 22.3,27.75 22.3,29.89 22.98,30.57 23.39,30.57
  vias: v1(24.02,30.95) v1(24.26,21.38) v1(24.7,30.96) v1(24.81,22.25) v1(24.94,21.63)
MIC2-R_1: length 17.4
  TOP w1.016: CN2059.2 4.9,25.04 6.62,26.76 9.9,26.76 12.54,24.12 13.18,24.12 14.85,22.44 17.09,22.44
  vias: v1(19.02,22.55)
MIC2-VREFO-L: length 10.9
  TOP w0.203: U13108.28 25.84,32.46 25.72,32.58 25.14,32.58 v1(24.89,32.83)
  TOP w0.381: R21459.1 23.96,26.19 24.2,26.43 v1(24.2,26.51) v1(24.2,27.98)
  IN1 w0.381: v1(24.89,32.83) 24.2,32.15 23.79,32.15 23.49,31.84 23.49,30.55 23.77,30.27 24.28,30.27 24.56,29.99 24.56,29.34 24.4,29.18 24.4,28.26 24.2,28.06 v1(24.2,27.98)
MIC2-VREFO-R: length 15.9
  TOP w0.203: U13108.29 25.74,32.06 25.58,32.22 24.62,32.22
  TOP w0.381: 24.62,32.22 24.53,32.22 24.02,32.73 v1(24.02,33.11) ; R21458.1 24.33,23.49 v1(24.76,23.05)
  IN1 w0.381: v1(24.76,23.05) 23.92,23.89 23.92,26.42 22.6,27.74 22.6,32.22 23.49,33.11 v1(24.02,33.11)
MIC_JD#: length 18.5
  TOP w0.381: v1(16.96,20.96) D8575.1 12.52,20.96 11.24,22.25 CN2059.6
  BOTTOM w0.381: R22093.2 26.21,23.92 25.93,23.64 21.33,23.64 20.38,22.68 19.13,22.68 17.41,20.96 v1(16.96,20.96)
MIC_VCC_1.8V: length 4.3
  TOP w0.254: C94703.2 355.59,79.73 v1(355.55,79.77) 355.85,80.08 CN2042.34
  BOTTOM w0.254: v1(355.55,79.77) 355.55,79.39 355.24,79.09 R20949.2 C94704.2
