# Allegro board DAZGLMB1ED0 dazglmb1ed0-d-ver a-165 (.BRD) .brd (continued)
## Nets (continued)
+VIN_VCCSA: PC9425.1 PC9426.1 PC9427.1 PC9428.1 PJ9010.2 PU43.1(VIN#1) PU43.6(VIN#2)
+VIN_VGACORE: PC9018.1 PC9022.1 PC9023.2 PC9451.1 PC9452.1 PC9453.1 PC9454.1 PC9455.1 PC9456.1 PC9457.1 PC9458.2 PC9459.1 PC9460.1 PC9461.1 PC9462.1 PC9463.1 PC9464.1 PC9465.2 PC9466.1 PC9467.1 PC9468.1 PC9469.1 PC9470.1 PC9471.1 PC9472.2 PC9473.1 PC9474.1 PC9475.1 PJ9025.1 PR67198.1 PU9011.8(VIN#1) PU9011.9(VIN#2) PU9012.8(VIN#1) PU9012.9(VIN#2) PU9013.8(VIN#1) PU9013.9(VIN#2) PU9014.8(VIN#1) PU9014.9(VIN#2)
AVDDH: C94980.1 C94981.2 C94984.2 U13143.9(AVDDH_REG) U13143.22(AVDDH)
AVDDL: C94974.2 C94977.2 C94978.1 C94987.1 C94988.2 L4243.2 L4244.1 U13143.6(AVDDL_REG) U13143.13(AVDDL#1) U13143.19(AVDDL#2) U13143.31(AVDDL#3)
AVDDVCO: L4243.1 U13143.34(AVDDL#4)
DVDD_IO: C96237.2 Q7947.2(G) Q7947.5(G) R67353.2 R67373.2 R67374.2 U13157.12(DVDD_IO)
DVDDL: C94969.1 C94970.2 C94971.2 C94972.1 C94973.2 L4242.1 L4244.2 U13143.37(DVDDL_REG)
