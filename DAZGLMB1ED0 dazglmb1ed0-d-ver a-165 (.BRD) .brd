# Allegro board DAZGLMB1ED0 dazglmb1ed0-d-ver a-165 (.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCIE14_SATA_RXN_C_RE_C: length 3
  TOP w0.14: CN2070.29 37.74,20.93 37.86,21.05 37.86,22.32 R21794.2
PCIE14_SATA_RXP: length 293.6
  TOP w0.14: v1(44.11,43.42) 43.82,43.13 43.82,42.5 C95848.2 ; U13113.E41 293.5,72.33 293.74,72.09 293.74,71.89 v2(293.62,71.77)
  IN4 w0.089: v2(293.62,71.77) 293.81,71.77 293.9,71.86 293.9,72.25 293.79,72.37 291.69,72.37 291.55,72.51 291.03,72.51 289.19,74.34 287.26,74.34 286.78,74.82 280.15,74.82 273.05,81.92 210.3,81.92 207.55,79.17 207.55,78.48 203.9,74.83 203.9,73.81 201.93,71.85 191.84,71.85 190.28,70.28 182.84,70.28 182.54,69.98 181.82,69.98 181.66,69.82 178.52,69.82 175.81,67.11 174.72,67.11 173.21,65.59 173.21,64.87 170.75,62.41 170.3,62.41 166.75,58.85 163.86,58.85 163.12,58.11 159.68,58.11 159.12,57.55 145.81,57.55 145.41,57.15 140.56,57.15 139.69,58.03 134.38,58.03 133.99,57.63 130.16,57.63 129.77,57.24 124.01,57.24 123.3,57.95 118.24,57.95 117.32,58.87 115.23,58.87 114.32,57.95 108.66,57.95 107.61,56.9 95.2,56.9 93.22,54.92 84.09,54.92 81.08,51.9 73.3,51.9 72.21,52.99 68.51,52.99 68.43,53.06 68.42,53.06 68.2,53.29 65.91,53.29 65.6,52.99 64.11,52.99 61.81,55.29 57.98,55.29 57.36,55.91 56.86,55.91 55.7,57.08 53.21,57.08 51.72,58.57 47.76,58.57 47.16,59.17 45.88,59.17 45.42,59.64 44.82,59.64 43.62,58.44 43.62,55.5 42.16,54.05 42.16,51.3 43.45,50 43.45,46.42 43.78,46.09 43.78,43.58 43.94,43.42 v1(44.11,43.42)
PCIE14_SATA_RXP_C: length 3
  TOP w0.14: U13149.19 43.94,39.65 43.87,39.72 43.87,41.56 C95848.1
PCIE14_SATA_RXP_C_RE: length 16.8
  TOP w0.14: v1(41.55,33.54) 41.32,33.54 41.16,33.71 41.16,34.07 41.28,34.19 42.37,34.19 42.67,33.9 43.33,33.9 43.94,34.51 U13149.30 ; v1(39.16,24.81) 38.95,24.59 38.95,24.34 38.66,24.06 38.46,24.06 38.29,23.89 38.29,23.68 R21795.1
  IN5 w0.089: v1(41.55,33.54) 41.17,33.16 41.17,32.79 40.98,32.6 40.98,31.37 41.4,30.95 41.4,28.28 38.88,25.76 38.88,24.91 38.98,24.81 v1(39.16,24.81)
PCIE14_SATA_RXP_C_RE_C: length 3
  TOP w0.14: R21795.2 38.12,22.31 38.12,21.05 38.24,20.93 CN2070.31
PCIE14_SATA_TXN: length 292.3
  TOP w0.14: C95846.2 45,42.37 45,43.2 v1(44.78,43.41) ; v1(287.01,73.85) 286.81,73.65 286.81,73.24 288.01,72.05 291.23,72.05 291.54,71.75 291.92,71.75 292.15,71.51 U13113.B39
  IN4 w0.089: v1(44.78,43.41) 45.09,43.72 45.09,49.05 42.67,51.48 42.67,53.99 44.01,55.34 44.01,56.95 45.84,58.77 46.94,58.77 49.09,56.62 55.59,56.62 56.72,55.49 57.12,55.49 57.78,54.83 61.18,54.83 62.37,53.65 62.37,52.92 62.83,52.46 64.88,52.46 65.51,51.82 65.86,51.82 66.88,52.84 67.96,52.84 68.27,52.53 69.07,52.53 70.23,51.38 72.82,51.38 72.96,51.51 81.24,51.51 84.08,54.35 93.35,54.35 95.4,56.4 107.76,56.4 108.85,57.5 114.42,57.5 115.26,58.34 117.3,58.34 118.14,57.5 123.19,57.5 123.84,56.85 130,56.85 130.18,57.04 133.95,57.04 134.44,57.53 139.57,57.53 140.38,56.73 148.87,56.73 149.05,56.9 163.02,56.9 164.55,58.44 166.99,58.44 168.89,60.33 170.13,60.33 171.3,61.5 171.3,62.39 173.72,64.81 173.72,65.54 174.85,66.68 176.73,66.68 176.97,66.91 176.97,67.29 177.33,67.65 178.28,67.65 179.84,69.22 181.8,69.22 182.01,69.43 182.66,69.43 183.04,69.82 191.38,69.82 191.95,70.39 195.3,70.39 196.29,71.38 202.4,71.38 208.18,77.17 208.18,79.16 210.48,81.45 272.68,81.45 276.36,77.77 276.36,76.08 276.82,75.62 278.8,75.62 279.99,74.43 286.54,74.43 286.8,74.17 286.8,74.07 v1(287.01,73.85)
PCIE14_SATA_TXN_C: length 3.1
  TOP w0.14: U13149.17 44.74,39.33 44.87,39.46 44.87,40.75 45.11,40.98 45.11,41.52 C95846.1
PCIE14_SATA_TXN_C_RE: length 14.5
  TOP w0.14: C95634.1 39.39,23.36 v1(39.54,23.51) ; v1(43.73,30.22) 43.97,30.46 43.97,32.82 44.11,32.96 44.11,33.52 44.84,34.24 44.84,34.38 44.74,34.48 U13149.32
  IN5 w0.089: v1(43.73,30.22) 43.96,29.99 43.96,29.68 39.96,25.68 39.96,23.88 39.59,23.51 v1(39.54,23.51)
PCIE14_SATA_TXN_C_RE_C: length 2.9
  TOP w0.14: C95634.2 39.68,22.18 39.68,21.43 39.41,21.16 39.41,21.1 39.24,20.93 CN2070.35
PCIE14_SATA_TXP: length 292.3
  TOP w0.14: v1(45.63,43.41) 45.4,43.41 45.26,43.27 45.26,42.58 C95849.2 ; U13113.A39 291.68,71.48 291.43,71.48 291.12,71.78 287.89,71.78 286.54,73.13 286.54,73.71 286.41,73.85 v1(286.33,73.85)
  IN4 w0.089: v1(286.33,73.85) 286.53,73.85 286.62,73.94 286.62,74.11 286.47,74.26 279.92,74.26 278.73,75.45 276.75,75.45 276.19,76.01 276.19,77.7 272.61,81.29 210.55,81.29 208.35,79.09 208.35,77.1 202.47,71.21 196.36,71.21 195.37,70.22 192.02,70.22 191.45,69.65 183.11,69.65 182.73,69.27 182.08,69.27 181.87,69.05 179.91,69.05 178.35,67.49 177.39,67.49 177.13,67.23 177.13,66.84 176.8,66.51 174.92,66.51 173.88,65.48 173.88,64.74 171.47,62.32 171.47,61.43 170.2,60.16 168.96,60.16 167.06,58.27 164.62,58.27 163.09,56.73 149.12,56.73 148.94,56.56 140.31,56.56 139.5,57.37 134.51,57.37 134.02,56.87 130.25,56.87 130.07,56.68 123.77,56.68 123.12,57.33 118.07,57.33 117.23,58.17 115.33,58.17 114.49,57.33 108.92,57.33 107.83,56.23 95.47,56.23 93.42,54.18 84.15,54.18 81.31,51.34 73.03,51.34 72.89,51.21 70.16,51.21 69,52.37 68.2,52.37 67.89,52.67 66.95,52.67 65.93,51.65 65.44,51.65 64.81,52.29 62.76,52.29 62.2,52.85 62.2,53.58 61.11,54.66 57.71,54.66 57.05,55.32 56.65,55.32 55.52,56.46 49.02,56.46 46.87,58.6 45.91,58.6 44.18,56.88 44.18,55.27 42.83,53.92 42.83,51.55 45.26,49.12 45.26,43.5 45.35,43.41 v1(45.63,43.41)
PCIE14_SATA_TXP_C: length 3.1
  TOP w0.14: C95849.1 45.37,41.54 45.37,40.87 45.14,40.64 U13149.16
PCIE14_SATA_TXP_C_RE: length 14.5
  TOP w0.14: v1(44.51,30.22) 44.24,30.48 44.24,32.71 44.38,32.85 44.38,33.41 45.11,34.13 45.11,34.36 45.14,34.39 U13149.33 ; C95635.1 40.15,23.4 v1(40.2,23.45)
  IN5 w0.089: v1(40.2,23.45) 40.13,23.53 40.13,25.61 44.13,29.61 44.13,30.07 44.28,30.22 v1(44.51,30.22)
PCIE14_SATA_TXP_C_RE_C: length 2.8
  TOP w0.14: C95635.2 39.95,22.27 39.95,21.32 39.68,21.05 39.68,20.86 39.74,20.79 CN2070.37
PCIE15_SATA_RXN: length 261
  TOP w0.14: C95855.2 57.51,51.38 57.51,51.66 57.75,51.91 57.75,52.36 v1(57.58,52.54) ; v2(292.8,71.43) 292.96,71.27 293.16,71.27 U13113.D39
  IN4 w0.089: v2(292.8,71.43) 293.01,71.43 293.15,71.28 293.15,71.16 292.96,70.96 292.32,70.96 291.24,72.04 290.82,72.04 290.14,72.71 280.12,72.71 278.49,74.34 275.46,74.34 269.62,80.18 210.79,80.18 209.71,79.09 209.71,76.92 203.02,70.24 198.02,70.24 195.63,67.85 182.47,67.85 181.9,67.27 180.18,67.27 177.85,64.94 175.61,64.94 173.14,62.46 173.14,61.5 170.85,59.22 170.85,58.62 167.89,55.66 149.59,55.66 149.52,55.6 147.36,55.6 146.84,55.08 143.9,55.08 143.6,55.38 134.01,55.38 133.83,55.2 123.03,55.2 121.98,56.24 118.72,56.24 118.27,55.8 115.49,55.8 115.16,56.13 111.09,56.13 110.24,55.28 100.58,55.28 99.99,54.69 95.47,54.69 93.78,53 84.37,53 81.76,50.39 78.19,50.39 77.8,50 70.01,50 68.9,51.1 66.94,51.1 65.95,50.11 62.89,50.11 62.19,50.81 61.63,50.81 59.16,53.27 58.07,53.27 57.86,53.06 57.86,52.79 57.6,52.54 v1(57.58,52.54)
PCIE15_SATA_RXN_C: length 3.4
  TOP w0.14: C95855.1 57.49,50.42 57.49,50.32 56.38,49.21 56.38,48.65 56.12,48.39 U13148.13
PCIE15_SATA_RXN_C_RE: length 36.2
  TOP w0.14: R21792.1 34.09,23.47 v1(34.74,24.12) ; U13148.36 56.12,43.41 56.25,43.27 56.25,42.61 55.89,42.24 55.89,41.46 56.01,41.33 56.01,41.08 56.17,40.93 v1(56.17,40.58)
  IN4 w0.089: v1(34.74,24.12) 34.96,24.34 34.96,24.51 35.61,25.16 36.23,25.16 37.56,26.49 39.33,26.49 40.95,28.11 40.95,29.34 43.1,31.49 43.85,31.49 44.78,32.42 47,32.42 47.47,32.88 50.13,32.88 52,34.75 52.6,34.75 53.17,35.32 53.17,37.11 54.22,38.16 55.41,38.16 56.52,39.28 56.52,40.23 v1(56.17,40.58)
PCIE15_SATA_RXN_C_RE_C: length 3.1
  TOP w0.14: CN2070.17 34.74,21.38 34.36,21.77 34.36,22.26 R21792.2
PCIE15_SATA_RXP: length 261.1
  TOP w0.14: U13113.E37 293.47,70.66 293.85,71.04 v2(293.85,71.11) ; v1(58.27,52.54) 58.02,52.28 58.02,51.79 57.78,51.55 57.78,51.35 C95856.2
  IN4 w0.089: v2(293.85,71.11) 293.47,71.23 293.36,71.17 293.34,71.11 293.34,71.06 293.07,70.79 292.25,70.79 291.17,71.87 290.75,71.87 290.07,72.55 280.05,72.55 278.43,74.17 275.39,74.17 269.55,80.01 210.86,80.01 209.87,79.02 209.87,76.85 203.09,70.07 198.09,70.07 195.7,67.68 182.54,67.68 181.97,67.11 180.25,67.11 177.92,64.77 175.68,64.77 173.3,62.39 173.3,61.43 171.01,59.15 171.01,58.55 167.96,55.5 149.66,55.5 149.59,55.43 147.43,55.43 146.91,54.91 143.83,54.91 143.53,55.21 134.08,55.21 133.9,55.03 122.96,55.03 121.91,56.07 118.79,56.07 118.34,55.63 115.42,55.63 115.09,55.96 111.16,55.96 110.31,55.11 100.65,55.11 100.06,54.52 95.54,54.52 93.85,52.83 84.44,52.83 81.83,50.22 78.26,50.22 77.87,49.83 69.94,49.83 68.84,50.93 67.01,50.93 66.02,49.94 62.82,49.94 62.12,50.64 61.56,50.64 59.09,53.1 58.14,53.1 58.02,52.99 58.02,52.79 v1(58.27,52.54)
PCIE15_SATA_RXP_C: length 3.4
  TOP w0.14: U13148.12 56.52,48.39 56.64,48.51 56.64,49.1 57.76,50.21 57.76,50.42 C95856.1
PCIE15_SATA_RXP_C_RE: length 36.1
  TOP w0.14: v1(56.89,40.58) 56.28,41.19 56.28,41.44 56.15,41.57 56.15,42.13 56.52,42.49 U13148.37 ; v1(35.4,24.1) 34.95,23.64 R21793.1
  IN4 w0.089: v1(56.89,40.58) 56.69,40.38 56.69,39.21 55.47,38 54.29,38 53.33,37.04 53.33,35.25 52.67,34.58 52.07,34.58 50.2,32.72 47.54,32.72 47.07,32.25 44.85,32.25 43.92,31.32 43.17,31.32 41.12,29.27 41.12,28.04 39.4,26.32 37.63,26.32 36.3,24.99 35.68,24.99 35.13,24.44 35.13,24.27 35.3,24.1 v1(35.4,24.1)
PCIE15_SATA_RXP_C_RE_C: length 3.2
  TOP w0.14: CN2070.19 35.24,20.88 35.01,21.11 35.01,21.49 34.63,21.88 34.63,22.37 R21793.2
PCIE15_SATA_TXN: length 247.4
  TOP w0.14: v1(290.01,70.88) 289.94,70.95 289.94,71.15 290.03,71.25 290.91,71.25 291.22,70.94 292.1,70.94 U13113.B38 ; C95854.2 61.55,48.64 62.05,48.64 62.19,48.78 v1(62.19,49.01)
  IN4 w0.089: v1(62.19,49.01) 62.19,48.62 62.29,48.52 62.51,48.52 62.64,48.65 63.07,48.65 63.41,48.99 66.83,48.99 67.64,48.18 72.77,48.18 73.46,48.87 78.27,48.87 78.66,49.26 82.31,49.26 84.79,51.74 94.25,51.74 95.97,53.47 105.33,53.47 106.01,54.16 111,54.16 111.62,54.78 114.6,54.78 114.79,54.59 118.38,54.59 119.29,53.68 127.16,53.68 127.48,54 131.53,54 131.82,53.71 167.58,53.71 171.97,58.1 172.32,58.1 173.43,59.2 173.43,59.9 175.62,62.09 175.62,62.54 176.8,63.72 179.46,63.72 180.68,64.94 181.01,64.94 181.26,65.19 181.26,65.52 181.71,65.97 182.22,65.97 182.89,66.64 192.66,66.64 193.26,66.05 195.56,66.05 197.5,67.99 205.19,67.99 207.19,69.98 208.97,69.98 211.63,67.33 277.31,67.33 279.05,69.07 281.06,69.07 283.43,71.44 289.43,71.44 289.77,71.1 289.77,70.97 289.86,70.88 v1(290.01,70.88)
PCIE15_SATA_TXN_C: length 4.5
  TOP w0.14: U13148.10 57.32,48.76 57.68,49.11 59.44,49.11 59.62,48.94 C95854.1
PCIE15_SATA_TXN_C_RE: length 35.5
  TOP w0.14: v1(36.16,23.59) 36.16,23.38 C95632.1 ; v1(57.3,41.85) 57.39,41.94 57.39,43.3 57.32,43.37 U13148.39
  IN4 w0.089: v1(57.3,41.85) 57.39,41.75 57.39,41.52 57.28,41.41 57.28,40.16 57.09,39.97 57.09,38.91 55.1,36.92 55.1,33.58 53.83,32.32 51.22,32.32 49.04,30.14 46.83,30.14 44.57,27.88 42.23,27.88 39.8,25.46 37.54,25.46 36.43,24.34 36.43,23.73 36.29,23.59 v1(36.16,23.59)
PCIE15_SATA_TXN_C_RE_C: length 3
  TOP w0.14: CN2070.23 36.24,20.93 36.34,21.03 36.34,21.64 36.05,21.93 36.05,22.39 C95632.2
PCIE15_SATA_TXP: length 247.5
  TOP w0.104: 292.12,71.21 292.29,71.21 292.54,70.96 U13113.C38
  TOP w0.14: v1(62.19,48.08) 61.9,48.37 61.45,48.37 C95857.2 ; v1(289.36,70.88) 289.99,71.52 291.02,71.52 291.33,71.21 292.12,71.21
  IN4 w0.089: v1(289.36,70.88) 289.45,70.98 289.45,71.18 289.36,71.27 283.5,71.27 281.13,68.9 279.12,68.9 277.38,67.16 211.56,67.16 208.9,69.82 207.26,69.82 205.26,67.82 197.57,67.82 195.63,65.88 193.19,65.88 192.59,66.47 182.96,66.47 182.29,65.8 181.78,65.8 181.43,65.45 181.43,65.12 181.08,64.77 180.75,64.77 179.53,63.55 176.87,63.55 175.79,62.47 175.79,62.02 173.59,59.83 173.59,59.13 172.39,57.93 172.04,57.93 167.65,53.54 131.75,53.54 131.46,53.83 127.55,53.83 127.23,53.51 119.22,53.51 118.31,54.42 114.72,54.42 114.53,54.61 111.69,54.61 111.07,53.99 106.08,53.99 105.4,53.3 96.04,53.3 94.32,51.58 84.86,51.58 82.38,49.1 78.73,49.1 78.34,48.7 73.53,48.7 72.84,48.01 67.57,48.01 66.76,48.82 63.48,48.82 63.14,48.49 62.71,48.49 62.31,48.08 v1(62.19,48.08)
PCIE15_SATA_TXP_C: length 4.5
  TOP w0.14: U13148.9 57.72,48.35 57.59,48.48 57.59,48.65 57.79,48.85 59.33,48.85 59.51,48.67 60.48,48.67 60.81,48.35 C95857.1
PCIE15_SATA_TXP_C_RE: length 35.6
  TOP w0.14: C95633.1 36.6,23.36 v1(36.82,23.59) ; v1(57.96,41.85) 57.65,42.16 57.65,43.3 57.72,43.37 U13148.40
  IN4 w0.089: v1(57.96,41.85) 57.45,41.34 57.45,40.09 57.26,39.9 57.26,38.84 55.27,36.85 55.27,33.51 53.9,32.15 51.29,32.15 49.11,29.97 46.9,29.97 44.64,27.71 42.3,27.71 39.87,25.29 37.61,25.29 36.6,24.27 36.6,23.82 v1(36.82,23.59)
PCIE15_SATA_TXP_C_RE_C: length 3
  TOP w0.14: C95633.2 36.32,22.32 36.32,22.04 36.61,21.75 36.61,21.06 36.74,20.93 CN2070.25
PCIE16_SATA_RXN: length 267.4
  TOP w0.14: U13113.G35 294.35,69.96 v2(294.51,70.12) ; C95851.2 53.11,51.39 53.25,51.53 53.25,52.09 v1(53.08,52.26)
  IN4 w0.089: v2(294.51,70.12) 294.34,70.29 294.34,70.54 294.17,70.71 293.65,70.71 293.24,70.3 292.07,70.3 290.98,71.39 290.56,71.39 289.87,72.08 279.96,72.08 278.26,73.77 275.09,73.77 269.32,79.54 211.06,79.54 210.53,79.02 210.53,74.23 204.86,68.56 201.21,68.56 200.7,69.08 197.73,69.08 195.91,67.26 182.7,67.26 182,66.57 180.36,66.57 178.15,64.35 176.64,64.35 173.91,61.62 173.91,61.31 172.71,60.11 172.71,59.45 171.92,58.66 171.71,58.66 167.37,54.32 132.11,54.32 131.78,54.64 122.55,54.64 122.13,55.06 118.74,55.06 118.61,55.19 115.16,55.19 114.86,55.48 111.5,55.48 110.74,54.72 105.78,54.72 105.1,54.03 95.69,54.03 94.09,52.43 84.63,52.43 82.03,49.82 78.43,49.82 78.04,49.43 69.65,49.43 68.95,48.74 67.88,48.74 67.06,49.55 62.62,49.55 61.97,50.2 59.5,50.2 59.08,50.61 58.87,50.61 56.49,52.99 53.58,52.99 53.39,52.8 53.39,52.57 v1(53.08,52.26)
PCIE16_SATA_RXN_C: length 2.9
  TOP w0.14: U13148.20 53.32,48.45 53.39,48.52 53.39,50.39 C95851.1
PCIE16_SATA_RXN_C_RE: length 38.1
  TOP w0.14: v1(31.48,24.12) 31.31,24.12 30.66,23.47 R21788.1 ; v1(51.1,44.07) 51.19,44.07 51.31,43.96 51.91,43.96 52.6,43.27 53.17,43.27 53.32,43.42 U13148.29
  IN4 w0.089: v1(51.1,44.07) 50.89,43.86 50.65,43.86 50.47,43.68 50.47,42.83 50.16,42.52 50.16,39.55 48.95,38.34 48.95,36.19 47.22,34.46 44.31,34.46 43.33,33.48 42.78,33.48 42.29,32.99 40.42,32.99 39.83,32.39 38.56,32.39 37.92,31.75 37.92,28.82 36.92,27.83 36.92,27.59 36.21,26.88 34.35,26.88 32.54,25.07 32.06,25.07 31.86,24.87 31.86,24.36 31.62,24.12 v1(31.48,24.12)
PCIE16_SATA_RXN_C_RE_C: length 3.7
  TOP w0.14: R21788.2 30.73,22.33 30.73,22.09 31.03,21.78 31.41,21.78 31.85,21.35 31.85,20.92 31.74,20.81 CN2070.5
PCIE16_SATA_RXP: length 267.4
  TOP w0.14: U13113.E35 293.83,69.64 294,69.81 294,70.01 v2(293.89,70.11) ; C95852.2 53.87,51.38 53.73,51.52 53.66,51.52 53.52,51.66 53.52,52.1 53.68,52.26 v1(53.82,52.26)
  IN4 w0.089: v1(53.82,52.26) 53.56,52.52 53.56,52.73 53.65,52.82 56.42,52.82 58.8,50.45 59.01,50.45 59.43,50.03 61.9,50.03 62.55,49.38 66.99,49.38 67.81,48.57 69.02,48.57 69.72,49.27 78.11,49.27 78.5,49.66 82.1,49.66 84.7,52.26 94.16,52.26 95.75,53.86 105.16,53.86 105.85,54.55 110.81,54.55 111.57,55.31 114.79,55.31 115.09,55.02 118.54,55.02 118.67,54.89 122.06,54.89 122.48,54.47 131.71,54.47 132.04,54.15 167.43,54.15 171.78,58.49 171.99,58.49 172.88,59.38 172.88,60.04 174.08,61.24 174.08,61.55 176.71,64.19 178.22,64.19 180.43,66.4 182.07,66.4 182.77,67.1 195.98,67.1 197.79,68.91 200.63,68.91 201.14,68.39 204.93,68.39 210.7,74.16 210.7,78.95 211.13,79.37 269.25,79.37 275.02,73.61 278.19,73.61 279.89,71.91 289.8,71.91 290.49,71.22 290.91,71.22 292,70.13 293.31,70.13 293.72,70.54 294.1,70.54 294.17,70.47 294.17,70.34 293.94,70.11 v2(293.89,70.11)
PCIE16_SATA_RXP_C: length 2.9
  TOP w0.14: C95852.1 53.65,50.45 53.65,48.47 53.72,48.4 U13148.19
PCIE16_SATA_RXP_C_RE: length 38.1
  TOP w0.14: U13148.30 53.72,43.37 53.36,43.01 52.49,43.01 51.8,43.69 51.39,43.69 51.13,43.43 v1(51.13,43.37) ; v1(32.15,24.1) 32.14,24.1 31.51,23.47 R21790.1
  IN4 w0.089: v1(32.15,24.1) 32.02,24.22 32.02,24.8 32.13,24.9 32.61,24.9 34.42,26.71 36.28,26.71 37.09,27.52 37.09,27.76 38.08,28.75 38.08,31.68 38.63,32.22 39.9,32.22 40.49,32.82 42.36,32.82 42.85,33.32 43.4,33.32 44.38,34.29 47.29,34.29 49.12,36.12 49.12,38.27 50.33,39.48 50.33,42.45 50.64,42.76 50.64,43.61 50.72,43.69 51.04,43.69 51.13,43.6 v1(51.13,43.37)
PCIE16_SATA_RXP_C_RE_C: length 3.7
  TOP w0.14: CN2070.7 32.24,20.76 32.11,20.88 32.11,21.46 31.52,22.05 31.14,22.05 31,22.2 31,22.3 R21790.2
PCIE16_SATA_TXN: length 255.5
  TOP w0.14: C95850.2 54.85,51.34 54.85,52.11 v1(54.66,52.3) ; U13113.C36 292.26,70.23 291.93,70.23 291.84,70.13 291.55,70.13 291.26,70.43 287.98,70.43 287.85,70.55 287.85,70.69 v1(287.94,70.78)
  IN4 w0.089: v1(54.66,52.3) 54.9,52.06 54.9,51.15 55.32,50.73 56.58,50.73 58.13,49.17 59.42,49.17 61.16,47.42 65.27,47.42 66.1,48.25 66.47,48.25 67.32,47.4 73.6,47.4 74.34,48.14 78.57,48.14 78.96,48.53 82.63,48.53 84.56,50.46 94.02,50.46 96.24,52.68 105.6,52.68 106.34,53.43 110.05,53.43 110.8,52.68 115.01,52.68 115.9,53.57 116.71,53.57 117.32,52.95 127.78,52.95 128.1,53.27 131.21,53.27 131.52,52.96 167.9,52.96 171.69,56.75 172.29,56.75 175.78,60.25 177.27,60.25 179.22,62.2 183.53,62.2 184.19,62.86 190.74,62.86 190.9,63.02 193.56,63.02 197.21,66.67 205.06,66.67 206.28,67.89 208.51,67.89 208.93,67.46 210.14,67.46 211.06,66.54 280.11,66.54 283.71,70.14 287.5,70.14 287.66,70.31 287.66,70.5 v1(287.94,70.78)
PCIE16_SATA_TXN_C: length 3
  TOP w0.14: U13148.17 54.52,48.61 54.65,48.74 54.65,48.75 54.89,48.99 54.89,50.41 C95850.1
PCIE16_SATA_TXN_C_RE: length 35.9
  TOP w0.14: v1(32.46,23.44) 32.46,23.1 C95626.1 ; v1(53.52,39.41) 53.82,39.71 53.82,42.33 54.52,43.03 U13148.32
  IN4 w0.089: v1(53.52,39.41) 53.82,39.11 53.82,38.68 53.53,38.39 52.53,38.39 51.03,36.89 51.03,34.86 49.85,33.67 44.77,33.67 43.36,32.26 41.26,32.26 39.36,30.37 39.36,29.47 37.49,27.59 37.49,27.36 35.93,25.8 34.84,25.8 32.48,23.44 v1(32.46,23.44)
PCIE16_SATA_TXN_C_RE_C: length 3.1
  TOP w0.14: C95626.2 32.53,22.22 32.53,22.01 33.36,21.19 33.36,20.9 33.24,20.78 CN2070.11
PCIE16_SATA_TXP: length 255.5
  TOP w0.14: v1(287.27,70.76) 287.42,70.76 287.56,70.62 287.56,70.47 287.87,70.16 291.15,70.16 291.44,69.87 291.95,69.87 292.07,69.99 U13113.B36 ; v1(55.49,52.33) 55.26,52.33 55.12,52.19 55.12,51.39 C95853.2
  IN4 w0.089: v1(55.49,52.33) 55.21,52.33 55.07,52.19 55.07,51.22 55.39,50.89 56.65,50.89 58.2,49.34 59.49,49.34 61.23,47.59 65.2,47.59 66.03,48.42 66.54,48.42 67.39,47.57 73.53,47.57 74.27,48.31 78.5,48.31 78.89,48.7 82.56,48.7 84.49,50.63 93.95,50.63 96.17,52.85 105.53,52.85 106.27,53.59 110.12,53.59 110.87,52.85 114.94,52.85 115.83,53.73 116.77,53.73 117.39,53.12 127.71,53.12 128.03,53.44 131.28,53.44 131.59,53.13 167.83,53.13 171.62,56.92 172.22,56.92 175.71,60.42 177.2,60.42 179.15,62.37 183.46,62.37 184.12,63.03 190.67,63.03 190.83,63.19 193.49,63.19 197.14,66.83 204.99,66.83 206.21,68.05 208.58,68.05 209,67.63 210.21,67.63 211.13,66.71 280.04,66.71 283.64,70.31 287.43,70.31 287.5,70.37 287.5,70.68 287.42,70.76 v1(287.27,70.76)
PCIE16_SATA_TXP_C: length 2.9
  TOP w0.14: C95853.1 55.15,50.43 55.15,48.88 54.92,48.64 U13148.16
PCIE16_SATA_TXP_C_RE: length 35.9
  TOP w0.14: v1(33.12,23.45) 33.05,23.45 32.91,23.31 32.91,23.05 C95628.1 ; v1(54.29,39.41) 54.08,39.62 54.08,42.22 54.92,43.05 U13148.33
  IN4 w0.089: v1(33.12,23.45) 33.04,23.52 33.04,23.76 34.91,25.63 36,25.63 37.65,27.29 37.65,27.52 39.53,29.4 39.53,30.3 41.33,32.1 43.43,32.1 44.84,33.5 49.92,33.5 51.2,34.79 51.2,36.82 52.6,38.22 53.6,38.22 53.98,38.61 53.98,39.1 v1(54.29,39.41)
PCIE16_SATA_TXP_C_RE_C: length 3.1
  TOP w0.14: CN2070.13 33.74,20.83 33.62,20.95 33.62,21.3 32.8,22.12 32.8,22.23 C95628.2
PCIE_CLKREQ1#: length 17.6
  TOP w0.102: U13113.AW24 310.68,64.76 v2(310.66,64.79)
  IN1 w0.089: v2(310.66,64.79) 311.09,64.35 311.55,64.35 312.06,64.86 313.04,64.86 313.55,64.35 315.74,64.35 316.02,64.63 322.5,64.63 v1(323.77,65.91)
  BOTTOM w0.14: v1(323.77,65.91) 323.77,66.23 323.62,66.39 R21992.2 323.24,66.68 323.77,67.2 v1(323.77,67.23) 323.59,67.4 R21194.1
PCIE_CLKREQ2#: length 12.6
  TOP w0.102: U13113.AT24 309.13,64.23 v2(308.63,64.74)
  IN1 w0.089: v2(308.63,64.74) 309.39,65.5 315.74,65.5 v1(316.25,66.01)
  BOTTOM w0.14: v1(316.25,66.01) 316.35,66.11 316.63,66.11 316.78,66.26 R21195.1 317.35,66.54 317.7,66.89 319.04,66.89 R21208.2
PCIE_CLKREQ3#: length 8.8
  TOP w0.102: v1(316.45,65.02) 315.81,64.38 313.18,64.38 312.95,64.62 U13113.BD25
  TOP w0.14: R21209.2 319.29,66 318.84,65.55 317.72,65.55 317.42,65.85 R21200.1 317.14,66.26 316.99,66.11 316.99,65.55 v1(316.45,65.02)
PCIE_CLKREQ4#: length 15.1
  TOP w0.102: v2(311.68,63.69) 311.93,63.95 U13113.BB24
  IN1 w0.089: v1(321.58,64.23) 321.05,63.69 315.82,63.69 315.21,63.08 312.29,63.08 v2(311.68,63.69)
  BOTTOM w0.14: R21193.1 324.51,64.23 324.15,64.58 v1(324.05,64.58) 322.6,64.58 322.34,64.32 R21211.2 321.79,64.02 v1(321.58,64.23)
PCIE_CLKREQ5#: length 4.5
  TOP w0.102: U13113.BE25 313.67,64.62 v1(313.84,64.79)
  BOTTOM w0.14: v1(313.84,64.79) 313.84,64.99 314.35,65.5 314.99,65.5 315.11,65.37 R21201.1
PCIE_CLKREQ6#: length 12.3
  TOP w0.104: U13113.AT33 309.01,68.78 309.36,69.13 v2(309.36,69.16)
  BOTTOM w0.14: R21202.1 318.79,72.99 318.33,72.53 v1(318.1,72.53) 317.39,72.53 316.71,71.85 315.73,71.85 313.98,70.1 312.25,70.1 312.12,69.97 310.69,69.97 310.41,69.69 309.89,69.69 v2(309.36,69.16)
PCIE_CLKREQ7#: length 14.6
  TOP w0.14: v2(308.74,68.06) 308.71,68.06 U13113.AR31
  BOTTOM w0.14: v2(308.74,68.06) 308.74,68.5 308.88,68.65 313.41,68.65 v1(313.63,68.88) 313.65,68.89 314.66,68.89 316.1,70.32 317.93,70.32 318.03,70.22 318.91,70.22 R21203.1 319.45,70.48 320.16,71.19 320.16,72.01 R21213.2
PCIE_CLKREQ8#: length 9.4
  TOP w0.102: U13113.BD32 313.05,68.02 313.18,67.89 313.33,67.89 313.37,67.85 314.41,67.85 314.63,68.07 314.63,68.85 315.97,70.2 316.89,70.2
  TOP w0.14: 316.89,70.2 317.14,69.94 v1(317.57,69.94) 317.62,69.99 318.61,69.99 319.04,69.56 R21990.2 319.35,69.7 319.35,69.96 319.73,70.34 R21204.1
PCIE_CLKREQ9#: length 6.2
  TOP w0.102: 316.76,70.7 316.19,70.7 314.39,68.9 314.3,68.9 313.92,68.53 313.35,68.53 313.1,68.27 312.49,68.27 U13113.BC32
  TOP w0.14: 316.76,70.7 R21205.1
PCIE_CLKREQ10#: length 7.8
  TOP w0.102: R21207.1 316.17,69.16 315.78,69.55 315.58,69.55 314.81,68.78 314.81,67.97 314.5,67.65 313.21,67.65 313.17,67.69 313.09,67.69 313.05,67.73 312.01,67.73 U13113.BB31
  TOP w0.14: R21207.1 317.27,68.87 v1(317.75,68.39)
PCIE_CLKREQ11#: length 6.1
  TOP w0.102: 316.38,71.47 316.06,71.15 316.06,71.14 314.22,69.31 314.13,69.31 313.76,68.93 312.77,68.93 U13113.BC33
  TOP w0.14: 316.38,71.47 316.61,71.7 R21210.1
PCIE_CLKREQ12#: length 8.6
  TOP w0.102: v2(310.66,69.1) 311.04,68.73 U13113.BA33
  BOTTOM w0.14: v2(310.66,69.1) 310.66,69.43 310.92,69.69 312.24,69.69 312.36,69.82 314.37,69.82 v1(314.95,70.4) 316.05,71.49 316.94,71.49 R21212.1
PCIE_CLKREQ13#: length 7.5
  TOP w0.102: v2(310.92,68.16) 310.53,68.55 U13113.AW33
  IN1 w0.089: v1(316.38,69.69) 313.58,69.69 312.69,68.8 311.55,68.8 v2(310.92,68.16)
  BOTTOM w0.14: R21214.1 v1(316.38,69.69)
PCIE_CLKREQ14#: length 6.4
  TOP w0.102: v2(312.36,69.26) 312.36,69.06 U13113.BB33
  BOTTOM w0.14: v2(312.36,69.26) 312.64,69.54 314.75,69.54 316.2,70.98 v1(316.33,70.98) 316.35,71.01 317.12,71.01 R21215.1
PCIE_CLKREQ15#: length 8.1
  TOP w0.102: 317.52,71.23 316.43,71.23 316.26,71.06 316.26,71.06 314.31,69.1 314.21,69.1 313.84,68.73 313.17,68.73 U13113.BD33
  TOP w0.14: 318.92,71.26 318.92,71.51 319.33,71.92 R21216.1 ; 318.92,71.26 v1(318.91,71.26) ; 318.92,71.26 318.89,71.23 317.52,71.23
PCIE_CLKREQ_LAN#: length 33.5
  TOP w0.14: v1(320.75,65.24) 320.75,65.68 R21209.1 ; Q7848.3 345.74,75.48 345.46,75.76 v1(344.95,75.76) 344.93,75.76 v1(344.41,75.24)
  IN5 w0.089: v1(344.41,75.24) 344.85,74.8 344.85,74.39 343.09,72.63 343,72.63 340.93,70.56 336.4,70.56 335.02,69.18 332.49,69.18 331.32,68.02 331.32,67.36 330.12,66.16 327.18,66.16 327.1,66.08 325.07,66.08 324.86,66.29 323.97,66.29 323.84,66.41 323.26,66.41 323.11,66.26 321.91,66.26 321.53,65.88 321.38,65.88 v1(320.75,65.24)
  BOTTOM w0.14: R22095.1 344.42,75.26 v1(344.41,75.24)
PCIE_CLKREQ_NGFF1#: length 384.5
  TOP w0.14: v1(48.93,62.81) 49.5,62.24 R22212.1 R22211.1
  IN1 w0.089: v1(53.06,31.59) 53.06,31.39 53.41,31.03 55.01,31.03 55.87,30.17 56.13,30.17 57.35,28.95 58.19,28.95 58.69,28.44 58.69,26.84 59.63,25.9 59.63,23.61 61.03,22.22 61.03,20.06 61.79,19.3 69.03,19.3 69.49,18.84 CN2069.52
  IN2 w0.089: v1(40.84,57.98) 41.09,58.23 42.73,58.23 47.31,62.81 v1(48.93,62.81) 49.66,63.54 52.06,63.54 54.81,66.29 60.74,66.29 61.16,66.71 65.09,66.71 65.94,65.86 65.94,62.36 66.53,61.78 66.53,60.68 69.68,57.52 71.57,57.52 72.74,56.36 72.74,53.08 73.62,52.19 81.16,52.19 83.3,54.33 92.2,54.33 95.4,57.54 105.69,57.54 108.39,60.24 116.58,60.24 v1(117.14,60.8)
  IN4 w0.089: v1(319.55,71.34) 319.55,70.83 318.92,70.2 314.12,70.2 313.74,69.82 309.65,69.82 309.44,70.02 307.69,70.02 306.98,69.31 306.98,67.67 306.55,67.24 302.54,67.24 302.29,66.98 301.26,66.98 301,67.24 300.65,67.24 297.9,69.98 297.9,71.08 293.37,75.61 291.4,75.61 290.16,76.85 289,76.85 288.89,76.75 286.25,76.75 285.89,77.11 285.44,77.11 285.28,77.26 280.79,77.26 273.97,84.08 209.53,84.08 201.91,76.46 197.09,76.46 195.27,74.64 190.78,74.64 189.64,73.5 187.25,73.5 186.58,72.83 183.61,72.83 183.44,73 178.38,73 176.59,71.21 176.59,70.6 175.02,69.03 173.92,69.03 171.22,66.32 171.22,66.05 166.46,61.29 159.14,61.29 158.06,60.21 152.53,60.21 151.93,59.61 146.32,59.61 145.65,60.28 132.22,60.28 131.93,59.99 128.16,59.99 127.79,59.62 124.38,59.62 123.63,60.37 118.88,60.37 118.27,60.98 117.32,60.98 v1(117.14,60.8)
  BOTTOM w0.14: v1(319.55,71.34) 319.55,71.39 319.29,71.65 R21213.1 ; v1(40.84,57.98) 40.84,54.91 42.84,52.9 42.84,51.58 43.07,51.35 43.07,47.39 45,45.46 45.82,45.46 46.88,44.39 46.88,42.97 47.54,42.31 49.42,42.31 50.06,41.67 50.06,41.63 50.38,41.3 50.38,40.46 53.06,37.79 v1(53.06,31.59)
PCIE_CLKREQ_NGFF2#: length 396.9
  TOP w0.14: R21990.1 320.17,69.74 v1(320.82,69.74) ; v1(29.23,58.89) 29.77,58.36 R22214.1 30.98,58.36 31.26,58.64 R22213.2
  IN2 w0.089: v1(34.79,52.34) 34.95,52.19 41.02,52.19 42.18,51.02 43.76,51.02 44.42,51.68 44.42,54.17 44.15,54.44 44.15,56.51 44.98,57.34 44.98,58.13 45.82,58.97 45.82,60.47 47.51,62.17 49.18,62.17 49.38,62.37 52.67,62.37 55.99,65.69 60.99,65.69 61.41,66.11 64.83,66.11 65.32,65.63 65.32,61.04 67.78,58.58 67.78,56.14 68.86,55.07 68.86,54.42 70.57,52.7 72.26,52.7 73.37,51.6 81.41,51.6 83.52,53.72 92.42,53.72 95.65,56.94 105.94,56.94 108.64,59.64 116.85,59.64 v1(117.77,60.57)
  IN4 w0.089: v1(117.77,60.57) 118.59,59.76 123.39,59.76 124.13,59.02 129.7,59.02 129.83,59.15 132.61,59.15 133.15,59.69 145.4,59.69 146.08,59.01 152.17,59.01 152.78,59.62 158.94,59.62 159.11,59.44 161.51,59.44 162.77,60.7 166.71,60.7 171.81,65.8 171.81,66.08 174.17,68.43 175.27,68.43 178.33,71.5 178.33,72.1 178.58,72.36 179.09,72.36 179.24,72.21 189.8,72.21 190.84,73.24 193.19,73.24 193.82,73.88 200.17,73.88 209.75,83.46 273.75,83.46 280.54,76.67 285.01,76.67 285.17,76.51 285.64,76.51 286.01,76.15 287.33,76.15 287.74,75.74 289.78,75.74 290.51,75.02 292.02,75.02 293.41,73.63 294.28,73.63 294.91,72.99 294.91,71.34 296.44,69.82 297.23,69.82 300.41,66.64 300.76,66.64 301.01,66.39 302.53,66.39 302.79,66.64 306.97,66.64 307.91,67.58 313,67.58 314.84,69.42 315.94,69.42 316.28,69.08 320.16,69.08 v1(320.82,69.74)
  BOTTOM w0.14: v1(29.23,58.89) 25.66,58.89 24.77,58.01 24.77,54.26 25.47,53.56 28.16,53.56 29.71,52.01 31.92,52.01 32.56,52.65 34.49,52.65 v1(34.79,52.34) 34.79,50.13 35.1,49.83 35.1,49.39 35.45,49.04 35.45,46.88 34.61,46.04 34.61,43.82 34.18,43.4 34.18,40.22 35.35,39.06 35.35,32.78 37.56,30.57 37.56,29.61 39.54,27.63 41.04,27.63 42.21,26.46 42.21,25.97 42.46,25.71 42.46,24.6 42.31,24.45 42.31,23.92 42.39,23.84 42.39,22.49 42.64,22.24 42.64,19.84 43.49,18.99 CN2070.52
PCIE_CLKREQ_TBT#: length 24.9
  TOP w0.102: U13113.BC24 312.57,64.05 312.74,64.22 313.05,64.22 313.1,64.18 317.06,64.18 317.14,64.1 R21198.1 317.3,64.38 317.49,64.58
  TOP w0.14: 317.49,64.58 318.71,64.58 319.5,65.37 v1(320.09,65.37) ; v1(327.81,67.75) 328,67.94 329.33,67.94 329.89,67.38 330.11,67.38 330.72,66.77 331.72,66.77 332.2,66.29 332.76,66.29 Q7917.1 333.4,66.46 333.58,66.27 R67050.2
  IN5 w0.089: v1(327.81,67.75) 324.85,67.75 324.38,67.28 322.6,67.28 322.09,66.77 320.44,66.77 320.09,66.41 v1(320.09,65.37)
PCIE_CLKREQ_TBT#_C: length 24.7
  TOP w0.079: U21.AC5 344.61,56.38 344.38,56.61
  TOP w0.14: 344.38,56.61 344.35,56.64 343.52,56.64 v1(342.84,57.32) ; v1(338.37,66.13) 337.08,66.13 336.43,65.49 R67049.1 R67050.1 333.48,64.94 332.05,64.94 331.58,65.41 Q7917.3
  IN4 w0.089: v1(342.84,57.32) 341.32,57.32 341.01,57.63 338.62,57.63 336.93,59.33 336.93,61.84 337.92,62.83 337.92,64.63 338.37,65.09 v1(338.37,66.13)
PCIE_CLKREQ_VGA#: length 234.5
  TOP w0.14: Q7851.3 158.9,104.23 v1(158.72,104.06)
  IN2 w0.089: v1(158.72,104.06) 158.72,104.69 162.11,108.08 165.61,108.08 166.31,107.38 169.34,107.38 170.17,106.54 170.17,104.36 170.96,103.57 172.92,103.57 176.37,100.12 199.71,100.12 202.67,97.17 206.11,97.17 209.71,93.56 209.71,72.85 207.49,70.63 207.49,54.38 209.57,52.3 241.45,52.3 242.15,51.6 247.15,51.6 249.41,53.86 263.33,53.86 263.66,54.19 278.34,54.19 282.09,57.93 286.66,57.93 286.97,57.62 288.35,57.62 289.39,56.58 291.14,56.58 291.61,56.1 291.61,55.59 292.97,54.23 292.97,54.04 293.18,53.83 293.42,53.83 293.72,53.53 294.02,53.53 295.42,54.93 295.42,56.86 296.31,57.75 301.39,57.75 302.03,58.39 303.98,58.39 304.19,58.59 304.19,61.16 305.98,62.96 306.36,62.96 306.87,63.47 306.87,63.77 308.25,65.15 312.34,65.15 312.57,65.37 316.89,65.37 318.41,66.89 321.08,66.89 321.2,66.77 321.71,66.77 322.6,65.88 322.6,64.86 v1(323.74,63.72)
  BOTTOM w0.14: R21211.1 323.44,64.02 v1(323.74,63.72)
PCIE_CLKREQ_WIGIG#: length 303.1
  TOP w0.14: v1(47.26,49.24) v1(47.95,49.24) 47.95,49.66 Q7890.3
  IN2 w0.089: v1(321.46,66.36) 320.92,65.83 319.96,65.83 319.64,65.51 319.64,63.78 318.98,63.12 318.48,63.12 317.86,62.51 317.86,57.89 318.74,57.02 318.74,55.41 317.96,54.64 315.77,54.64 313.97,52.84 313.55,52.84 312.34,51.63 309.98,51.63 306.7,48.35 302.9,48.35 301.32,46.77 289.36,46.77 287.29,48.84 270.77,48.84 270.4,48.47 268.88,48.47 267.74,47.34 264.31,47.34 263.99,47.65 258.77,47.65 257.56,46.45 203.76,46.45 202.85,47.36 196.16,47.36 195.24,48.28 189.38,48.28 188.73,48.92 183.87,48.92 183.34,49.45 182.54,49.45 182.32,49.67 176.22,49.67 175.98,49.43 98.86,49.43 96.2,46.77 87.51,46.77 85.29,44.56 81.76,44.56 80.87,43.67 76.92,43.67 76.52,43.27 69.84,43.27 68.57,42 65.53,42 64.82,42.71 62.63,42.71 61.62,43.73 61.62,47.18 59.28,49.52 47.54,49.52 v1(47.26,49.24)
  BOTTOM w0.14: v1(321.46,66.36) 322.44,66.36 R21992.1
PCIE_CLKREQ_WLAN#: length 287.3
  TOP w0.14: v1(63.6,45.94) 63.7,46.04 63.7,48.64 62.31,50.02 Q7888.3
  IN2 w0.089: v1(63.6,45.94) 64.64,44.9 64.64,44.16 65.68,43.12 66.19,43.12 67.55,44.49 73.13,44.49 73.36,44.71 76.61,44.71 77.18,44.14 80.68,44.14 81.57,45.03 85.1,45.03 87.31,47.24 96,47.24 98.66,49.9 175.79,49.9 176.03,50.14 178.54,50.14 179.24,50.84 185.16,50.84 186.61,49.39 189.91,49.39 190.22,49.09 195.09,49.09 196.36,47.83 203.24,47.83 204.15,46.92 233.19,46.92 233.77,47.5 238.35,47.5 238.93,46.92 257.36,46.92 258.57,48.12 264.21,48.12 264.56,48.48 268.09,48.48 268.56,48.94 270.2,48.94 270.57,49.31 287.5,49.31 288.81,48 296.31,48 297.07,47.24 301.12,47.24 302.71,48.82 306.5,48.82 308.21,50.52 308.21,51.66 308.99,52.44 309.88,52.44 310.22,52.79 312.76,52.79 313.46,53.48 313.95,53.48 315.57,55.11 317.77,55.11 318.23,55.57 318.23,56.86 317.39,57.7 317.39,62.7 318.28,63.59 318.79,63.59 319.17,63.97 319.17,65.71 319.83,66.36 v1(320.8,66.36)
  BOTTOM w0.14: v1(320.8,66.36) 320.35,66.36 R21208.1
PCIE_LAN_WAKE#_R: length 15.5
  TOP w0.14: v1(344.42,74.57) 344.18,74.33 Q7849.1 ; v1(349.41,67.3) 349.34,67.38 349.34,68.09 349.41,68.16 U13143.3
  IN1 w0.089: v1(349.41,67.3) 349.19,67.52 349.19,68.11 347.49,69.82 347.49,71.49 v1(344.42,74.57)
  BOTTOM w0.14: v1(343.05,73.02) 343.11,73.02 R21486.2 ; R21486.2 343.94,74.68 343.65,74.98 R22096.2 ; R21486.2 344.27,73.85 344.42,74.01 v1(344.42,74.57)
PCIE_REQ_LAN#_R: length 13.3
  TOP w0.14: v1(349.81,67.83) U13143.4 ; v1(346.43,74.59) 346.24,74.41 Q7848.1 346.89,73.89 v1(347.14,74.13)
  IN1 w0.089: v1(349.81,67.83) 349.81,68.38 348.13,70.07 348.13,71.72 346.43,73.42 v1(346.43,74.59)
  BOTTOM w0.14: v1(346.43,74.59) 346.43,74.44 345.89,73.91 R21484.2 345.76,74.39 345.83,74.46 R22095.2
PCIE_RXN1_TBT: length 78.5
  TOP w0.14: U13113.K19 295.86,61.68 v2(296.35,61.19) ; v1(343.05,45.69) 342.84,45.48 342.84,45.33 342.98,45.19 344.36,45.19 C94573.2
  IN2 w0.089: v2(296.35,61.19) 297.07,60.47 299.33,60.47 299.54,60.25 300.84,60.25 301.52,60.93 302.44,60.93 304.69,63.18 304.69,63.97 305.74,65.02 305.74,65.27 307.57,67.11 308.21,67.11 308.6,67.5 310.22,67.5 310.27,67.56 311.58,67.56 311.63,67.5 312.74,67.5 318.7,73.46 321.53,73.46 322.33,74.26 325.9,74.26 327.69,72.47 327.69,70.44 328.83,69.3 328.83,68.17 329.52,67.49 329.52,65.56 331.45,63.62 331.45,61.36 332.31,60.5 334.02,60.5 336.05,58.48 336.05,54.49 337.16,53.37 337.16,51.19 340.54,47.81 340.54,46.03 341.65,44.92 342.82,44.92 343.01,45.11 343.01,45.65 v1(343.05,45.69)
PCIE_RXN1_TBT_C: length 4.7
  TOP w0.079: U21.V22 347.06,48.34 347.06,47.92 346.15,47 346.15,46.11 346.1,46.06 346.1,46.04
  TOP w0.14: C94573.1 345.2,45.28 345.84,45.28 346.1,45.53 346.1,46.04
PCIE_RXN2_TBT: length 85.5
  TOP w0.14: U13113.G22 294.27,62.83 294.27,62.43 v2(294.36,62.34) ; C94575.2 348.48,44.62 348.48,44.49 v1(348.3,44.31)
  IN2 w0.089: v2(294.36,62.34) 294.25,62.34 293.91,62.69 293.91,62.82 294.05,62.96 294.91,62.96 295.36,62.51 295.36,62.02 295.73,61.65 302.25,61.65 303.3,62.7 303.3,64.89 303.51,65.1 304.4,65.1 307.85,68.55 312.68,68.55 316.16,72.03 316.16,72.67 318.14,74.64 320.64,74.64 321.02,75.02 326.05,75.02 328.66,72.41 328.66,71.65 328.81,71.5 328.81,70.23 329.48,69.55 329.48,68.82 329.92,68.38 330.4,68.38 331.07,67.71 331.07,66.05 335.71,61.41 335.71,60.99 337.37,59.33 337.37,54.94 340.16,52.14 340.16,49.27 342.65,46.79 343.21,46.79 345.13,44.87 348.73,44.87 348.82,44.78 348.82,44.69 348.44,44.31 v1(348.3,44.31)
PCIE_RXN2_TBT_C: length 3.6
  TOP w0.079: 348.43,46.23 348.43,46.74 348.49,46.81 348.81,47.13 348.81,47.69 348.89,47.77 348.89,48.33 U21.P22
  TOP w0.14: 348.43,46.23 348.43,46.18 348.18,45.94 C94575.1
PCIE_RXN3_TBT: length 94.3
  TOP w0.14: v2(297.05,62.32) 297.05,62.47 U13113.L22 ; v1(350.62,44.42) 350.35,44.68 350.35,44.89 350.54,45.08 C94577.2
  IN2 w0.089: v1(350.62,44.42) 350.31,44.42 350.26,44.37 350.26,44.25 350.05,44.04 350.05,43.87 350.14,43.77 351.36,43.77 351.66,44.07 351.66,44.46 351.23,44.88 350.96,44.88 350.33,45.51 346.55,45.51 345.92,46.14 345.92,46.5 344.57,47.84 342.49,47.84 340.81,49.52 340.81,52.61 338.73,54.69 338.73,57.26 338.36,57.63 338.36,59.24 336.34,61.26 336.34,61.69 332.85,65.18 332.85,65.96 331.96,66.84 331.96,68.59 330.09,70.45 330.09,77.64 329.76,77.97 327.55,77.97 326.39,76.81 319.05,76.81 312.02,69.78 310.73,69.78 310.55,69.6 309.75,69.6 309.32,70.03 308.76,70.03 308.54,69.82 307.47,69.82 306.92,69.27 306.03,69.27 305.5,68.73 305.5,67.56 304.03,66.09 303.61,66.09 302.66,65.15 302.66,62.98 302.34,62.66 299.91,62.66 299.65,62.92 296.5,62.92 296.36,62.78 296.36,62.7 296.57,62.5 296.57,62.4 296.68,62.29 297.01,62.29 v2(297.05,62.32)
PCIE_RXN3_WLAN: length 264
  TOP w0.14: CN2068.43 59.59,63.75 59.43,63.59 59,63.59 v1(58.52,64.08) ; v2(296.51,60.04) 296.72,60.24 U13113.L17
  IN1 w0.089: v2(296.51,60.04) 296.38,59.91 296.38,59.68 296.14,59.43 293.11,59.43 291.99,60.54 290.98,60.54 290.71,60.81 286.67,60.81 286.28,60.42 284.36,60.42 283.49,59.56 283.05,59.56 278.75,55.26 278.75,54.77 277.44,53.46 264.38,53.46 263.96,53.04 210.52,53.04 209.93,53.64 205.19,53.64 204.14,54.69 199.39,54.69 196,58.08 193.92,58.08 193.72,57.88 192.55,57.88 192.43,57.75 191.85,57.75 191.61,57.99 188.72,57.99 188.49,57.75 183.98,57.75 183.21,56.99 176.72,56.99 176.21,57.5 174.01,57.5 172.69,56.18 171.55,56.18 168.13,52.75 127.99,52.75 127.02,51.78 98.02,51.78 95.24,49 83.11,49 82.69,48.58 79.32,48.58 78.79,48.05 73.27,48.05 72.79,47.57 68.91,47.57 67.52,48.96 65.45,48.96 63.4,51.01 63.4,54.28 59.79,57.89 59.79,62.24 58.73,63.29 58.73,63.86 v1(58.52,64.08)
PCIE_RXN4_LAN: length 70
  TOP w0.14: U13113.E20 293.62,61.63 v2(293.92,61.33) ; C94976.1 348.98,75.77 348.98,76.15 348.71,76.42 347.66,76.42 347.04,75.8 347.04,75.34 v1(346.86,75.16)
  IN5 w0.089: v2(293.92,61.33) 294.11,61.52 294.11,61.71 294.34,61.94 302.68,61.94 303.02,62.27 305.35,62.27 305.71,61.92 313.19,61.92 313.39,62.11 316.05,62.11 316.42,62.48 317.48,62.48 317.97,61.98 318.97,61.98 319.74,62.74 322.14,62.74 322.68,63.28 322.68,63.67 323.4,64.4 325.4,64.4 326.09,63.71 326.09,63.3 326.38,63.01 329.53,63.01 331.74,65.22 333.79,65.22 335.9,67.33 336.13,67.33 338.33,69.53 342.14,69.53 342.9,68.77 346.59,68.77 347.38,69.56 347.38,73.35 347.12,73.61 347.12,74.89 v1(346.86,75.16)
PCIE_RXN4_LAN_R: length 1.4
  TOP w0.14: C94976.2 348.88,74.94 348.88,74.81 349.01,74.68 U13143.29
PCIE_RXN4_TBT: length 93.7
  TOP w0.14: C94579.2 351.8,44.46 351.8,42.88 v1(351.76,42.84) ; v2(296.16,64.76) 295.86,64.46 U13113.K24
  IN2 w0.089: v1(351.76,42.84) 351.86,42.94 351.86,43.36 352.3,43.8 352.3,44.81 351.44,45.67 351.22,45.67 349.8,47.08 349.8,47.63 349.63,47.8 345.52,47.8 344.84,48.48 343.01,48.48 342.59,48.9 342.59,51.73 339.37,54.95 339.37,58.14 339.7,58.47 339.7,59.23 333.61,65.32 333.61,66.63 333.1,67.14 333.1,68.46 331.24,70.32 331.24,71.09 330.86,71.47 330.86,77.78 330.03,78.61 327.29,78.61 326.13,77.44 318.67,77.44 314.73,73.5 312.69,73.5 312.31,73.88 308,73.88 307.37,73.24 306.47,73.24 305.46,72.23 305.46,71.74 304.3,70.59 304.3,69.32 301.88,66.89 300.61,66.89 299.09,65.37 298.09,65.37 297.88,65.16 297.88,64.67 297.27,64.06 296.67,64.06 296.37,64.36 296.37,64.6 296.21,64.76 v2(296.16,64.76)
PCIE_RXP1_TBT: length 78.5
  TOP w0.14: U13113.L19 296.71,61.8 296.95,61.56 v2(296.95,61.18) ; C94574.2 344.4,44.92 342.87,44.92 342.58,45.22 342.58,45.4 v1(342.29,45.69)
  IN2 w0.089: v1(342.29,45.69) 342.48,45.69 342.83,45.34 342.84,45.32 342.84,45.18 342.75,45.09 341.72,45.09 340.71,46.1 340.71,47.88 337.33,51.26 337.33,53.44 336.21,54.55 336.21,58.55 334.09,60.67 332.38,60.67 331.62,61.43 331.62,63.69 329.69,65.62 329.69,67.56 329,68.24 329,69.37 327.86,70.51 327.86,72.54 325.97,74.43 322.26,74.43 321.46,73.63 318.63,73.63 312.68,67.67 311.7,67.67 311.65,67.72 310.2,67.72 310.15,67.67 308.54,67.67 308.14,67.28 307.5,67.28 305.57,65.34 305.57,65.09 304.53,64.04 304.53,63.25 302.37,61.09 301.45,61.09 300.77,60.42 299.61,60.42 299.39,60.64 297.14,60.64 296.95,60.83 v2(296.95,61.18)
PCIE_RXP1_TBT_C: length 4.7
  TOP w0.079: 346.36,46.04 346.36,46.06 346.31,46.11 346.31,46.94 347.29,47.92 U21.V23
  TOP w0.14: 346.36,46.04 346.36,45.42 345.95,45.01 345.34,45.01 C94574.1
PCIE_RXP2_TBT: length 85.5
  TOP w0.14: U13113.E22 293.74,62.73 v2(293.74,62.34) ; C94576.2 348.75,44.74 348.75,44.56 v1(348.99,44.31)
  IN2 w0.089: v1(348.99,44.31) 348.99,44.85 348.8,45.04 345.2,45.04 343.28,46.96 342.72,46.96 340.33,49.34 340.33,52.21 337.54,55.01 337.54,59.4 335.87,61.06 335.87,61.48 331.24,66.12 331.24,67.78 330.47,68.55 329.99,68.55 329.65,68.89 329.65,69.62 328.98,70.3 328.98,71.57 328.82,71.72 328.82,72.48 326.12,75.19 320.95,75.19 320.57,74.81 318.07,74.81 316,72.74 316,72.1 312.61,68.71 307.78,68.71 304.33,65.27 303.44,65.27 303.14,64.96 303.14,62.77 302.18,61.82 295.8,61.82 295.52,62.09 295.52,62.58 294.98,63.13 293.98,63.13 293.74,62.89 v2(293.74,62.34)
PCIE_RXP2_TBT_C: length 3.5
  TOP w0.079: 348.69,46.26 348.58,46.36 348.58,46.67 348.77,46.85 348.97,47.06 348.97,47.63 349.05,47.7 349.05,48.03 U21.P23
  TOP w0.14: 348.69,46.26 348.69,46.07 348.44,45.83 348.44,45.72 348.58,45.59 348.58,45.44 348.64,45.38 C94576.1
PCIE_RXP3_TBT: length 94.2
  TOP w0.14: v1(349.88,44.42) 350.08,44.62 350.08,44.88 C94578.2 ; v2(296.19,62.35) 296.19,62.65 295.95,62.9 U13113.K22
  IN2 w0.089: v1(349.88,44.42) 349.88,43.8 350.07,43.6 351.43,43.6 351.83,44 351.83,44.53 351.3,45.05 351.03,45.05 350.4,45.68 346.62,45.68 346.08,46.21 346.08,46.57 344.64,48.01 342.56,48.01 340.98,49.59 340.98,52.68 338.9,54.76 338.9,57.33 338.52,57.7 338.52,59.31 336.51,61.33 336.51,61.76 333.01,65.25 333.01,66.02 332.13,66.91 332.13,68.66 330.26,70.52 330.26,77.71 329.83,78.14 327.48,78.14 326.32,76.97 318.98,76.97 311.95,69.94 310.66,69.94 310.48,69.77 309.82,69.77 309.39,70.2 308.69,70.2 308.47,69.98 307.4,69.98 306.85,69.43 305.96,69.43 305.33,68.8 305.33,67.63 303.96,66.26 303.54,66.26 302.49,65.22 302.49,63.05 302.27,62.83 299.98,62.83 299.72,63.08 296.43,63.08 296.19,62.85 v2(296.19,62.35)
PCIE_RXP3_WLAN: length 264
  TOP w0.14: v1(59.2,64.08) 59.38,64.25 CN2068.41 ; U13113.K17 296.09,60.75 296.29,60.75 296.42,60.62 296.42,60.48 295.98,60.04 v2(295.83,60.04)
  IN1 w0.089: v2(295.83,60.04) 295.94,60.15 296.02,60.15 296.09,60.09 296.09,59.96 296.22,59.83 296.22,59.75 296.07,59.6 293.18,59.6 292.06,60.71 291.05,60.71 290.78,60.98 286.6,60.98 286.21,60.59 284.29,60.59 283.42,59.72 282.98,59.72 278.58,55.33 278.58,54.84 277.37,53.62 264.31,53.62 263.89,53.21 210.59,53.21 210,53.8 205.26,53.8 204.21,54.86 199.46,54.86 196.07,58.25 193.85,58.25 193.65,58.05 192.48,58.05 192.36,57.92 191.92,57.92 191.68,58.15 188.65,58.15 188.42,57.92 183.91,57.92 183.14,57.16 176.79,57.16 176.28,57.66 173.94,57.66 172.62,56.34 171.49,56.34 168.06,52.91 127.92,52.91 126.95,51.95 97.95,51.95 95.17,49.17 83.04,49.17 82.62,48.75 79.25,48.75 78.72,48.22 73.2,48.22 72.72,47.74 68.98,47.74 67.59,49.13 65.52,49.13 63.57,51.08 63.57,54.35 59.96,57.96 59.96,62.31 58.9,63.36 58.9,64.03 59.04,64.16 59.11,64.16 v1(59.2,64.08)
PCIE_RXP4_LAN: length 69.9
  TOP w0.14: v1(347.71,75.16) 347.52,75.16 347.31,75.37 347.31,75.69 347.77,76.15 348.6,76.15 348.71,76.04 348.71,75.72 348.62,75.63 C94975.1 ; v2(294.55,61.29) 294.45,61.29 294.33,61.41 U13113.G19
  IN5 w0.089: v1(347.71,75.16) 347.42,75.16 347.29,75.03 347.29,73.68 347.54,73.42 347.54,69.49 346.66,68.6 342.69,68.6 341.93,69.36 338.4,69.36 336.2,67.16 335.97,67.16 333.86,65.05 331.81,65.05 329.6,62.84 326.32,62.84 325.92,63.23 325.92,63.64 325.33,64.23 323.47,64.23 322.85,63.6 322.85,63.21 322.21,62.58 319.81,62.58 319.04,61.81 317.9,61.81 317.41,62.31 316.49,62.31 316.12,61.94 313.46,61.94 313.26,61.75 305.64,61.75 305.28,62.1 303.09,62.1 302.75,61.77 294.41,61.77 294.28,61.64 294.28,61.43 294.43,61.29 v2(294.55,61.29)
PCIE_RXP4_LAN_R: length 1.4
  TOP w0.14: U13143.30 348.61,74.99 348.43,75.18 C94975.2
PCIE_RXP4_TBT: length 93.7
  TOP w0.14: v2(296.77,64.81) 296.62,64.66 U13113.L24 ; v1(352.39,43.04) 352.06,43.37 352.06,44.44 C94580.2
  IN2 w0.089: v2(296.77,64.81) 296.54,64.58 296.54,64.43 296.74,64.23 297.2,64.23 297.71,64.74 297.71,65.23 298.02,65.54 299.02,65.54 300.54,67.06 301.81,67.06 304.14,69.39 304.14,70.66 305.29,71.81 305.29,72.3 306.4,73.41 307.3,73.41 307.93,74.05 312.38,74.05 312.76,73.67 314.66,73.67 318.6,77.61 326.06,77.61 327.22,78.77 330.1,78.77 331.02,77.85 331.02,71.54 331.4,71.16 331.4,70.39 333.27,68.53 333.27,67.21 333.78,66.7 333.78,65.39 339.87,59.3 339.87,58.4 339.54,58.07 339.54,55.02 342.76,51.8 342.76,48.97 343.08,48.65 344.91,48.65 345.59,47.97 349.7,47.97 349.97,47.7 349.97,47.15 351.29,45.84 351.51,45.84 352.47,44.88 352.47,43.73 352.03,43.29 352.03,43.13 352.11,43.04 v1(352.39,43.04)
PCIE_TXN1_TBT: length 86.7
  TOP w0.079: v1(344.8,46.99) 344.9,46.88 345.13,46.88 346.13,47.88 346.13,48.33 U21.Y22
  TOP w0.14: C94800.1 285.15,62.44 285.05,62.44 282.3,59.69 282.3,55.52 281.62,54.84 281.62,54.31 281.29,53.98 281.29,52.91 283.15,51.05 287.04,51.05 289.37,48.71 293.36,48.71 295.51,46.56 296.32,46.56 296.65,46.23 296.65,46.01 297.06,45.61 v1(297.24,45.61)
  IN4 w0.089: v1(344.8,46.99) 344.8,46.83 344.9,46.73 345.08,46.73 345.41,47.06 345.41,47.4 345.01,47.81 339.23,47.81 338.1,48.94 330.17,48.94 329.3,48.06 324.92,48.06 322.22,45.36 310.78,45.36 309.41,46.73 300.9,46.73 300.26,46.09 297.06,46.09 296.97,46.01 296.97,45.79 297.15,45.61 v1(297.24,45.61)
PCIE_TXN1_TBT_C: length 7.7
  TOP w0.081: U13113.D22 292.96,63.06 292.67,62.77 288.91,62.77 288.77,62.63 288.77,62.56 288.76,62.55
  TOP w0.14: 288.76,62.55 288.42,62.21 288.32,62.21 288.18,62.07 287.44,62.07 287.3,62.21 286.11,62.21 C94800.2
PCIE_TXN2_TBT: length 96.4
  TOP w0.079: 347.61,47.02 347.77,47.18 347.77,47.62 347.98,47.83 347.98,48.34 U21.T22
  TOP w0.14: C94802.1 285.91,63.96 285.12,63.96 284.03,62.87 282.12,62.87 281.51,62.26 281.51,55.84 280.84,55.17 280.84,54.64 280.5,54.3 280.5,52.56 282.8,50.26 286.5,50.26 289.74,47.02 290.41,47.02 290.57,47.18 293.75,47.18 294.5,46.44 294.5,46 294.89,45.61 v1(295.08,45.61) ; v1(347.34,46.75) 347.45,46.87 347.61,47.02
  IN4 w0.089: v1(347.34,46.75) 347.34,46.52 347.5,46.36 347.73,46.36 347.91,46.18 347.91,45.74 347.62,45.44 346.68,45.44 346.05,46.07 346.05,47.78 345.39,48.44 339.5,48.44 338.32,49.62 328.92,49.62 328,48.7 323.95,48.7 322.79,47.54 322.18,47.54 320.71,46.08 311.28,46.08 309.99,47.37 300.63,47.37 300,46.73 295.27,46.73 294.81,46.27 294.81,45.77 294.98,45.61 v1(295.08,45.61)
PCIE_TXN2_TBT_C: length 5.6
  TOP w0.081: U13113.B22 292.02,63.24 288.81,63.24 288.76,63.19 288.74,63.19
  TOP w0.14: C94802.2 287.22,63.62 287.51,63.33 288.06,63.33 288.2,63.19 288.74,63.19
PCIE_TXN3_TBT: length 103.7
  TOP w0.079: v1(349.33,46.73) 349.38,46.68 349.65,46.68 349.81,46.84 349.81,48.33 U21.M22
  TOP w0.14: v1(292.07,45.61) 292.07,45.96 291.91,46.12 291.1,46.12 290.85,45.86 289.4,45.86 286.06,49.2 282.31,49.2 279.34,52.17 279.34,54.64 279.78,55.08 279.78,55.61 280.45,56.28 280.45,59.06 279.93,59.59 279.93,67.02 280.82,67.91 283.76,67.91 284.12,67.56 284.12,66.49 284.68,65.93 C95876.1
  IN4 w0.089: v1(349.33,46.73) 348.36,46.73 347.96,47.12 347.96,47.75 347.45,48.27 346.7,48.27 345.72,49.25 339.83,49.25 338.53,50.55 328.47,50.55 327.92,50 325.39,50 324.9,49.51 323.62,49.51 322.46,48.35 320.93,48.35 320.19,47.61 318.82,47.61 318.27,47.06 314.07,47.06 313.63,47.49 313.63,48.02 313.16,48.5 303.17,48.5 303.02,48.35 300.45,48.35 299.64,47.54 293.74,47.54 292.36,46.16 292.36,45.9 v1(292.07,45.61)
PCIE_TXN3_TBT_C: length 8.2
  TOP w0.081: 288.82,64.17 289.02,63.98 292.47,63.98 U13113.C23
  TOP w0.14: C95876.2 286.43,65.93 287.95,64.41 288.59,64.41 288.82,64.17
PCIE_TXN3_WLAN: length 251.7
  TOP w0.14: v1(59.25,65.25) 59.25,65.38 59.35,65.48 59.47,65.48 59.7,65.25 CN2068.37 ; v1(282.75,54.56) 282.75,54.7 283.57,55.53 283.57,59.36 284.44,60.23 284.64,60.23 C94796.1
  IN5 w0.089: v1(59.25,65.25) 59.04,65.25 58.95,65.35 58.95,65.58 59.07,65.7 59.63,65.7 60.03,65.31 60.03,60.6 60.99,59.64 60.99,58.03 62.1,56.92 62.1,54.9 66.33,50.67 67.05,50.67 68.45,49.27 72.61,49.27 73.55,48.33 83.66,48.33 84.45,49.12 89.73,49.12 91.14,50.53 92.27,50.53 94.08,52.34 126.5,52.34 126.98,52.82 154.81,52.82 155.2,52.43 174.07,52.43 176.45,54.81 177.48,54.81 178.36,55.69 191.47,55.69 191.94,56.16 193.1,56.16 193.68,56.75 197.31,56.75 197.83,56.22 198.26,56.22 198.5,55.98 198.93,55.98 199.15,55.77 203.42,55.77 204.89,54.31 205.75,54.31 206.69,55.25 207.26,55.25 208.21,54.31 255.55,54.31 255.63,54.38 263.19,54.38 263.79,54.98 270.72,54.98 271.04,54.66 280.17,54.66 280.47,54.96 282.72,54.96 282.82,54.86 282.82,54.64 v1(282.75,54.56)
PCIE_TXN3_WLAN_C: length 7.9
  TOP w0.081: U13113.B20 290.08,61.9 289.86,61.68 289.86,61.63
  TOP w0.14: 289.86,61.63 288.46,60.23 286.31,60.23 286.22,60.33 285.83,60.33 285.69,60.19 285.51,60.19 285.39,60.06 285.39,59.94 C94796.2
PCIE_TXN4_LAN: length 70.2
  TOP w0.14: v1(346.25,71.16) 346.48,71.16 346.65,70.98 347.06,70.98 347.22,71.14 U13143.36 ; C94798.1 286.41,61.21 286.07,61.21 v1(286,61.13)
  IN5 w0.089: v1(346.25,71.16) 346.3,71.16 346.47,71.33 346.47,71.62 346.3,71.78 343.11,71.78 341.25,69.92 336.73,69.92 335.31,68.51 334.07,68.51 333.5,67.93 333.5,67.07 332.59,66.17 331.99,66.17 330.74,64.91 323.29,64.91 322.03,63.65 320.49,63.65 320.13,63.3 317.58,63.3 317.22,63.65 316.12,63.65 315.64,64.14 313.63,64.14 312.41,62.92 302.72,62.92 302.33,62.53 298.77,62.53 298.45,62.84 293.26,62.84 291.98,61.56 285.78,61.56 285.7,61.48 285.7,61.22 285.8,61.13 v1(286,61.13)
PCIE_TXN4_LAN_C: length 5.7
  TOP w0.081: 289.35,62.14 289.46,62.25 291.82,62.25 292.09,62.52 U13113.B21
  TOP w0.14: 289.35,62.14 288.81,61.61 288.15,60.95 C94798.2
PCIE_TXN4_TBT: length 111.7
  TOP w0.079: 351.62,46.54 351.62,46.59 352.24,47.21 352.24,47.79 352.11,47.93 352.11,48.34 U21.H22
  TOP w0.14: v1(351.43,46.3) 351.43,46.35 351.62,46.54 ; v1(301.44,45.62) 301.39,45.57 301.39,45.03 301.14,44.77 289.22,44.77 285.81,48.19 282.05,48.19 278.56,51.68 278.56,56.18 277.68,57.06 277.68,58.47 278.58,59.38 278.58,61.15 278.79,61.36 278.79,67.78 279.93,68.93 283.87,68.93 285.07,67.72 287.26,67.72 287.71,67.26 287.71,66.83 C95879.1
  IN4 w0.089: v1(301.44,45.62) 301.29,45.77 301.29,45.94 301.44,46.09 309.11,46.09 310.81,44.39 322.16,44.39 325.19,47.43 329.56,47.43 330.4,48.26 337.88,48.26 341.33,44.81 349.94,44.81 v1(351.43,46.3)
PCIE_TXN4_TBT_C: length 6.5
  TOP w0.081: U13113.C24 292.25,64.54 291.75,64.54 291.64,64.43 289.63,64.43 289.36,64.7 289.36,64.78 289.35,64.79
  TOP w0.14: 289.35,64.79 288.85,65.28 288.2,65.28 287.51,65.97 287.51,66.17 287.63,66.29 C95879.2
PCIE_TXP1_TBT: length 86.7
  TOP w0.079: U21.Y23 346.37,47.89 345.35,46.87 v1(345.35,46.43)
  TOP w0.14: v1(296.39,45.61) 296.39,46.12 296.21,46.3 295.4,46.3 293.25,48.44 289.26,48.44 286.93,50.78 283.04,50.78 281.02,52.8 281.02,54.09 281.36,54.42 281.36,54.95 282.03,55.63 282.03,59.8 284.94,62.7 285.39,62.7 C94801.1
  IN4 w0.089: v1(296.39,45.61) 296.67,45.61 296.8,45.75 296.8,46.08 296.99,46.26 300.19,46.26 300.83,46.9 309.48,46.9 310.85,45.52 322.15,45.52 324.85,48.23 329.23,48.23 330.1,49.1 338.17,49.1 339.3,47.97 345.08,47.97 345.58,47.47 345.58,46.99 345.35,46.76 v1(345.35,46.43)
PCIE_TXP1_TBT_C: length 7.6
  TOP w0.081: 288.57,62.74 288.59,62.75 288.66,62.75 288.84,62.93 292.6,62.93 292.64,62.97 292.64,63.02 U13113.C22
  TOP w0.14: 288.57,62.74 288.31,62.48 288.21,62.48 288.07,62.34 287.55,62.34 287.41,62.48 285.92,62.48 285.82,62.58 285.82,62.68 C94801.2
PCIE_TXP2_TBT: length 96.4
  TOP w0.079: U21.T23 348.21,47.83 347.93,47.55 347.93,47.02
  TOP w0.14: C94803.1 286.1,64.23 285.01,64.23 283.92,63.14 282.01,63.14 281.24,62.37 281.24,55.95 280.57,55.28 280.57,54.75 280.23,54.41 280.23,52.45 282.69,49.99 286.39,49.99 289.63,46.75 290.52,46.75 290.68,46.92 293.64,46.92 294.23,46.32 v1(294.23,45.61) ; v1(347.24,46.07) 347.31,46.07 347.93,46.69 347.93,47.02
  IN4 w0.089: v1(294.23,45.61) 294.41,45.61 294.64,45.85 294.64,46.34 295.2,46.9 299.93,46.9 300.56,47.53 310.06,47.53 311.35,46.24 320.64,46.24 322.11,47.71 322.72,47.71 323.88,48.87 327.93,48.87 328.86,49.79 338.39,49.79 339.57,48.61 345.46,48.61 346.22,47.84 346.22,46.14 346.75,45.61 347.55,45.61 347.75,45.81 347.75,46.11 347.66,46.19 347.37,46.19 v1(347.24,46.07)
