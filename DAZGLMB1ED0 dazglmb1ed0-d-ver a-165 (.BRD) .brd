# Allegro board DAZGLMB1ED0 dazglmb1ed0-d-ver a-165 (.BRD) .brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on IN4 (solid shape): 54.37,17.44 54.42,17.4 54.48,17.36 54.64,17.2 54.64,17 54.63,16.99 54.47,16.29 54.86,15.7 54.86,13.01 51.12,13.01 51.12,15.7 51.49,16.21 51.43,16.84 51.43,16.85 51.43,16.91 51.75,17.23 51.82,17.29 51.88,17.35 52.31,17.35 52.53,16.29 52.14,15.28 52.14,14.02 53.84,14.02 53.84,15.28 53.44,16.34 53.72,17.44
GND on IN4 (solid shape): 22.04,73.98 22.04,69.43 20.82,68.22 16.2,68.22 12.19,64.2 10.97,64.2 9.09,62.32 9.09,32.83 8.55,32.3 0.51,32.3 0.51,36.39 5.3,36.39 6.27,37.14 5.81,38.27 5.81,43.73 6.27,44.86 5.3,45.61 0.51,45.61 0.51,54.39 5.3,54.39 6.27,55.14 5.81,56.27 5.81,61.73 6.27,62.86 5.3,63.61 0.51,63.61 0.51,66.2 0.65,66.55 1,66.69 8.14,66.69 9.21,67.13 9.65,68.2 9.65,70.74 18.59,70.74 19.56,71.49 19.1,72.62 19.1,75.43 20.59,75.43
GND on IN4 (solid shape): 28.44,17.39 28.56,17.32 28.7,17.26 28.71,17.25 28.71,17.08 28.69,17.06 28.46,16.34 28.86,15.7 28.86,13.01 28.5,13.01 27.43,12.57 26.99,11.5 26.99,5.25 26.56,4.19 25.5,3.76 15.5,3.76 14.43,3.32 13.99,2.25 13.99,0.51 7.01,0.51 7.01,0.56 4.97,2.52 2.99,0.51 1,0.51 0.65,0.65 0.51,1 0.51,5 6.96,5 10.26,1.7 11.6,1.7 12.03,1.7 13.68,2.78 13.34,4.73 13.31,4.77 13.54,5 15.31,5 15.53,4.77 25.5,4.77 25.84,4.91 25.98,5.25 25.98,11.5 26.47,12.99 27.74,13.91 27.84,13.94 27.84,15.28 27.45,16.31 27.69,17.39
GND on IN4 (solid shape): 277.05,107.87 281.1,100.35 286.76,93.96 286.82,93.91 286.59,93.66 286.8,89.76 290.7,89.97 291.21,90.54 291.24,90.52 300.93,86.03 311.5,84.49 321.5,84.49 322.26,84.5 324.16,84.82 335.02,88.66 344.19,95.62 344.65,95.9 345.18,95.99 375.28,95.99 375.75,94.92 376.83,94.48 386.02,94.48 386.32,94.36 386.48,94.07 386.48,93.6 386.49,93.55 386.49,93.5 386.49,87.01 375.71,87.01 374.75,87.32 374.16,86.5 374.16,86.09 373.9,86.09 373.9,83.61 373.17,83.61 373.15,83.63 373.15,86.5 373.81,87.93 375.33,88.35 377.44,90.45 377.44,92.52 376.98,92.98 375.99,92.98 374,94.98 354.69,94.98 354.52,95.02 354.36,94.98 344.98,94.98 335.53,87.79 324.34,83.82 322.35,83.48 321.5,83.48 311.5,83.48 301.04,84.94 291.38,89.22 286.34,88.82 285.43,93.8 280.06,100.07 276.16,107.36 276.67,107.87
GND on IN4 (solid shape): outline of 189 points within 76.98,0.51 386.49,69.39
GND on IN4 (solid shape): outline of 1088 points within 0.51,79.09 275.99,182.49
GND on SGND5 (solid shape): outline of 3601 points within 0.51,0.51 386.49,182.49
GND on IN5 (solid shape): 353.64,65.75 353.64,63.76 353.55,63.67 352.11,63.67 351.76,63.32 350.64,63.32 350.26,63.69 350.26,65.83 350.62,66.18 353.21,66.18
GND on IN5 (solid shape): 355.92,44.47 355.92,42.36 355.29,41.72 355.29,41.14 355.09,40.94 354.07,40.94 352.95,42.05 352.95,43.37 352.72,43.6 352.72,44.31 353,44.59 355.8,44.59
GND on IN5 (solid shape): 286.4,55.33 287.33,55.33 287.41,55.24 287.41,54.76 287.45,54.73 287.45,53.22 284.58,53.22 284.55,53.29 284.55,55.19 284.98,55.62 286.11,55.62
GND on IN5 (solid shape): 147.87,108.98 147.87,107.59 148.66,106.8 148.66,104.54 148.53,104.41 145.26,104.41 145.21,104.46 145.21,106.77 145.69,107.26 145.69,108.98 146.12,109.41 147.44,109.41
GND on IN5 (solid shape): 54.26,17.54 54.39,17.43 54.53,17.33 54.54,17.33 54.69,17.18 54.69,17.05 54.68,17.04 54.47,16.33 54.86,15.7 54.86,13.01 51.12,13.01 51.12,15.7 51.49,16.21 51.43,16.84 51.43,16.85 51.43,16.98 51.54,17.09 51.57,17.11 51.75,17.23 51.9,17.37 52.3,17.37 52.53,16.3 52.14,15.28 52.14,14.02 53.84,14.02 53.84,15.28 53.44,16.4 53.78,17.54
GND on IN5 (solid shape): 21.56,74.62 21.56,69.97 20.98,69.38 19.88,69.38 18.46,67.96 16.12,67.96 12.24,64.08 10.69,64.08 9.16,62.55 9.16,33.24 8.08,32.15 0.51,32.15 0.51,36.39 5.3,36.39 6.27,37.14 5.81,38.27 5.81,43.73 6.27,44.86 5.3,45.61 0.51,45.61 0.51,54.39 5.3,54.39 6.27,55.14 5.81,56.27 5.81,61.73 6.27,62.86 5.3,63.61 0.51,63.61 0.51,66.2 0.65,66.55 1,66.69 8.14,66.69 9.21,67.13 9.65,68.2 9.65,70.74 18.59,70.74 19.56,71.49 19.1,72.62 19.1,75.53 20.64,75.53
GND on IN5 (solid shape): 28.37,17.44 28.48,17.36 28.61,17.3 28.62,17.29 28.71,17.2 28.71,17.08 28.69,17.06 28.46,16.34 28.86,15.7 28.86,13.01 28.5,13.01 27.43,12.57 26.99,11.5 26.99,5.25 26.56,4.19 25.5,3.76 15.5,3.76 14.43,3.32 13.99,2.25 13.99,0.51 7.01,0.51 7.01,0.56 5,2.53 2.99,0.56 2.99,0.51 1,0.51 0.65,0.65 0.51,1 0.51,5.02 6.93,5.02 10.25,1.7 11.01,1.7 12.03,1.7 13.68,2.78 13.35,4.73 13.31,4.76 13.57,5.02 15.39,5.02 15.63,4.77 25.5,4.77 25.84,4.91 25.98,5.25 25.98,11.5 26.47,12.99 27.74,13.91 27.84,13.94 27.84,15.28 27.44,16.34 27.72,17.44
GND on IN5 (solid shape): outline of 824 points within 355.37,40.34 381.78,51.8
GND on IN5 (solid shape): outline of 194 points within 76.98,0.51 386.49,69.39
GND on IN5 (solid shape): outline of 1562 points within 0.51,79.21 386.49,182.49
GND on SGND6 (solid shape): outline of 3671 points within 0.51,0.51 386.49,182.49
VCC0P9_CIO on BOTTOM (solid shape): 348.92,55.78 349.08,55.75 349.24,55.79 349.26,55.79 349.35,55.69 349.35,55.47 349.32,55.45 348.86,55.45 348.85,55.44 348.81,55.44 348.81,55.4 348.8,55.39 348.8,54.32 348.86,54.26 349.33,54.26 349.38,54.21 349.38,54.14 349.38,54.1 349.38,53.52 349.38,53.5 349.36,53.46 349.33,53.45 348.81,53.45 348.81,53.38 348.68,53.24 348.29,53.24 348.17,53.37 348.17,55.69 348.25,55.77 348.28,55.78 348.43,55.75 348.58,55.78 348.59,55.79 348.91,55.79
VCC0P9_DP on BOTTOM (solid shape): 348.03,54.27 348.03,53.31 348.04,53.3 348.04,53.18 348.03,53.14 347.99,53.13 347.83,53.13 347.83,52.59 347.77,52.53 347.75,52.53 347.64,52.51 347.54,52.45 347.34,52.45 347.11,52.53 346.88,52.45 346.7,52.45 346.5,52.53 346.3,52.49 346.29,52.48 346.26,52.48 346.14,52.35 346.13,52.19 346.14,52.12 346.14,51.95 346.1,51.92 345.24,51.92 345.15,52 345.15,53.29 345.25,53.38 345.49,53.38 345.52,53.37 345.54,53.35 345.71,53.17 345.96,53.16 345.99,53.16 346.01,53.14 346.66,52.94 347.05,53.49 347.05,53.75 346.99,53.81 346.98,53.83 346.99,53.87 347.05,54.06 347.04,54.26 347.06,54.35 347.14,54.38 347.91,54.38
VCC0P9_DP on IN3 (solid shape): outline of 320 points within 345.59,52.58 351.32,55.71
VCC0P9_LVR on BOTTOM (solid shape): 351.98,51.54 351.98,51.52 352.2,51.22 352.56,51.29 352.58,51.3 352.59,51.3 352.71,51.3 352.72,51.3 352.74,51.29 352.97,51.2 353.21,51.29 353.23,51.3 353.24,51.3 353.36,51.3 353.37,51.3 353.39,51.29 353.63,51.2 353.86,51.29 353.93,51.32 354,51.29 354.17,51.19 354.37,51.21 354.46,51.19 354.5,51.11 354.5,48.89 354.1,48.48 353.77,48.48 353.69,48.56 353.69,48.91 353.99,49.22 353.99,50.47 353.78,50.69 352.2,50.69 352.02,50.87 352.02,50.89 351.91,51.13 351.68,51.23 351.66,51.24 351.64,51.26 351.48,51.26 351.45,51.29 351.45,51.53 351.49,51.57 351.94,51.57
VCC0P9_LVR on IN3 (solid shape): 352.08,53.68 352.08,53.64 352.08,53.63 352.04,53.46 352.12,53.3 352.12,52.38 352.04,52.19 352.12,52 352.12,51.73 352.14,51.33 352.54,51.36 352.56,51.37 352.58,51.38 352.72,51.38 352.74,51.37 352.76,51.36 352.97,51.26 353.19,51.36 353.21,51.37 353.23,51.38 353.36,51.38 353.45,51.29 353.45,50.86 353.19,50.6 351.97,50.6 351.91,50.66 351.89,50.69 351.9,50.73 351.9,51.06 351.58,51.16 351.49,51.17 351.44,51.25 351.44,53.69 351.5,53.75 352.01,53.75
VCC0P9_PCIE on BOTTOM (solid shape): 351.24,49.69 351.24,48.88 351.48,48.64 351.48,48.42 351.43,48.37 347.83,48.37 347.7,48.51 347.7,48.73 347.8,48.84 348.05,48.84 348.26,48.63 350.68,48.63 350.73,48.68 350.73,48.76 350.74,48.78 350.74,49.68 350.86,49.8 351.13,49.8
VCC0P9_SVR on TOP (solid shape): 356.81,64.48 357.14,64.48 357.78,63.85 357.78,62.32 357.53,62.07 354.31,62.07 354.29,62.09 354.29,62.72 353.48,63.53 353.48,63.83 353.58,63.93 354.52,63.93 354.52,63.87 354.52,63.81 354.54,63.76 354.56,63.71 354.59,63.66 354.63,63.62 354.67,63.58 354.72,63.55 354.77,63.53 354.83,63.51 354.88,63.5 354.94,63.5 354.99,63.51 355.05,63.53 355.1,63.55 355.15,63.58 355.19,63.62 355.22,63.66 355.26,63.71 355.28,63.76 355.29,63.81 355.3,63.87 355.3,63.93 355.29,63.98 355.28,64.04 355.26,64.09 355.22,64.13 355.19,64.18 355.15,64.21 355.1,64.24 355.05,64.27 354.99,64.28 354.94,64.29 354.88,64.29 354.83,64.28 354.77,64.27 354.72,64.24 354.67,64.21 354.63,64.18 354.59,64.13 354.56,64.09 354.54,64.04 354.52,63.98 354.52,63.93 353.58,63.93 353.74,64.09 353.74,64.13 353.75,64.14 353.75,64.21 353.76,64.25 353.78,64.3 353.78,64.35 353.78,64.41 353.76,64.46 353.75,64.5 353.75,64.8 353.87,64.91 356.38,64.91
VCC0P9_SVR on BOTTOM (solid shape): 357.44,64.7 357.44,63.25 357.18,63 356.01,63 355.67,63.34 355.67,64.59 356.08,65 357.13,65
VCC0P9_SVR on BOTTOM (solid shape): 354.38,55.34 354.38,51.96 354.34,51.92 352.18,51.92 352.06,52.04 352.06,52.29 352.19,52.42 352.57,52.42 352.7,52.54 352.7,53.31 352.64,53.36 352.63,53.67 352.36,53.83 352.34,53.83 350.91,53.83 350.86,53.88 350.86,54.12 351.15,54.41 352.75,54.41 352.75,54.4 352.83,54.32 352.83,53.94 352.98,53.79 353.11,53.79 353.21,53.69 353.83,53.69 353.96,53.81 353.96,54.07 353.97,54.14 353.96,54.21 353.96,54.72 353.97,54.79 353.96,54.86 353.96,55.3 354.06,55.4 354.31,55.4
VCC0P9_SVR on IN2 (solid shape): outline of 610 points within 350.61,51.65 357.55,64.76
VCC0P9_SVR_IND on TOP (solid shape): 356.43,61.79 356.43,60.95 356.36,60.88 356.06,60.88 354.4,59.22 354.4,57.73 354.34,57.66 354.09,57.66 354.05,57.7 354.05,57.88 353.89,58.03 353.72,58.03 353.7,58.05 353.68,58.07 353.68,58.09 353.68,58.83 353.84,59 353.84,60.02 353.93,60.11 353.95,60.13 353.97,60.13 354.41,60.5 354.02,60.91 353.98,60.93 353.97,60.96 353.97,61.66 354.17,61.87 356.36,61.87
VCC0P9_USB on BOTTOM (solid shape): 348.66,51.63 348.66,51.38 349.2,51.38 349.28,51.31 349.28,50.9 349.15,50.77 348.97,50.77 348.86,50.75 348.78,50.68 348.7,50.61 347.89,50.61 347.86,50.64 347.86,51.01 348.16,51.32 348.16,51.69 348.2,51.73 348.56,51.73
VCC3V3_FLASH on BOTTOM (solid shape): outline of 192 points within 336.09,64.89 339.62,69.87
VCC3V3_FLASH on IN4 (solid shape): outline of 1247 points within 366.21,19.57 370.89,36.71
VDD1V8 on TOP (solid shape): 29.62,44.11 29.64,44.11 29.66,44.09 30.32,44.09 30.34,44.11 30.36,44.11 32.02,44.11 32.15,43.98 32.15,42.94 32.09,42.88 31.12,42.88 31.06,42.94 31.06,43.2 30.88,43.37 30.77,43.37 30.6,43.41 30.43,43.37 30.35,43.37 30.04,43.07 27.71,43.07 27.6,43.17 27.6,43.93 27.78,44.11
1P35V_LGATE on BOTTOM (solid shape): 180.44,82.41 180.74,82.41 181.02,82.13 181.02,81.78 180.92,81.68 179.83,81.68 179.83,82.67 180.18,82.67
1P35V_PHASE on TOP (solid shape): 188.49,86.83 188.49,86.33 188.62,86.2 191.61,86.2 192.73,85.08 192.73,79.32 192.32,78.91 191.03,78.91 188.79,81.14 187.09,81.14 187.04,81.2 187.04,81.75 186.89,81.91 185.8,81.91 185.69,82.01 185.69,82.34 185.8,82.44 186.58,82.44 186.81,82.67 186.81,85.26 187.35,85.79 187.35,86.96 187.47,87.09 188.23,87.09
1P35V_UGATE on TOP (solid shape): 186.84,81.2 186.33,81.2 186.15,81.02 185.44,81.02 185.29,81.17 185.29,81.55 185.44,81.7 186.84,81.7
1080Q_8816ABOOT1 on TOP (solid shape): 113.13,79.06 113.13,78.43 113.71,77.85 113.71,77.26 114.14,76.83 114.14,76.65 114.08,76.59 113.42,76.59 113.23,76.78 113.23,76.9 112.31,77.82 112.31,79.09 112.39,79.16 113.02,79.16
1080Q_8816ABOOT2 on TOP (solid shape): 118.61,78.96 118.61,77.79 117.44,76.62 116.68,76.62 116.61,76.7 116.61,76.88 117.52,77.79 117.52,79.01 117.57,79.06 118.51,79.06
1080Q_8816ALGATE1 on TOP (solid shape): 114.8,79.73 114.8,78.6 114.98,78.43 114.98,78.15 114.96,78.12 114.8,78.12 114.22,78.71 114.22,79.79 114.33,79.91 114.62,79.91
1080Q_8816ALGATE2 on TOP (solid shape): 119.65,85.41 119.65,84.75 119.58,84.67 118.49,84.67 118.41,84.75 118.41,85.36 118.54,85.49 119.58,85.49
1080Q_8816ALGATE2 on TOP (solid shape): 116.44,79.84 116.44,78.77 115.97,78.3 115.89,78.3 115.77,78.17 115.69,78.17 115.62,78.25 115.62,78.73 115.81,78.93 115.81,79.85 115.9,79.93 116.35,79.93
1080Q_8816APHASE1 on TOP (solid shape): 114.12,95.83 114.12,92.12 112.92,90.92 112.92,86.43 112.34,85.84 103.58,85.84 103.53,85.89 103.53,87.04 103.69,87.2 103.69,87.51 107.34,91.15 107.34,96.05 107.49,96.21 113.74,96.21
1080Q_8816APHASE1 on TOP (solid shape): 114.04,80.05 114.04,78.63 114.52,78.15 114.52,77.16 114.47,77.11 114.17,77.11 114.06,77.22 114.06,77.88 113.43,78.51 113.43,79.21 113.3,79.34 112.59,79.34 112.26,79.67 112.26,80.43 112.36,80.53 113.56,80.53
1080Q_8816APHASE1 on BOTTOM (solid shape): 108.53,87.55 108.53,86.61 108.35,86.43 107.23,86.43 106.98,86.68 106.98,87.7 107.18,87.9 108.17,87.9
1080Q_8816APHASE2 on TOP (solid shape): 121.38,95.29 121.38,91.94 120.95,91.51 120.95,86.81 120.35,86.21 114.94,86.21 114.24,86.91 114.24,91.15 114.88,91.79 114.88,95.5 115.34,95.95 120.72,95.95
1080Q_8816APHASE2 on TOP (solid shape): 119.17,80.31 119.17,79.82 118.99,79.65 117.6,79.65 117.37,79.42 117.37,78.15 117.29,78.07 117.29,78.06 116.26,77.03 116.12,77.03 116.02,77.13 116.02,77.99 116.63,78.6 116.63,79.82 117.37,80.56 118.92,80.56
1080Q_8816APHASE2 on BOTTOM (solid shape): 121.05,90.39 121.05,88.89 120.85,88.69 119.93,88.69 119.73,88.89 119.73,90.29 119.96,90.52 120.92,90.52
1080Q_8816APVCC on BOTTOM (solid shape): 115.56,79.19 115.56,78.63 117.62,76.57 117.62,75.81 117.5,75.68 116.53,75.68 116.35,75.86 116.35,76.7 115.06,77.99 115.06,79.19 115.16,79.29 115.46,79.29
1080Q_8816AUGATE1 on TOP (solid shape): 111.91,78.2 111.91,77.84 112.77,76.98 112.77,76.6 112.95,76.42 112.95,76.24 112.9,76.19 112.69,76.19 112.19,76.7 112.19,76.9 111.98,77.11 111.04,77.11 110.76,77.39 110.76,78.2 110.89,78.32 111.78,78.32
1080Q_8816AUGATE1_1 on TOP (solid shape): 111.79,80.29 111.79,78.79 111.65,78.66 110.92,78.66 110.78,78.79 110.78,80.06 111.15,80.43 111.65,80.43
1080Q_8816AUGATE1_1 on TOP (solid shape): 103.4,87.63 103.4,87.37 102.79,86.76 102.79,86.22 102.43,85.87 101.59,85.87 101.34,86.12 101.34,86.69 101.9,87.25 102.72,87.25 103.19,87.72 103.3,87.72
1080Q_8816AUGATE2 on TOP (solid shape): 119.91,77.59 119.91,76.9 119.78,76.78 118.54,76.78 117.93,76.17 117.75,76.17 117.7,76.22 117.7,76.6 118.84,77.74 119.76,77.74
1080Q_8816AUGATE2_1 on TOP (solid shape): 120.9,85.82 120.9,84.73 120.8,84.62 120.26,84.62 120.11,84.78 120.11,85.84 120.21,85.94 120.77,85.94
1080Q_8816AUGATE2_1 on TOP (solid shape): 120.68,79.58 120.68,79.16 119.87,78.35 119.22,78.35 119.12,78.45 119.12,79.37 119.53,79.77 120.49,79.77
1080Q_FBRTN on IN1 (solid shape): outline of 832 points within 137.03,62.6 143.2,75.91
8068LX_1.8V on TOP (solid shape): 98.82,87.2 100.15,85.87 100.15,82.95 99.62,82.41 99.59,82.44 92.82,82.44 92.82,82.45 92.56,82.45 92.56,83.15 92.32,83.15 92.32,82.45 92.06,82.45 92.06,83.15 91.82,83.15 91.82,82.45 91.56,82.45 91.56,83.3 95.99,87.73 98.29,87.73
24780_LX on TOP (solid shape): 84.98,60.47 84.98,55.97 84.73,55.72 82.19,55.72 81.61,56.3 78.74,56.3 78.71,56.32 78.71,60.68 78.84,60.8 84.66,60.8
51225_DH1 on BOTTOM (solid shape): 84.42,74.37 84.42,73.93 84.21,73.72 84.21,73.71 83.54,73.04 82.77,73.04 82.7,73.12 82.7,73.5 83.32,74.12 83.6,74.12 83.98,74.5 84.28,74.5
51225_DH2 on TOP (solid shape): 69.94,67.34 69.94,66.83 70.25,66.51 70.25,66.23 70.07,66.06 69.67,66.06 69.26,66.47 69.26,67.31 69.35,67.4 69.88,67.4
51225_DH2 on BOTTOM (solid shape): 80.28,73.4 80.28,73.3 80.36,73.22 80.36,73.09 80.31,73.04 79.62,73.04 79.24,73.42 79.24,73.83 79.4,73.98 79.7,73.98
51225_DL1 on TOP (solid shape): 89.68,74.51 89.68,73.37 89.56,73.24 89.05,73.24 88.79,73.5 88.79,74.51 89.05,74.77 89.43,74.77
51225_DL1 on BOTTOM (solid shape): 82.93,74.77 82.93,74.57 82.7,74.34 82.7,73.75 82.57,73.63 82.32,73.63 82.19,73.75 82.19,74.72 82.54,75.07 82.62,75.07
51225_DL2 on TOP (solid shape): 70.05,74.74 70.05,72.48 69.95,72.38 69.49,72.38 69.34,72.53 69.34,74.67 69.49,74.82 69.97,74.82
51225_DL2 on BOTTOM (solid shape): 80.77,74.26 80.77,73.58 80.67,73.47 80.56,73.47 80.44,73.6 80.44,73.8 79.95,74.29 79.95,74.59 80.16,74.79 80.23,74.79
51225_SW1 on TOP (solid shape): 100.51,73.16 100.51,72.01 100.68,71.84 100.68,71.83 100.83,71.69 100.83,68.14 100.6,67.91 94.38,67.91 94.13,68.16 94.13,69.43 93.5,70.07 88.83,70.07 88.52,70.38 88.52,72.43 88.75,72.66 97.99,72.66 98.17,72.84 98.17,73.93 98.37,74.13 99.54,74.13
51225_SW1 on BOTTOM (solid shape): 85.87,72.99 85.87,72.1 85.59,71.82 84.04,71.82 83.84,72.03 83.84,72.36 83.97,72.48 84.37,72.48 85,73.11 85.76,73.11
51225_SW2 on TOP (solid shape): 68.97,74.07 68.97,73.01 68.99,73 68.99,72.35 69.34,72 74.14,72 74.37,71.77 74.37,69.52 74.09,69.23 69.18,69.23 68.26,70.16 62.8,70.16 62.12,70.83 62.12,74.62 63.34,75.84 67.2,75.84
51225_SW2 on BOTTOM (solid shape): 69.59,73.6 69.59,72.56 69.44,72.41 67.34,72.41 67.16,72.58 67.16,73.41 67.53,73.78 69.41,73.78
51225_SW2 on BOTTOM (solid shape): 77.95,73.5 77.95,73.07 78.07,72.94 78.35,72.94 78.79,72.51 79.06,72.51 79.19,72.38 79.19,72.25 79.14,72.2 78.33,72.2 78.1,72.43 77.36,72.43 77.11,72.69 77.11,73.58 77.21,73.68 77.77,73.68
51225_VBST1 on BOTTOM (solid shape): 86.26,75.12 86.26,74.81 85.87,74.42 85.87,73.5 85.75,73.37 85.06,73.37 84.37,72.69 83.97,72.69 83.81,72.84 83.81,73.04 84.59,73.82 84.59,74.43 85.39,75.23 86.15,75.23
51225_VBST2 on BOTTOM (solid shape): 78.51,74.62 78.59,74.4 78.79,74.28 78.79,73.47 79.17,73.09 79.17,72.74 79.09,72.66 78.96,72.66 78.2,73.42 78.2,73.6 77.58,74.22 77.15,74.22 77.11,74.26 77.11,74.9 77.36,75.15 77.97,75.15
51225_VIN on BOTTOM (solid shape): 80.64,77.11 81.38,77.11 81.44,77.04 81.44,76.43 81.17,76.17 81.17,73.42 81,73.42 80.98,73.44 80.98,74.2 80.97,74.2 80.97,74.74 79.27,76.45 79.27,77.31 79.41,77.45 80.3,77.45
61087SW on TOP (solid shape): 370.83,94.11 370.83,93.18 370.48,92.83 369.18,92.83 368.61,92.26 368.61,89.22 367.33,87.94 367.33,86.45 367.16,86.29 366.94,86.29 366.9,86.3 366.88,86.33 366.88,87.12 366.66,87.12 366.66,86.33 366.65,86.3 366.61,86.29 366.44,86.29 366.38,86.34 366.38,87.48 366.62,87.72 366.62,88.77 366.54,88.85 366.54,88.85 365.9,89.49 365.9,93.8 366.37,94.27 370.67,94.27
+601_VCC on BOTTOM (solid shape): outline of 1364 points within 53.64,28.44 66.91,39.49
+602_VCC on BOTTOM (solid shape): 68.57,46.65 68.57,45.84 68.58,45.83 68.58,45.78 68.75,45.61 68.75,45.08 68.47,44.8 67.71,44.8 67.51,45 67.51,45.32 67.48,45.35 67.48,45.46 67.41,45.53 67.41,46.54 67.44,46.54 67.44,47.29 67.61,47.46 67.76,47.46
+602_VCC on BOTTOM (solid shape): outline of 556 points within 63.9,36.52 71.69,47.29
+602_VCC on IN4 (solid shape): outline of 428 points within 64,43.79 78.77,47.77
+603_VCC on BOTTOM (solid shape): outline of 1136 points within 38.35,31.21 52,40.48
+603_VCC on IN3 (solid shape): outline of 263 points within 49.32,35.68 52.95,42.05
+604_VCC on BOTTOM (solid shape): outline of 1812 points within 48.57,39.92 62,52.14
+TPVDD on TOP (solid shape): outline of 114 points within 126.26,60.08 132.71,64.77
+WL_VDD on TOP (solid shape): 53.92,74.13 53.92,73.47 53.74,73.31 53.72,73.31 53.7,73.31 53.69,73.33 53.68,73.36 52.13,73.36 52.12,73.3 52.11,73.29 51.99,73.28 51.99,73.27 51.94,73.27 51.88,73.21 51.73,73.21 51.45,72.93 51.45,72.78 51.35,72.69 49.93,72.69 49.8,72.81 49.8,73.64 53.68,73.64 53.68,73.86 52.13,73.86 52.13,73.64 49.8,73.64 49.81,73.73 49.81,73.78 49.8,73.81 49.8,74.29 49.98,74.46 53.59,74.46
+WL_VDD on TOP (solid shape): outline of 161 points within 47.74,49.01 53.79,56.76
+WL_VDD on BOTTOM (solid shape): outline of 749 points within 45.59,53.97 52.9,74.97
+WL_VDD on IN1 (solid shape): outline of 372 points within 50.62,51.88 63.01,56.94
ADOGND on TOP (solid shape): 1.52,5.59 0.51,5.59 0.51,28.72 1.52,28.72
ADOGND on TOP (solid shape): 22.72,16.36 22.72,16.19 21.79,15.27 21.79,15.09 21.79,15.07 21.78,15.06 21.51,14.79 21.47,14.79 21.12,15.13 21.12,15.75 21.42,16.05 21.66,16.05 21.95,16.34 21.95,16.42 21.95,16.43 22,16.56 22.02,16.7 22.02,16.88 22.05,16.92 22.17,16.92
ADOGND on TOP (solid shape): 18.46,21.45 18.5,21.44 18.51,21.4 18.51,20.86 18.43,20.63 18.51,20.39 18.51,19.24 18.44,19.17 17.65,19.17 17.57,19.24 17.57,20.62 17.66,20.96 17.58,21.3 17.57,21.31 17.57,21.4 17.59,21.44 17.62,21.45
ADOGND on BOTTOM (solid shape): 1.52,5.66 0.51,5.66 0.51,28.87 1.52,28.87
ADOGND on BOTTOM (solid shape): 18.44,20.7 18.8,20.24 19.22,20.65 19.25,20.72 19.32,20.76 20.89,20.76 20.98,20.67 20.98,19.42 20.64,19.09 20.64,17.44 20.92,17.16 20.92,16.91 20.87,16.86 18.59,16.86 18.46,16.98 17.77,16.98 17.67,17.09 17.67,20.11 18.32,20.76 18.44,20.76
ADOGND on SGND1 (solid shape): outline of 434 points within 0.51,5.55 32.13,42.79
ADOGND on IN1 (solid shape): 1.52,5.59 0.51,5.59 0.51,28.82 1.52,28.82
ADOGND on SGND2 (solid shape): outline of 438 points within 0.51,5.55 32.13,42.79
ADOGND on IN2 (solid shape): 1.52,5.61 0.51,5.61 0.51,28.82 1.52,28.82
ADOGND on SGND3 (solid shape): outline of 438 points within 0.51,5.55 32.13,42.79
ADOGND on SVCC (solid shape): outline of 422 points within 0.51,5.55 32.13,42.79
ADOGND on IN3 (solid shape): 1.52,5.62 0.51,5.62 0.51,28.82 1.52,28.82
ADOGND on SGND4 (solid shape): outline of 436 points within 0.51,5.55 32.13,42.79
ADOGND on IN4 (solid shape): 1.52,5.66 0.51,5.66 0.51,28.82 1.52,28.82
ADOGND on IN4 (solid shape): outline of 2511 points within 0.51,5.55 28.71,32.99
ADOGND on SGND5 (solid shape): outline of 435 points within 0.51,5.55 32.13,42.79
ADOGND on IN5 (solid shape): 1.52,5.64 0.51,5.64 0.51,28.82 1.52,28.82
ADOGND on SGND6 (solid shape): outline of 435 points within 0.51,5.55 32.13,42.79
BAT-V on TOP (solid shape): outline of 425 points within 91.71,46.65 171.57,61.99
BL# on BOTTOM (solid shape): 346.2,91.41 346.24,91.39 346.26,91.36 346.26,90.88 346.45,90.88 346.45,91.36 346.47,91.39 346.5,91.41 346.6,91.41 346.72,91.29 346.72,91.26 346.7,91.18 346.7,91.11 346.7,90.78 346.46,90.54 346.46,89.61 346.35,89.5 345.71,89.5 345.46,89.75 345.46,91.28 345.59,91.41
BL_ON on TOP (solid shape): 346.59,90.63 346.59,90.44 346.85,90 347.36,90 347.37,90.01 347.42,90.01 347.54,90.14 347.54,90.19 347.55,90.2 347.6,90.31 347.61,90.44 347.61,90.71 347.64,90.75 348.1,90.75 348.38,90.47 348.38,89.58 348.23,89.42 345.43,89.42 345.31,89.55 345.31,90.67 345.38,90.75 346.48,90.75
BL_ON on BOTTOM (solid shape): 348.46,91.55 349.18,91.55 349.48,91.26 353.17,91.26 353.19,91.24 353.19,90.69 353.21,90.67 353.21,89.86 353.04,89.69 352.38,89.69 352.36,89.71 352.35,89.74 352.36,89.78 352.2,90.37 351.65,90.1 351.65,90.08 351.62,90.06 347.78,90.06 347.75,90.09 347.62,90.09 347.52,90.19 347.52,91.26 347.52,91.26 347.52,91.37 346.98,91.9 346.98,92.68 347.01,92.7 347.31,92.7
BLON_EN on BOTTOM (solid shape): outline of 215 points within 344.1,90.53 352.99,94.45
CLK_VDD on IN1 (solid shape): outline of 295 points within 32.35,54.83 45.36,58.72
CORE_PLLVDD on BOTTOM (solid shape): 159.81,121.86 159.81,121.15 159.96,121.01 159.96,120.36 159.97,120.33 159.99,120.25 159.98,120.18 159.97,120.13 159.97,120.01 159.91,119.95 159.66,119.95 159.4,119.7 159.4,119.67 159.4,119.66 159.34,119.45 159.4,119.25 159.4,118.97 159.34,118.76 159.4,118.55 159.4,118.27 159.34,118.06 159.4,117.85 159.4,117.57 159.34,117.36 159.4,117.15 159.4,116.84 159.4,116.83 159.36,116.71 159.37,116.54 159.2,116.37 159.2,115.43 158.52,114.75 158.32,114.75 158.06,115 158.06,119.09 158.52,119.55 158.52,119.83 158.64,119.95 158.64,120.59 159.14,121.09 159.14,121.85 159.23,121.94 159.74,121.94
CORE_PLLVDD on BOTTOM (solid shape): outline of 83 points within 150.34,118.51 153.64,121.91
CORE_PLLVDD on BOTTOM (solid shape): outline of 374 points within 151.53,106.01 157.82,112.92
DDR_VTT on BOTTOM (solid shape): outline of 752 points within 179.42,55.21 211.97,79.87
ECAGND on BOTTOM (solid shape): 191.71,58.32 191.86,58.08 192.12,58 192.25,58 192.29,57.95 192.93,57.95 193.19,58.21 193.29,58.21 193.39,58.11 193.39,57.75 193.19,57.55 193.19,57.32 193.03,57.17 192.76,57.17 192.43,57.5 191.93,57.5 191.83,57.6 191.62,57.94 191.22,57.93 191.03,57.93 190.9,58.06 190.9,58.39 190.93,58.42 191.61,58.42
FAN2_PWM_Q on BOTTOM (solid shape): 55.32,77.39 55.32,76.78 55.04,76.5 54.17,76.5 54.13,76.51 54.12,76.55 54.12,76.94 53.73,77.33 53.33,76.94 53.33,76.86 53.3,76.83 53.06,76.83 53.01,76.83 52.91,76.82 52.85,76.81 52.79,76.79 52.76,76.78 52.73,76.8 52.52,77 51.56,77 51.43,76.88 50.49,76.88 50.29,77.08 50.29,77.64 50.57,77.92 51.66,77.92 51.94,78.2 54.5,78.2
FBVDDQ_MEM on TOP (solid shape): 122.96,171.92 122.96,158.97 118.66,158.97 118.66,167.3 118.38,167.58 118.38,172.05 118.64,172.3 122.58,172.3
FBVDDQ_MEM on TOP (solid shape): 171.72,125.93 171.96,125.81 172.22,125.91 172.35,125.91 172.4,125.89 172.76,125.53 172.79,125.49 172.83,125.46 172.94,125.35 172.94,124.73 172.74,124.53 172.38,124.53 172.27,124.65 172.27,124.89 171.88,125.27 171.64,125.27 171.39,125.52 171.39,125.85 171.5,125.95 171.68,125.95
FBVDDQ_MEM on TOP (solid shape): 171.96,140.51 171.99,140.51 172.63,140.51 172.7,140.45 172.7,140.43 172.71,140.38 172.75,140.24 172.86,140.14 172.87,140.13 172.88,140.11 172.88,139.43 172.88,139.4 172.76,139.29 172.71,139.15 172.71,139.13 172.49,138.92 172.2,138.92 171.93,139.02 171.7,138.87 171.7,138.87 171.43,138.87 171.43,140.41 171.52,140.5 171.54,140.51 171.55,140.51
FBVDDQ_MEM on TOP (solid shape): 153.06,143.11 153.08,143.11 153.1,143.09 153.17,143.02 153.27,142.97 153.28,142.97 153.56,142.69 153.56,142.46 153.55,142.43 153.48,142.09 153.79,141.91 153.83,141.89 153.85,141.86 153.87,141.77 153.91,141.68 153.88,141.63 153.82,141.61 151.98,141.61 151.88,141.71 151.88,142.01 151.96,142.21 151.88,142.42 151.88,142.74 152.11,142.96 152.12,142.96 152.23,143.01 152.32,143.09 152.34,143.11 152.36,143.11
FBVDDQ_MEM on TOP (solid shape): 120.5,144.65 120.58,144.61 120.7,144.52 120.84,144.49 120.88,144.48 120.89,144.45 120.93,144.34 121.03,144.24 121.04,144.21 121.04,144.07 121.03,144.05 121.02,144.04 120.95,143.99 120.91,143.91 120.91,143.9 120.81,143.8 120.79,143.8 120.64,143.74 120.54,143.62 120.54,143.61 120.47,143.54 120.47,142.73 120.4,142.66 120.36,142.64 120.32,142.66 119.82,143.16 119.82,143.3 119.84,143.34 119.85,143.4 120.08,143.63 120.08,143.71 120.08,143.72 120.08,143.92 119.94,144.06 119.93,144.06 119.88,144.11 119.87,144.15 119.88,144.19 119.93,144.23 119.94,144.23 120.03,144.29 120.09,144.38 120.09,144.39 120.19,144.49 120.21,144.49 120.32,144.53 120.42,144.61
FBVDDQ_MEM on TOP (solid shape): 170.36,142.63 170.49,142.63 170.58,142.62 170.67,142.64 170.7,142.64 170.98,142.92 171,142.92 171.12,142.97 171.22,143.06 171.24,143.07 171.26,143.08 171.47,143.08 171.5,143.04 171.5,141.91 171.26,141.66 169.3,141.66 169.22,141.7 169.21,141.79 169.22,141.87 169.31,141.96 169.37,142.01 169.43,142.08 169.43,142.1 169.3,142.47 168.92,142.38 168.84,142.34 168.75,142.39 168.72,142.43 168.69,142.46 168.68,142.48 168.68,142.5 168.68,142.71 168.88,142.92 168.9,142.92 169.04,142.98 169.14,143.09 169.16,143.11 169.18,143.11 169.88,143.11
FBVDDQ_MEM on TOP (solid shape): 150.11,132.12 150.11,131.92 150.08,131.89 150.01,131.82 150,131.71 150.01,131.61 150.08,131.53 150.11,131.51 150.15,131.46 150.26,131.46 150.42,131.46 150.67,131.71 150.72,131.72 150.81,131.71 150.86,131.63 150.86,128.54 150.85,128.53 150.85,128.32 150.79,128.26 149.93,128.26 149.5,128.69 149.5,128.71 149.45,128.81 149.36,128.88 149.36,129.64 149.45,129.73 149.51,129.85 149.51,129.86 149.75,130.11 150.01,130.11 150.04,130.1 150.56,130.31 150.04,130.53 150.01,130.52 149.78,130.52 149.5,130.79 149.5,130.81 149.45,130.91 149.36,130.98 149.33,131 149.33,131.73 149.45,131.82 149.51,131.95 149.51,131.96 149.76,132.21 150.01,132.21
FBVDDQ_MEM on TOP (solid shape): 150.05,140.59 150.26,140.51 150.47,140.59 150.73,140.59 150.86,140.46 150.86,137.4 150.84,137.33 150.78,137.3 150.66,137.33 150.42,137.57 150.26,137.57 150.01,137.36 150.17,137.07 150.19,137.06 150.21,136.97 150.15,136.9 150.09,136.86 150.03,136.82 149.78,136.82 149.5,137.09 149.5,137.11 149.47,137.17 149.43,137.22 149.43,138.1 149.47,138.16 149.5,138.22 149.5,138.23 149.78,138.51 150.03,138.51 150.56,138.71 150.03,138.92 149.74,138.92 149.51,139.14 149.51,139.16 149.48,139.25 149.43,139.32 149.43,140.2 149.48,140.28 149.51,140.36 149.51,140.38 149.72,140.59
FBVDDQ_MEM on TOP (solid shape): 150.83,136.71 150.86,136.65 150.86,132.38 150.84,132.31 150.78,132.28 150.69,132.32 150.59,132.33 150.57,132.36 150.56,132.38 150.39,132.69 150.05,132.63 150.04,132.63 150.01,132.62 149.74,132.62 149.51,132.84 149.51,132.86 149.46,132.99 149.36,133.08 149.36,133.84 149.45,133.93 149.51,134.05 149.51,134.06 149.76,134.31 150.01,134.31 150.04,134.3 150.05,134.29 150.56,134.51 150.05,134.73 150.04,134.73 150.01,134.72 149.73,134.72 149.51,134.93 149.48,135.05 149.43,135.13 149.42,135.14 149.41,135.17 149.41,135.95 149.42,135.99 149.47,136.05 149.5,136.12 149.5,136.13 149.78,136.41 150.03,136.41 150.38,136.33 150.56,136.64 150.59,136.69 150.63,136.72 150.7,136.73 150.77,136.75
FBVDDQ_MEM on TOP (solid shape): 172.7,138.29 172.75,138.14 172.86,138.04 172.88,138.02 172.88,137.3 172.86,137.28 172.75,137.18 172.71,137.05 172.7,137.02 172.5,136.82 172.19,136.82 171.65,136.61 172.19,136.41 172.49,136.41 172.7,136.19 172.71,136.17 172.76,136.03 172.88,135.93 172.91,135.91 172.91,135.23 172.9,135.21 172.88,135.21 172.79,135.14 172.69,135.03 172.69,134.99 172.34,134.64 172.34,134.38 172.53,134.19 172.63,134.19 172.7,134.12 172.71,134.08 172.75,133.94 172.86,133.84 172.87,133.83 172.88,133.81 172.88,133.1 172.86,133.08 172.75,132.99 172.71,132.85 172.5,132.64 172.16,132.64 171.82,132.68 171.65,132.38 171.65,132.36 171.63,132.33 171.56,132.33 171.49,132.31 171.45,132.35 171.43,132.4 171.43,138.02 171.49,138.02 171.54,138.01 171.79,137.76 172.06,137.76 172.21,137.91 172.21,138.12 172.11,138.22 172.11,138.45 172.15,138.48 172.19,138.51 172.49,138.51
FBVDDQ_MEM on TOP (solid shape): 172.7,131.99 172.74,131.86 172.81,131.78 172.82,131.77 172.83,131.73 172.83,130.99 172.82,130.96 172.81,130.95 172.74,130.86 172.71,130.75 172.7,130.72 172.5,130.52 172.2,130.52 172.18,130.53 172.17,130.53 171.65,130.31 172.17,130.09 172.18,130.1 172.2,130.11 172.51,130.11 172.53,130.09 172.7,129.92 172.71,129.88 172.75,129.74 172.86,129.64 172.86,128.88 172.75,128.78 172.71,128.65 172.7,128.62 172.5,128.42 172.2,128.42 172.18,128.43 172.17,128.43 171.65,128.21 172.17,127.99 172.18,128 172.2,128.01 172.47,128.01 172.49,128 172.5,127.99 172.71,127.79 172.71,127.77 172.76,127.62 172.89,127.52 172.9,127.52 172.93,127.47 172.93,126.79 172.55,126.4 172.24,126.4 172.15,126.5 172.12,126.57 172.15,126.64 172.19,126.92 171.95,127.07 171.93,127.07 171.43,127.56 171.43,131.6 171.47,131.68 171.55,131.7 171.59,131.7 171.8,131.48 171.85,131.48 171.86,131.48 172.18,131.59 172.09,131.93 172.09,132.14 172.13,132.16 172.16,132.18 172.51,132.18
FBVDDQ_MEM on TOP (solid shape): 163.56,143.11 163.58,143.11 163.6,143.09 163.67,143.02 163.76,142.97 163.78,142.97 164.06,142.69 164.06,142.46 164.04,142.43 164.26,141.91 164.48,142.43 164.46,142.46 164.46,142.72 164.71,142.96 164.72,142.96 164.82,143 164.9,143.07 164.94,143.09 165.68,143.09 165.72,143.07 165.78,143.01 165.87,142.97 165.88,142.97 166.14,142.71 166.15,142.69 166.16,142.67 166.16,142.46 166.15,142.44 166.14,142.43 166.36,141.91 166.58,142.43 166.57,142.44 166.56,142.46 166.56,142.69 166.57,142.71 166.58,142.73 166.81,142.96 166.82,142.96 166.92,143 167,143.07 167.04,143.09 167.78,143.09 167.82,143.07 167.91,143 168.02,142.96 168.04,142.96 168.24,142.76 168.25,142.74 168.25,142.72 168.25,142.46 168.24,142.43 168.16,142.15 168.35,141.92 168.38,141.9 168.38,141.66 163.01,141.66 162.92,141.7 162.91,141.79 162.91,141.83 162.92,141.86 162.92,141.88 162.93,141.9 163.09,142.06 163.09,142.1 163.09,142.11 162.96,142.45 162.62,142.31 162.61,142.29 162.52,142.26 162.44,142.33 162.42,142.38 162.38,142.43 162.36,142.46 162.36,142.72 162.61,142.96 162.62,142.96 162.73,143.01 162.82,143.09 162.84,143.11 162.86,143.11
FBVDDQ_MEM on TOP (solid shape): outline of 87 points within 153.98,141.67 162.2,143.2
FBVDDQ_MEM on TOP (solid shape): outline of 12476 points within 107.51,96.44 209.57,179.65
FBVDDQ_MEM on BOTTOM (solid shape): 141.99,174.61 142.03,174.59 142.04,174.56 142.04,173.58 141.9,173.44 141.68,173.44 141.48,173.24 141.48,171.36 140.24,170.12 139.71,170.12 139.62,170.18 139.64,170.29 140.97,171.62 140.97,174.34 141.23,174.61
FBVDDQ_MEM on BOTTOM (solid shape): outline of 51947 points within 113.51,111.91 209.8,180.59
FBVDDQ_MEM on IN1 (solid shape): outline of 1563 points within 149.39,124.78 172.85,142.92
FBVDDQ_MEM on IN2 (solid shape): outline of 37752 points within 115.97,113.88 207.44,177.56
FBVDDQ_MEM on SVCC (solid shape): 143.81,178.65 144.04,178.57 144.27,178.65 184.21,178.65 188.93,173.94 188.93,171.74 188.97,171.54 189.08,171.37 192.95,167.5 193.12,167.39 193.32,167.35 201.74,167.35 209.32,159.78 209.32,113.46 208.6,112.74 191.49,112.74 190.01,114.22 190.01,143.72 189.97,143.92 189.86,144.09 179.96,154 179.79,154.11 179.59,154.14 143.54,154.14 143.34,154.11 143.17,154 135.04,145.87 134.93,145.7 134.89,145.5 134.89,123.63 134.55,123.28 134.89,122.94 134.89,95.26 134.8,95.01 134.89,94.76 134.89,94.5 134.8,94.25 134.89,94 134.89,93.74 134.8,93.49 134.89,93.24 134.89,92.98 134.8,92.73 134.89,92.48 134.89,92 134.3,91.41 126.97,91.41 126.69,91.52 126.41,91.41 126.21,91.41 125.93,91.52 125.65,91.41 124.94,91.41 114.83,101.52 114.83,109.36 116.71,111.24 116.82,111.41 116.86,111.6 116.86,119.28 117.08,119.6 116.86,119.92 116.86,121.63 116.82,121.82 116.71,121.99 115.21,123.49 115.24,134.25 115.5,134.54 115.24,134.83 115.27,143.39 115.54,143.72 115.27,144.06 115.27,144.16 115.56,144.5 115.28,144.84 115.28,146.58 115.54,146.91 115.28,147.25 115.34,164.6 129.39,178.65
FBVDDQ_MEM on IN3 (solid shape): outline of 59314 points within 114.6,99.91 208.68,178.43
FBVDDQ_MEM on IN4 (solid shape): outline of 1762 points within 149.39,127.19 173.12,143.19
FBVDDQ_MEM on IN5 (solid shape): outline of 1579 points within 149.39,125.46 172.69,142.93
G5719LX2.5V on TOP (solid shape): 198.06,75.3 198.06,73.6 197.84,73.37 196.62,73.37 196.34,73.65 196.34,75.71 196.2,75.85 196.02,75.85 196.01,75.86 194.91,75.86 194.89,75.89 194.89,76.29 194.94,76.34 197.02,76.34
HDMI_HPD on BOTTOM (solid shape): outline of 134 points within 228.49,170.4 232.53,173.3
L_SPK+ on TOP (solid shape): 21.79,12.21 21.79,11.83 21.64,11.68 21.53,11.68 20.52,10.66 20.52,7.97 20.26,7.71 19.58,7.71 19.46,7.83 19.46,9.74 19.48,9.87 19.46,10 19.46,10.47 20.04,11.04 20.04,11.4 20.95,12.31 21.69,12.31
L_SPK+ on TOP (solid shape): 29.61,28.85 29.61,27.52 29.62,27.51 29.62,27.23 29.87,26.99 29.87,26.08 29.74,25.95 29.51,25.95 29.36,26.1 29.36,27.52 29.37,27.54 29.37,27.72 29.48,27.83 29.48,28.82 29.53,28.87 29.59,28.87
L_SPK+ on IN2 (solid shape): 21.43,12.13 21.43,11.59 19.91,10.06 19.65,10.06 19.55,10.16 19.55,10.53 19.8,10.79 19.8,11.62 20.79,12.61 20.95,12.61
L_SPK+ on IN2 (solid shape): 29.87,27.02 29.87,25.11 29.61,24.86 28.85,24.86 28.72,24.98 28.72,25.85 28.86,25.99 28.9,26.03 28.96,26.04 29.31,26.3 29.11,26.7 29.05,26.77 29.08,26.86 29.36,27.14 29.74,27.14
L_SPK- on TOP (solid shape): 22.88,12.23 22.88,11.83 21.79,10.74 21.79,7.71 21.66,7.59 21.03,7.59 20.77,7.84 20.77,10.71 21.43,11.37 21.53,11.37 21.97,11.8 21.97,12.18 22.09,12.31 22.8,12.31
L_SPK- on TOP (solid shape): 30.04,28.84 30.04,27.44 30.5,26.98 30.5,25.68 30.46,25.64 30.09,25.64 30.01,25.73 30.01,26.37 30.03,26.53 29.99,26.68 29.99,27.02 29.84,27.17 29.84,28.84 29.85,28.86 30.02,28.86
L_SPK- on IN2 (solid shape): 24.63,12.63 24.63,12.28 23.94,11.6 22.95,11.6 22.89,11.53 22.88,11.53 22.8,11.47 22.74,11.38 22.74,11.38 22.25,10.89 22.25,10.17 22.11,10.03 21,10.03 20.87,10.17 20.87,10.66 21.7,11.49 21.7,11.72 22.41,12.43 23.28,12.43 23.94,13.09 24.17,13.09
L_SPK- on IN2 (solid shape): 30.53,26.89 30.61,26.85 30.63,26.76 30.62,26.57 30.72,26.42 30.75,26.34 30.71,26.26 30.62,25.85 31.01,25.67 31.1,25.65 31.14,25.57 31.14,23.59 30.88,23.33 30.5,23.33 30.12,23.71 30.12,26.76 30.25,26.89
LANVCC on TOP (solid shape): 348.71,69.21 348.71,68.11 348.67,68.07 348.66,68.07 348.39,67.81 348.39,67.45 349.08,66.77 349.08,66.12 349.68,65.52 349.68,64.83 349.59,64.75 349.57,64.74 347.99,64.74 347.91,64.77 347.89,64.85 347.74,65.17 347.34,65.19 346.99,65.19 346.9,65.28 346.9,65.69 347,65.79 347,67 346.81,67.19 346.44,67.19 346.29,67.33 346.29,67.61 346.35,67.67 347.68,67.67 347.76,67.74 347.82,67.74 347.82,68.23 347.8,68.25 347.8,68.61 348.41,69.23 348.69,69.23
LCDVCC on TOP (solid shape): 338.67,81.78 338.67,79.82 338.56,79.72 338.48,79.6 338.47,79.57 337.08,79.57 337.02,79.62 336.95,79.65 336.84,79.76 336.7,79.81 336.7,81.02 337.03,81.35 337.72,81.35 337.82,81.45 337.82,81.96 337.87,82.02 338.43,82.02
LCDVCC on TOP (solid shape): 326.66,75.53 328.82,75.53 328.9,75.45 328.92,75.42 328.91,75.39 328.86,75.25 328.86,75.09 328.85,75.06 328.82,75.04 328.56,74.67 328.82,74.29 328.85,74.27 328.86,74.24 328.86,74.12 328.9,74 328.9,73.97 328.88,73.94 328.7,73.75 326.75,73.75 326.42,74.08 325.8,74.08 325.65,74.24 325.65,75.53 325.78,75.66 326.54,75.66
LCDVCC on BOTTOM (solid shape): 349.92,94.34 349.92,93.26 349.83,93.17 348.53,93.17 348.29,93.42 348.29,94.4 348.35,94.46 349.79,94.46
LCDVCC on BOTTOM (solid shape): 338.79,84.24 338.8,84.16 338.83,84.1 338.83,83.85 338.79,83.77 338.71,83.75 337.84,83 338.71,82.25 338.79,82.23 338.83,82.15 338.83,80.85 338.63,80.65 336.21,80.65 336.11,80.76 336.11,84.15 336.55,84.6 338.43,84.6
LCDVCC on IN1 (solid shape): outline of 1071 points within 326.86,74.5 338.81,81.39
LCDVCC on IN2 (solid shape): outline of 856 points within 336.14,80.76 349.33,94.47
LCDVCC_R on TOP (solid shape): 339.48,80.3 339.72,80.3 339.72,81.48 339.98,81.48 339.98,80.3 340.22,80.3 340.22,81.48 340.46,81.48 340.48,81.46 340.48,81.14 340.4,81.06 340.4,79.67 340.02,79.29 340.02,78.63 340.32,78.34 340.32,78.01 340.26,77.95 338.68,77.95 337.99,77.27 337.82,77.27 337,78.08 337,78.95 337.06,78.99 337.08,79.02 338.73,79.02 338.74,79.03 339.15,79.13 339.24,79.54 339.19,79.68 339.1,79.78 339.1,81.41 339.17,81.48 339.48,81.48
LX on TOP (solid shape): 346.39,70.52 346.39,69.75 346.53,69.61 346.57,69.61 346.9,69.45 347.21,69.63 348.29,69.63 348.32,69.6 348.32,69.33 347.54,68.56 345.18,68.56 345.05,68.68 345.05,70.66 345.12,70.73 346.19,70.73
MIC2-L on TOP (solid shape): 24.91,25.09 24.91,23.92 24.81,23.82 24.58,23.82 24.17,24.23 23.76,24.23 23.69,24.3 23.69,25.06 23.79,25.16 24.84,25.16
MIC2-L on TOP (solid shape): 25.8,31.72 27.07,31.72 27.1,31.69 27.1,31.62 27.06,31.59 25.93,31.59 25.8,31.46 25.17,31.46 25.04,31.33 23.93,31.33 23.77,31.49 23.77,31.72 23.9,31.84 25.67,31.84
MIC2-L on IN5 (solid shape): 24.7,25.16 24.7,23.87 24.64,23.82 22.75,23.82 22.6,23.97 22.6,25.06 22.7,25.16 24.69,25.16
MIC2-L on IN5 (solid shape): 24.99,32.15 24.99,31.51 24.84,31.36 22.96,31.36 22.78,31.54 22.78,32.55 22.96,32.73 24.4,32.73
MIC2-L_1 on TOP (solid shape): 23.49,26.78 23.49,26.07 23.49,25.42 23.32,25.25 23.23,25.25 23.2,25.24 23.18,25.24 22.78,25.24 22.56,25.02 21.75,25.02 21.43,24.71 20.47,24.71 20.29,24.88 20.29,25.43 20.3,25.45 20.31,25.47 20.37,25.51 20.42,25.56 21,25.56 21.06,25.56 21.12,25.57 21.75,26.2 21.76,26.36 21.74,26.51 21.73,26.54 21.74,26.57 21.74,26.79 21.81,26.87 23.4,26.87
MIC2-L_C on TOP (solid shape): 23.46,24.73 23.46,24.18 23.37,24.09 21.84,24.09 21.76,24.17 21.76,24.48 21.77,24.48 21.77,24.63 21.9,24.76 22.8,24.76 22.89,24.85 23.35,24.85
MIC2-R on TOP (solid shape): 25.11,22.41 25.11,21.69 24.39,20.97 24.01,20.97 23.99,20.97 23.97,20.98 23.87,21.09 23.87,21.61 23.87,21.61 23.87,22.44 24.02,22.6 24.93,22.6
MIC2-R on TOP (solid shape): 27.09,31.32 27.09,31.23 27.06,31.21 25.93,31.21 25.67,30.95 25.42,30.95 25.17,30.7 23.92,30.7 23.75,30.87 23.75,31.06 23.9,31.21 25.17,31.21 25.29,31.33 27.07,31.33
MIC2-R on IN5 (solid shape): 25.17,31.13 25.17,30.22 24.99,30.04 23.44,30.04 23.24,30.24 23.24,31.06 23.41,31.23 25.06,31.23
MIC2-R on IN5 (solid shape): 26.44,22.88 26.44,22.2 25.29,21.05 24.04,21.05 23.81,21.27 23.81,22.48 24.05,22.71 25.21,22.71 25.51,23.01 26.32,23.01
MIC2-R_1 on TOP (solid shape): 23.59,23.7 23.59,23.2 23.48,23.09 22.1,23.09 21.66,22.65 20.74,22.65 20.62,22.67 20.5,22.65 20.33,22.65 19.64,21.96 16.76,21.96 16.63,22.09 16.63,22.8 16.78,22.95 19.41,22.95 19.97,23.51 21.36,23.51 21.67,23.83 23.47,23.83
MIC2-R_C on TOP (solid shape): 23.64,22.71 23.64,22.19 23.48,22.03 22.09,22.03 21.99,22.12 21.99,22.75 22.1,22.86 23.49,22.86
NVVDD on TOP (solid shape): 154.81,132.29 154.86,132.28 154.92,132.28 155.33,131.87 155.33,131.62 155.12,131.41 152.36,131.41 152.18,131.59 152.18,131.87 152.59,132.28 152.65,132.28 152.71,132.29 152.81,132.28 152.99,132.1 153.12,132.1 153.3,132.28 153.35,132.28 153.41,132.29 153.47,132.28 153.51,132.28 153.77,132.02 154.44,132.02 154.7,132.28 154.76,132.28
NVVDD on TOP (solid shape): 170.46,137.05 170.46,136.85 170.29,136.67 170.15,136.67 169.9,136.42 169.13,136.42 168.97,136.58 168.89,136.58 168.81,136.59 168.66,136.58 168.5,136.42 167.73,136.42 167.61,136.55 167.58,136.55 167.57,136.55 167.41,136.59 167.25,136.55 167.24,136.55 167.22,136.55 167.11,136.44 167,136.44 166.88,136.56 166.88,136.79 167.17,137.08 167.24,137.13 167.29,137.2 167.49,137.2 167.64,137.05 168.54,137.05 168.56,137.08 168.57,137.08 168.64,137.13 168.68,137.19 168.92,137.19 168.95,137.16 168.98,137.13 169.08,137.03 169.94,137.03 170.12,137.21 170.31,137.21
NVVDD on TOP (solid shape): outline of 4010 points within 144.42,79.14 197.23,141.6
NVVDD on BOTTOM (solid shape): 155.04,139.89 155.04,139.64 154.91,139.51 152.6,139.51 152.47,139.64 152.47,139.89 152.6,140.02 154.91,140.02
NVVDD on BOTTOM (solid shape): 155.04,139.89 155.04,139.64 154.91,139.51 152.6,139.51 152.47,139.64 152.47,139.89 152.6,140.02 154.91,140.02
NVVDD on BOTTOM (solid shape): 150.23,96.8 151.01,96.8 156.38,91.43 156.38,91.43 156.51,91.3 167.69,91.3 172.18,86.81 172.18,84.19 171.85,83.86 153.41,83.86 146.76,90.52 146.76,96.59 147.42,97.25 149.78,97.25
NVVDD on BOTTOM (solid shape): 154.61,138.6 154.93,138.6 155.08,138.45 155.08,138.25 154.97,138.13 154.67,138.13 154.6,138.2 153.57,138.2 153.5,138.13 152.58,138.13 152.47,138.25 152.47,138.57 152.55,138.65 153.68,138.65 153.8,138.78 154.43,138.78
NVVDD on BOTTOM (solid shape): 170.45,137.07 170.45,136.85 170.33,136.72 170.12,136.72 169.77,136.36 169.74,136.34 169.33,136.34 168.99,136.67 167.35,136.67 167.33,136.69 167.27,136.69 167.15,136.81 167.15,137.05 167.31,137.21 170.31,137.21
NVVDD on BOTTOM (solid shape): 154.64,135.8 154.88,135.8 155.05,135.63 155.05,135.48 154.87,135.31 152.03,135.31 151.89,135.45 151.89,135.73 151.91,135.75 152.42,135.75 152.5,135.83 152.54,135.83 152.55,135.83 152.6,135.83 152.6,135.83 153.61,135.83 153.81,136.03 154.41,136.03
NVVDD on BOTTOM (solid shape): 169.76,133.09 169.76,132.71 169.66,132.61 169.05,132.61 168.97,132.53 168.51,132.53 168.28,132.76 167.83,132.76 167.6,132.53 167.29,132.53 167.17,132.66 167.17,132.86 167.32,133.02 167.5,133.02 167.59,133.11 168.54,133.11 168.59,133.07 169.05,133.07 169.2,133.22 169.63,133.22
NVVDD on BOTTOM (solid shape): 170,123.26 170.34,123.26 170.44,123.16 170.44,122.83 170.3,122.69 169.99,122.69 169.8,122.88 169.25,122.88 169.06,122.69 168.68,122.69 168.57,122.79 168.57,123.05 168.77,123.24 169.05,123.24 169.23,123.43 169.83,123.43
NVVDD on BOTTOM (solid shape): 154.57,138.64 154.62,138.61 154.67,138.6 154.93,138.6 155.08,138.45 155.08,138.25 154.97,138.13 154.67,138.13 154.65,138.15 154.6,138.19 154.54,138.2 153.63,138.2 153.57,138.19 153.52,138.15 153.5,138.13 152.58,138.13 152.47,138.25 152.47,138.57 152.55,138.65 153.62,138.65 153.68,138.67 153.72,138.7 153.8,138.78 154.43,138.78
NVVDD on BOTTOM (solid shape): 170.44,137.08 170.45,137.07 170.45,137.05 170.45,136.85 170.33,136.72 170.18,136.72 170.13,136.71 170.08,136.68 169.74,136.34 169.33,136.34 169.04,136.63 168.99,136.66 168.94,136.67 167.34,136.67 167.31,136.69 167.27,136.69 167.17,136.8 167.16,136.82 167.15,136.84 167.15,137.03 167.16,137.05 167.17,137.06 167.31,137.21 170.31,137.21
NVVDD on BOTTOM (solid shape): 169.77,133.08 169.77,132.72 169.74,132.69 169.74,132.69 169.66,132.61 169.05,132.61 168.97,132.53 168.79,132.53 168.51,132.53 168.28,132.76 167.83,132.76 167.6,132.53 167.31,132.53 167.29,132.54 167.28,132.55 167.17,132.66 167.17,132.86 167.3,133 167.32,133.01 167.34,133.02 167.5,133.02 167.59,133.11 168.54,133.11 168.59,133.07 169.05,133.07 169.2,133.22 169.63,133.22
NVVDD on BOTTOM (solid shape): 166.92,132.17 166.92,131.94 166.71,131.73 166.69,131.73 166.62,131.72 166.54,131.69 165.46,131.69 165.45,131.69 165.3,131.73 165.14,131.69 165.13,131.69 164.07,131.69 164.02,131.71 163.97,131.72 163.95,131.74 163.34,131.74 163.29,131.69 163.29,131.31 163.27,131.28 163.11,131.28 163.06,131.33 163.06,131.84 162.89,132.01 162.88,132.03 162.88,132.05 162.71,132.37 162.35,132.4 162.32,132.39 162.3,132.41 162.28,132.43 162.28,132.62 162.28,132.62 162.28,132.89 162.38,132.99 166.11,132.99
NVVDD on BOTTOM (solid shape): 154.39,136.04 154.41,136.03 154.42,136.02 154.6,135.84 154.65,135.81 154.7,135.8 154.88,135.8 154.97,135.72 155.05,135.63 155.05,135.48 154.87,135.31 151.98,135.31 151.86,135.42 151.85,135.44 151.85,135.45 151.85,135.74 151.86,135.75 152.37,135.75 152.41,135.76 152.46,135.79 152.47,135.79 152.47,135.8 152.5,135.83 152.57,135.83 153.56,135.83 153.61,135.85 153.66,135.88 153.81,136.04 153.82,136.04
NVVDD on BOTTOM (solid shape): 156.05,134.81 156.05,134.03 155.7,133.67 155.7,133.59 155.55,133.23 155.29,133.52 154.93,133.87 152.7,133.87 152.63,133.94 152.55,134 152.47,134.1 152.47,134.35 152.54,134.42 154.81,134.42 154.85,134.43 154.89,134.45 155.07,134.6 155.14,134.7 155.14,134.7 155.22,134.78 155.25,134.82 155.27,134.87 155.37,134.97 155.9,134.97
NVVDD on BOTTOM (solid shape): 166.12,132.98 166.92,132.17 166.92,132.15 166.94,132.06 166.92,131.98 166.92,131.94 166.71,131.73 166.69,131.73 166.62,131.72 166.54,131.69 166.31,131.69 166.31,131.68 165.5,131.68 165.5,131.69 165.46,131.69 165.45,131.69 165.3,131.73 165.14,131.69 165.13,131.69 164.89,131.69 164.89,131.68 164.08,131.68 164.03,131.71 163.97,131.72 163.95,131.74 163.48,131.74 163.35,131.69 163.29,131.55 163.29,131.29 163.28,131.28 163.11,131.28 163.06,131.33 163.06,131.84 162.89,132.01 162.88,132.03 162.88,132.05 162.71,132.37 162.35,132.4 162.32,132.39 162.3,132.41 162.28,132.43 162.28,132.62 162.28,132.62 162.28,132.89 162.38,132.99 162.42,133.02 166.07,133.02
NVVDD on BOTTOM (solid shape): 157.08,124.96 157.13,124.96 157.34,124.75 157.37,124.75 157.38,124.74 157.42,124.74 157.43,124.74 157.61,124.69 157.78,124.74 157.8,124.74 157.94,124.74 158.15,124.96 158.45,124.96 158.73,124.68 159.74,124.68 159.76,124.66 159.89,124.66 159.91,124.65 159.92,124.64 159.99,124.58 160.45,124.58 160.52,124.5 160.52,124.2 160.45,124.13 153.26,124.13 153.16,124.23 153.14,124.25 153.14,124.27 153.14,124.6 153.25,124.71 153.31,124.71 153.31,124.71 153.42,124.69 153.52,124.71 153.53,124.71 153.6,124.71 153.63,124.74 153.7,124.74 153.86,124.91 153.88,124.92 154.31,124.92 154.33,124.91 154.35,124.9 154.49,124.75 154.57,124.75 154.58,124.74 154.62,124.74 154.63,124.74 154.81,124.69 154.98,124.74 155,124.74 155.07,124.74 155.08,124.75 155.1,124.75 155.28,124.93 155.76,124.93 155.91,124.78 155.92,124.78 155.95,124.74 156.02,124.74 156.03,124.74 156.21,124.69 156.38,124.74 156.4,124.74 156.44,124.74 156.65,124.96 156.72,124.96 156.74,124.97 157.06,124.97
NVVDD on BOTTOM (solid shape): 157.46,137.32 157.61,137.29 157.76,137.32 157.77,137.33 158.85,137.33 158.86,137.32 159.01,137.29 159.16,137.32 159.17,137.33 159.55,137.33 159.56,137.32 159.69,137.29 159.82,137.31 159.84,137.32 159.87,137.31 159.96,137.22 159.96,136.86 159.99,136.83 159.99,136.75 159.85,136.62 159.83,136.61 159.81,136.62 159.69,136.63 159.56,136.6 159.55,136.6 158.46,136.6 158.45,136.6 158.31,136.63 158.16,136.6 158.15,136.6 157.76,136.6 157.75,136.6 157.61,136.63 157.46,136.6 157.44,136.6 157.35,136.52 157.28,136.44 157.17,136.33 156.61,136.33 156.58,136.34 156.56,136.36 156.19,136.63 155.84,136.32 155.84,136.32 155.42,136.32 155.19,136.55 155.19,136.57 155.04,136.72 154.6,136.72 154.53,136.8 154.53,137.15 154.6,137.23 157.18,137.23 157.28,137.33 157.45,137.33
NVVDD on BOTTOM (solid shape): outline of 82 points within 162.28,139.51 169.04,140.26
NVVDD on BOTTOM (solid shape): outline of 264 points within 151.75,126.18 161.17,128.98
NVVDD on BOTTOM (solid shape): outline of 249 points within 161.24,125.52 170.44,131.61
NVVDD on BOTTOM (solid shape): outline of 841 points within 151.68,129.73 170.43,141.61
NVVDD on BOTTOM (solid shape): outline of 1100 points within 162.28,113.58 186.46,124.91
NVVDD on IN1 (solid shape): 172.18,87.6 172.18,85.21 171.09,84.12 152.75,84.12 151.06,85.8 151.06,86.88 152.04,87.86 155.93,87.86 157.22,89.16 170.62,89.16
NVVDD on IN1 (solid shape): 155.49,92.29 155.5,92.29 155.55,92.24 168.78,92.24 169.21,91.81 169.21,90.4 168.68,89.87 156.94,89.87 155.64,88.57 148.29,88.57 146.5,90.36 146.5,96.59 146.98,97.07 150.72,97.07
NVVDD on IN1 (solid shape): outline of 12353 points within 151.66,100.68 193.57,141.14
NVVDD on IN2 (solid shape): 190.24,108.4 193.19,108.4 193.92,107.66 193.92,102.56 192.85,101.48 189.02,101.48 188.31,102.19 188.31,108.2 188.84,108.73 189.91,108.73
NVVDD on IN2 (solid shape): outline of 13313 points within 138.41,84.27 180.84,141.19
NVVDD on SVCC (solid shape): outline of 129 points within 135.91,85.06 195.35,153.13
NVVDD on IN3 (solid shape): outline of 17526 points within 151.56,83.66 195.09,140.9
NVVDD on IN4 (solid shape): 194.1,108.49 194.1,106.14 189.5,101.54 188.97,101.54 188.46,102.05 188.46,108.3 189.25,109.09 193.5,109.09
NVVDD on IN4 (solid shape): outline of 17071 points within 130.62,83.86 179.04,141.71
NVVDD on IN5 (solid shape): outline of 19795 points within 138.7,84.27 197.71,140.94
PEX_PLL_HVDD on BOTTOM (solid shape): 163.62,122.9 163.62,122.52 163.41,122.31 163.38,122.31 163.38,122.28 163.38,122.28 163.38,121.7 163.38,121.69 163.38,121.61 163.46,121.61 163.47,121.6 163.8,121.27 163.8,121.1 163.64,120.94 163.4,120.94 162.88,121.45 162.88,122.22 163.16,122.5 163.16,122.88 163.22,122.93 163.6,122.93
R_SPK+ on TOP (solid shape): 25.29,12.21 25.29,9.01 24.33,8.04 24.33,7.71 24.2,7.59 23.57,7.59 23.31,7.84 23.31,10.84 23.32,10.84 23.32,10.99 23.86,11.53 24.28,11.53 24.45,11.7 24.45,12.08 24.68,12.31 25.19,12.31
R_SPK+ on TOP (solid shape): 30.8,28.79 30.8,27.8 31.53,27.08 31.71,27.08 31.9,26.89 31.9,26.08 31.73,25.91 31.43,25.91 31.37,25.97 31.37,26.94 30.65,27.65 30.65,28.79 30.7,28.85 30.75,28.85
