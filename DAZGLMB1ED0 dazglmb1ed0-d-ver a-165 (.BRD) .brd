# Allegro board DAZGLMB1ED0 dazglmb1ed0-d-ver a-165 (.BRD) .brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
H-C197D126P2
  round 5.004 hole 3.2: 1(0,0)
H-C315D118P2
  round 8.001 hole 2.997: 1(0,0)
H-C315D126P2
  round 8.001 hole 3.2: 1(0,0)
H-C315D162P2
  round 8.001 hole 4.115: 1(0,0)
H-C315D177P2
  round 8.001 hole 4.496: 1(0,0)
H-O152X112D152X112N
  oval 3.861x2.845 hole 3.861x2.845 unplated: (0,0)
H-TBC315IC126D126P2
  round 8.001 hole 3.2: 1(0,0)
H-TIC197BC315D150P2
  round 5.004 hole 3.81: 1(0,0)
HDMI-2HE1673-021111F-19P
  round 0.762 hole 0.559: 1(4.5,6.86) 2(4,5.36) 3(3.5,6.86) 4(3,5.36) 5(2.5,6.86) 6(2,5.36) 7(1.5,6.86) 8(1,5.36) 9(0.5,6.86) 10(0,5.36) 11(-0.5,6.86) 12(-1,5.36) 13(-1.5,6.86) 14(-2,5.36) 15(-2.5,6.86) 16(-3,5.36) 17(-3.5,6.86) 18(-4,5.36) 19(-4.5,6.86)
  oval 1.499x2.896 hole 0.889x2.311: 20(7.25,5.96) 22(-7.25,5.96)
  oval 1.499x1.905 hole 0.889x1.295: 21(7.25,0) 23(-7.25,0)
L2_5X2-1_2H
  rect 0.889x2.108 smd: 1(-0.85,0) 2(0.85,0)
L2_5X2-PHT25201T-R47MS
  rect 0.889x2.108 smd: 1(-0.85,0) 2(0.85,0)
L3_2X2_5-3_2
  rect 1.194x2.007 smd: 1(-1.6,0) 2(1.6,0)
L5_1X5_2-1_6H
  rect 1.905x2.489 smd: 1(-2.047,0) 2(2.047,0)
L6_6X6_6-3_8
  rect 2.362x3.505 smd: 1(-3.025,0) 2(3.025,0)
L10X10-3_8
  rect 4.089x4.089 smd: 1(-4.75,0) 2(4.75,0)
LEDLTST-C19JZRGBW-Q-4P
  rect 0.838x0.66 smd: 1(-0.725,-0.425) 2(-0.725,0.425) 3(0.725,0.425) 4(0.725,-0.425)
LQFP128-16X16-4-1_6H
  rect 0.203x1.499 smd: 1(-6.2,-7.85) 2(-5.8,-7.85) 3(-5.4,-7.85) 4(-5,-7.85) 5(-4.6,-7.85) 6(-4.2,-7.85) 7(-3.8,-7.85) 8(-3.4,-7.85) 9(-3,-7.85) 10(-2.6,-7.85) 11(-2.2,-7.85) 12(-1.8,-7.85) 13(-1.4,-7.85) 14(-1,-7.85) 15(-0.6,-7.85) 16(-0.2,-7.85) 17(0.2,-7.85) 18(0.6,-7.85) 19(1,-7.85) 20(1.4,-7.85) 21(1.8,-7.85) 22(2.2,-7.85) 23(2.6,-7.85) 24(3,-7.85) 25(3.4,-7.85) 26(3.8,-7.85) 27(4.2,-7.85) 28(4.6,-7.85) 29(5,-7.85) 30(5.4,-7.85) 31(5.8,-7.85) 32(6.2,-7.85) 65(6.2,7.85) 66(5.8,7.85) 67(5.4,7.85) 68(5,7.85) 69(4.6,7.85) 70(4.2,7.85) 71(3.8,7.85) 72(3.4,7.85) 73(3,7.85) 74(2.6,7.85) 75(2.2,7.85) 76(1.8,7.85) 77(1.4,7.85) 78(1,7.85) 79(0.6,7.85) 80(0.2,7.85) 81(-0.2,7.85) 82(-0.6,7.85) 83(-1,7.85) 84(-1.4,7.85) 85(-1.8,7.85) 86(-2.2,7.85) 87(-2.6,7.85) 88(-3,7.85) 89(-3.4,7.85) 90(-3.8,7.85) 91(-4.2,7.85) 92(-4.6,7.85) 93(-5,7.85) 94(-5.4,7.85) 95(-5.8,7.85) 96(-6.2,7.85)
  rect 1.499x0.203 smd: 33(7.85,-6.2) 34(7.85,-5.8) 35(7.85,-5.4) 36(7.85,-5) 37(7.85,-4.6) 38(7.85,-4.2) 39(7.85,-3.8) 40(7.85,-3.4) 41(7.85,-3) 42(7.85,-2.6) 43(7.85,-2.2) 44(7.85,-1.8) 45(7.85,-1.4) 46(7.85,-1) 47(7.85,-0.6) 48(7.85,-0.2) 49(7.85,0.2) 50(7.85,0.6) 51(7.85,1) 52(7.85,1.4) 53(7.85,1.8) 54(7.85,2.2) 55(7.85,2.6) 56(7.85,3) 57(7.85,3.4) 58(7.85,3.8) 59(7.85,4.2) 60(7.85,4.6) 61(7.85,5) 62(7.85,5.4) 63(7.85,5.8) 64(7.85,6.2) 97(-7.85,6.2) 98(-7.85,5.8) 99(-7.85,5.4) 100(-7.85,5) 101(-7.85,4.6) 102(-7.85,4.2) 103(-7.85,3.8) 104(-7.85,3.4) 105(-7.85,3) 106(-7.85,2.6) 107(-7.85,2.2) 108(-7.85,1.8) 109(-7.85,1.4) 110(-7.85,1) 111(-7.85,0.6) 112(-7.85,0.2) 113(-7.85,-0.2) 114(-7.85,-0.6) 115(-7.85,-1) 116(-7.85,-1.4) 117(-7.85,-1.8) 118(-7.85,-2.2) 119(-7.85,-2.6) 120(-7.85,-3) 121(-7.85,-3.4) 122(-7.85,-3.8) 123(-7.85,-4.2) 124(-7.85,-4.6) 125(-7.85,-5) 126(-7.85,-5.4) 127(-7.85,-5.8) 128(-7.85,-6.2)
ML1220-SMT
  round 1.092 hole 1.092 unplated: (0,3.988)
  round 0.711 hole 0.711 unplated: (0,-3.988)
  rect 2.997x1.499 smd: 1(-7.391,0) 2(7.391,0)
MSOP8-4_9-65
  rect 0.406x1.448 smd: 1(-0.975,-2.325) 2(-0.325,-2.325) 3(0.325,-2.325) 4(0.975,-2.325) 5(0.975,2.325) 6(0.325,2.325) 7(-0.325,2.325) 8(-0.975,2.325)
NGFF-NASA0-S6701-TS48-75P-KA
  round 1.194 hole 1.194 unplated: (-10,0)
  round 1.702 hole 1.702 unplated: (10,0)
  rect 0.279x1.549 smd: 1(-9.25,5.275) 2(-9,-2.275) 3(-8.75,5.275) 4(-8.5,-2.275) 5(-8.25,5.275) 6(-8,-2.275) 7(-7.75,5.275) 16(-5.5,-2.275) 17(-5.25,5.275) 18(-5,-2.275) 19(-4.75,5.275) 20(-4.5,-2.275) 21(-4.25,5.275) 22(-4,-2.275) 23(-3.75,5.275) 24(-3.5,-2.275) 25(-3.25,5.275) 26(-3,-2.275) 27(-2.75,5.275) 28(-2.5,-2.275) 29(-2.25,5.275) 30(-2,-2.275) 31(-1.75,5.275) 32(-1.5,-2.275) 33(-1.25,5.275) 34(-1,-2.275) 35(-0.75,5.275) 36(-0.5,-2.275) 37(-0.25,5.275) 38(0,-2.275) 39(0.25,5.275) 40(0.5,-2.275) 41(0.75,5.275) 42(1,-2.275) 43(1.25,5.275) 44(1.5,-2.275) 45(1.75,5.275) 46(2,-2.275) 47(2.25,5.275) 48(2.5,-2.275) 49(2.75,5.275) 50(3,-2.275) 51(3.25,5.275) 52(3.5,-2.275) 53(3.75,5.275) 54(4,-2.275) 55(4.25,5.275) 56(4.5,-2.275) 57(4.75,5.275) 58(5,-2.275) 59(5.25,5.275) 60(5.5,-2.275) 61(5.75,5.275) 62(6,-2.275) 63(6.25,5.275) 64(6.5,-2.275) 65(6.75,5.275) 66(7,-2.275) 67(7.25,5.275) 68(7.5,-2.275) 69(7.75,5.275) 70(8,-2.275) 71(8.25,5.275) 72(8.5,-2.275) 73(8.75,5.275) 74(9,-2.275) 75(9.25,5.275)
  rect 1.194x2.743 smd: 76(-10.35,4.5) 77(10.35,4.5)
NGFF-NASM0-B6701-TS18-75P-KM
  round 1.194 hole 1.194 unplated: (-11,0)
  round 1.702 hole 1.702 unplated: (11,0)
  rect 0.279x1.499 smd: 1(-9.25,1.7) 3(-8.75,1.7) 5(-8.25,1.7) 7(-7.75,1.7) 9(-7.25,1.7) 11(-6.75,1.7) 13(-6.25,1.7) 15(-5.75,1.7) 17(-5.25,1.7) 19(-4.75,1.7) 21(-4.25,1.7) 23(-3.75,1.7) 25(-3.25,1.7) 27(-2.75,1.7) 29(-2.25,1.7) 31(-1.75,1.7) 33(-1.25,1.7) 35(-0.75,1.7) 37(-0.25,1.7) 39(0.25,1.7) 41(0.75,1.7) 43(1.25,1.7) 45(1.75,1.7) 47(2.25,1.7) 49(2.75,1.7) 51(3.25,1.7) 53(3.75,1.7) 55(4.25,1.7) 57(4.75,1.7) 67(7.25,1.7) 69(7.75,1.7) 71(8.25,1.7) 73(8.75,1.7) 75(9.25,1.7)
  round 0.762 hole 0.508: 2(-9,-0.89) 4(-8.5,-0.09) 6(-8,-0.89) 8(-7.5,-0.09) 10(-7,-0.89) 12(-6.5,-0.09) 14(-6,-0.89) 16(-5.5,-0.09) 18(-5,-0.89) 20(-4.5,-0.09) 22(-4,-0.89) 24(-3.5,-0.09) 26(-3,-0.89) 28(-2.5,-0.09) 30(-2,-0.89) 32(-1.5,-0.09) 34(-1,-0.89) 36(-0.5,-0.09) 38(0,-0.89) 40(0.5,-0.09) 42(1,-0.89) 44(1.5,-0.09) 46(2,-0.89) 48(2.5,-0.09) 50(3,-0.89) 52(3.5,-0.09) 54(4,-0.89) 56(4.5,-0.09) 58(5,-0.89) 68(7.5,-0.09) 70(8,-0.89) 72(8.5,-0.09) 74(9,-0.89)
  oval 0.889x1.956 hole 0.508x1.753: 76(-11.25,-4.05) 77(11.25,-4.05)
PAD-ZGL-GDDR5X-1
  custom 3.961x3.961 smd: 1(0,0)
  custom 0.05x0.05 smd: 2(11.658,0) 4(85.8,-29.258) 5(-11.7,-36.158)
  custom 0.175x0.175 smd: 3(59.658,0)
PHJK-2SJ3072-170111F-6P
  round 1.397 hole 1.397 unplated: (0,3.25) (0,-3.25)
  oval 0.991x1.702 hole 0.61x1.295: 1(-2.85,6.35) 2(2.7,-1.1) 3(-2.7,-1.95) 4(3.35,-3.15) 5(2.15,6.35) 6(2.75,4.15)
POWER-5_2X5_55-1_27-5P
  rect 0.66x0.508 smd: 1(2.755,-1.905) 2(2.755,-0.635) 3(2.755,0.635) 4(2.755,1.905)
  custom 1.15x1.15 smd: 5(0,0)
POWER-5_2X5_55-1_27-7P
  rect 0.508x0.508 smd: 1(-1.905,-2.825)
  custom 0.475x0.475 smd: 2(0,-2.125)
  rect 0.508x0.66 smd: 5(1.905,2.8) 6(0.635,2.8) 7(-0.635,2.8) 8(-1.905,2.8)
  rect 4.801x2.591 smd: 9(0,0.575)
POWER-5X5-1_27-5P
  rect 1.143x0.762 smd: 1(2.875,-1.905) 2(2.875,-0.635) 3(2.875,0.635) 4(2.875,1.905)
  custom 1.14x1.14 smd: 5(0,0)
QFN10-3X3-5-16P
  rect 0.279x0.838 smd: 1(-1,-1.475) 2(-0.5,-1.475) 3(0,-1.475) 4(0.5,-1.475) 5(1,-1.475) 6(1,1.475) 7(0.5,1.475) 8(0,1.475) 9(-0.5,1.475) 10(-1,1.475)
  custom 0.413x0.413 smd: 11(0,0)
  round 0.508 hole 0.254: 12(-0.75,0.5) 13(0.75,0.5) 14(-0.75,-0.5) 15(0.75,-0.5) 16(0,0)
QFN13-3X3-4
  rect 0.254x1.6 smd: 1(-0.55,-1) 2(-0.05,-1) 3(0.75,-1) 4(1.15,1) 5(0.35,1) 6(-0.55,1)
  custom 0.175x0.175 smd: 7(-1.45,1.2) 13(-1.45,-1.2)
  rect 0.711x0.203 smd: 8(-1.45,0.8) 9(-1.45,0.4) 10(-1.45,0) 11(-1.45,-0.4) 12(-1.45,-0.8)
QFN16-3X3-5-17P-TPS2543RTER
  rect 0.305x0.991 smd: 1(-0.75,-1.6) 2(-0.25,-1.6) 3(0.25,-1.6) 4(0.75,-1.6) 9(0.75,1.6) 10(0.25,1.6) 11(-0.25,1.6) 12(-0.75,1.6)
  rect 0.991x0.305 smd: 5(1.6,-0.75) 6(1.6,-0.25) 7(1.6,0.25) 8(1.6,0.75) 13(-1.6,0.75) 14(-1.6,0.25) 15(-1.6,-0.25) 16(-1.6,-0.75)
  custom 0.415x0.415 smd: 17(0,0)
QFN16-3X3-5-22P-TPS2544RTER
  custom 0.07x0.07 smd: 1(-0.75,-1.475) 2(-0.25,-1.475) 3(0.25,-1.475) 4(0.75,-1.475) 5(1.475,-0.75) 6(1.475,-0.25) 7(1.475,0.25) 8(1.475,0.75) 9(0.75,1.475) 10(0.25,1.475) 11(-0.25,1.475) 12(-0.75,1.475) 13(-1.475,0.75) 14(-1.475,0.25) 15(-1.475,-0.25) 16(-1.475,-0.75)
  rect 1.702x1.702 smd: 17(0,0)
  round 0.508 hole 0.254: 18(-0.5,-0.5) 19(0.5,-0.5) 20(0.5,0.5) 21(-0.5,0.5) 22(0,0)
QFN16-4X4-65-17P-MAX4063
  rect 0.381x1.143 smd: 1(-0.975,-2.025) 2(-0.325,-2.025) 3(0.325,-2.025) 4(0.975,-2.025) 9(0.975,2.025) 10(0.325,2.025) 11(-0.325,2.025) 12(-0.975,2.025)
  rect 1.143x0.381 smd: 5(2.025,-0.975) 6(2.025,-0.325) 7(2.025,0.325) 8(2.025,0.975) 13(-2.025,0.975) 14(-2.025,0.325) 15(-2.025,-0.325) 16(-2.025,-0.975)
  rect 2.108x2.108 smd: 17(0,0)
QFN20-3X3-4-26P
  rect 0.203x0.787 smd: 1(-0.8,-1.5) 2(-0.4,-1.5) 3(0,-1.5) 4(0.4,-1.5) 5(0.8,-1.5) 11(0.8,1.5) 12(0.4,1.5) 13(0,1.5) 14(-0.4,1.5) 15(-0.8,1.5)
  rect 0.787x0.203 smd: 6(1.5,-0.8) 7(1.5,-0.4) 8(1.5,0) 9(1.5,0.4) 10(1.5,0.8) 16(-1.5,0.8) 17(-1.5,0.4) 18(-1.5,0) 19(-1.5,-0.4) 20(-1.5,-0.8)
  rect 1.803x1.803 smd: 21(0,0)
  round 0.508 hole 0.254: 22(-0.5,-0.5) 23(0.5,-0.5) 24(0.5,0.5) 25(-0.5,0.5) 26(0,0)
QFN21-3X4-4-15P
  rect 1.6x0.254 smd: 1(-1,1.05) 2(-1,0.55) 3(-1,-0.25) 4(-1,-1.05) 12(1,-0.65) 13(1,0.15) 14(1,1.05)
  custom 0.2x0.2 smd: 5(0,-1.9)
  custom 0.175x0.175 smd: 15(1.2,1.9) 21(-1.2,1.9)
  rect 0.203x0.787 smd: 16(0.8,1.9) 17(0.4,1.9) 18(0,1.9) 19(-0.4,1.9) 20(-0.8,1.9)
QFN28-4X4-4-38P
  custom 0.05x0.05 smd: 1(-1.2,-2) 2(-0.8,-2) 3(-0.4,-2) 4(0,-2) 5(0.4,-2) 6(0.8,-2) 7(1.2,-2) 8(2,-1.2) 9(2,-0.8) 10(2,-0.4) 11(2,0) 12(2,0.4) 13(2,0.8) 14(2,1.2) 15(1.2,2) 16(0.8,2) 17(0.4,2) 18(0,2) 19(-0.4,2) 20(-0.8,2) 21(-1.2,2) 22(-2,1.2) 23(-2,0.8) 24(-2,0.4) 25(-2,0) 26(-2,-0.4) 27(-2,-0.8) 28(-2,-1.2)
  rect 2.591x2.591 smd: 29(0,0)
  round 0.508 hole 0.254: 30(-1,-1) 31(0,-1) 32(1,-1) 33(1,0) 34(1,1) 35(0,1) 36(-1,1) 37(-1,0) 38(0,0)
QFN31-5X5-5-19P
  rect 0.305x0.61 smd: 1(-1.75,-2.4) 2(-1.25,-2.4) 3(-0.75,-2.4) 4(-0.25,-2.4) 5(0.25,-2.4) 6(0.75,-2.4) 7(1.25,-2.4) 8(1.75,-2.4)
  custom 0.32x0.32 smd: 9(2.4,-1.75)
  custom 0.542x0.542 smd: 12(0,0)
  rect 3.81x0.61 smd: 16(0,2.4)
  rect 0.61x1.295 smd: 24(-2.4,1.25)
  rect 0.559x0.305 smd: 27(-2.4,0.25)
  rect 0.61x0.305 smd: 28(-2.4,-0.25) 29(-2.4,-0.75) 30(-2.4,-1.25) 31(-2.4,-1.75)
  rect 1.422x1.118 smd: 32(-1.05,-1.185)
  rect 0.559x0.356 smd: 33(-1.66,0.225)
QFN32-3X6-4-33P-1H
  rect 0.203x0.889 smd: 1(-2,-1.65) 2(-1.6,-1.65) 3(-1.2,-1.65) 4(-0.8,-1.65) 5(-0.4,-1.65) 6(0,-1.65) 7(0.4,-1.65) 8(0.8,-1.65) 9(1.2,-1.65) 10(1.6,-1.65) 11(2,-1.65) 17(2,1.65) 18(1.6,1.65) 19(1.2,1.65) 20(0.8,1.65) 21(0.4,1.65) 22(0,1.65) 23(-0.4,1.65) 24(-0.8,1.65) 25(-1.2,1.65) 26(-1.6,1.65) 27(-2,1.65)
  rect 0.889x0.203 smd: 12(3.15,-0.8) 13(3.15,-0.4) 14(3.15,0) 15(3.15,0.4) 16(3.15,0.8) 28(-3.15,0.8) 29(-3.15,0.4) 30(-3.15,0) 31(-3.15,-0.4) 32(-3.15,-0.8)
  rect 4.801x1.803 smd: 33(0,0)
QFN32-4X4-4-33P-UP9511Q
  custom 0.051x0.051 smd: 1(-1.4,-2.1) 8(1.4,-2.1) 9(2.1,-1.4) 16(2.1,1.4) 17(1.4,2.1) 24(-1.4,2.1) 25(-2.1,1.4) 32(-2.1,-1.4)
  rect 0.203x0.991 smd: 2(-1,-2.1) 3(-0.6,-2.1) 4(-0.2,-2.1) 5(0.2,-2.1) 6(0.6,-2.1) 7(1,-2.1) 18(1,2.1) 19(0.6,2.1) 20(0.2,2.1) 21(-0.2,2.1) 22(-0.6,2.1) 23(-1,2.1)
  rect 0.991x0.203 smd: 10(2.1,-1) 11(2.1,-0.6) 12(2.1,-0.2) 13(2.1,0.2) 14(2.1,0.6) 15(2.1,1) 26(-2.1,1) 27(-2.1,0.6) 28(-2.1,0.2) 29(-2.1,-0.2) 30(-2.1,-0.6) 31(-2.1,-1)
  rect 2.54x2.54 smd: 33(0,0)
QFN32-5X5-5-33P-TRF7970A
  custom 0.07x0.07 smd: 1(-1.75,-2.475) 2(-1.25,-2.475) 3(-0.75,-2.475) 4(-0.25,-2.475) 5(0.25,-2.475) 6(0.75,-2.475) 7(1.25,-2.475) 8(1.75,-2.475) 9(2.475,-1.75) 10(2.475,-1.25) 11(2.475,-0.75) 12(2.475,-0.25) 13(2.475,0.25) 14(2.475,0.75) 15(2.475,1.25) 16(2.475,1.75) 17(1.75,2.475) 18(1.25,2.475) 19(0.75,2.475) 20(0.25,2.475) 21(-0.25,2.475) 22(-0.75,2.475) 23(-1.25,2.475) 24(-1.75,2.475) 25(-2.475,1.75) 26(-2.475,1.25) 27(-2.475,0.75) 28(-2.475,0.25) 29(-2.475,-0.25) 30(-2.475,-0.75) 31(-2.475,-1.25) 32(-2.475,-1.75)
  rect 3.454x3.454 smd: 33(0,0)
QFN40-5X5-4-41P-IT6515FN
  rect 0.203x0.991 smd: 1(-1.8,-2.6) 2(-1.4,-2.6) 3(-1,-2.6) 4(-0.6,-2.6) 5(-0.2,-2.6) 6(0.2,-2.6) 7(0.6,-2.6) 8(1,-2.6) 9(1.4,-2.6) 10(1.8,-2.6) 21(1.8,2.6) 22(1.4,2.6) 23(1,2.6) 24(0.6,2.6) 25(0.2,2.6) 26(-0.2,2.6) 27(-0.6,2.6) 28(-1,2.6) 29(-1.4,2.6) 30(-1.8,2.6)
  rect 0.991x0.203 smd: 11(2.6,-1.8) 12(2.6,-1.4) 13(2.6,-1) 14(2.6,-0.6) 15(2.6,-0.2) 16(2.6,0.2) 17(2.6,0.6) 18(2.6,1) 19(2.6,1.4) 20(2.6,1.8) 31(-2.6,1.8) 32(-2.6,1.4) 33(-2.6,1) 34(-2.6,0.6) 35(-2.6,0.2) 36(-2.6,-0.2) 37(-2.6,-0.6) 38(-2.6,-1) 39(-2.6,-1.4) 40(-2.6,-1.8)
  rect 3.505x3.505 smd: 41(0,0)
QFN40-6X4-4-41P-0_8H
  custom 0.05x0.05 smd: 1(-1.4,-2.975) 2(-1,-2.975) 3(-0.6,-2.975) 4(-0.2,-2.975) 5(0.2,-2.975) 6(0.6,-2.975) 7(1,-2.975) 8(1.4,-2.975) 9(1.975,-2.2) 10(1.975,-1.8) 11(1.975,-1.4) 12(1.975,-1) 13(1.975,-0.6) 14(1.975,-0.2) 15(1.975,0.2) 16(1.975,0.6) 17(1.975,1) 18(1.975,1.4) 19(1.975,1.8) 20(1.975,2.2) 21(1.4,2.975) 22(1,2.975) 23(0.6,2.975) 24(0.2,2.975) 25(-0.2,2.975) 26(-0.6,2.975) 27(-1,2.975) 28(-1.4,2.975) 29(-1.975,2.2) 30(-1.975,1.8) 31(-1.975,1.4) 32(-1.975,1) 33(-1.975,0.6) 34(-1.975,0.2) 35(-1.975,-0.2) 36(-1.975,-0.6) 37(-1.975,-1) 38(-1.975,-1.4) 39(-1.975,-1.8) 40(-1.975,-2.2)
  rect 2.692x4.699 smd: 41(0,0)
QFN40-6X4-4-49P-SMT
  custom 0.05x0.05 smd: 1(-1.4,-3.014) 2(-1,-3.014) 3(-0.6,-3.014) 4(-0.2,-3.014) 5(0.2,-3.014) 6(0.6,-3.014) 7(1,-3.014) 8(1.4,-3.014) 9(2.014,-2.2) 10(2.014,-1.8) 11(2.014,-1.4) 12(2.014,-1) 13(2.014,-0.6) 14(2.014,-0.2) 15(2.014,0.2) 16(2.014,0.6) 17(2.014,1) 18(2.014,1.4) 19(2.014,1.8) 20(2.014,2.2) 21(1.4,3.014) 22(1,3.014) 23(0.6,3.014) 24(0.2,3.014) 25(-0.2,3.014) 26(-0.6,3.014) 27(-1,3.014) 28(-1.4,3.014) 29(-2.014,2.2) 30(-2.014,1.8) 31(-2.014,1.4) 32(-2.014,1) 33(-2.014,0.6) 34(-2.014,0.2) 35(-2.014,-0.2) 36(-2.014,-0.6) 37(-2.014,-1) 38(-2.014,-1.4) 39(-2.014,-1.8) 40(-2.014,-2.2)
  rect 2.692x4.699 smd: 41(0,0)
  round 0.508 hole 0.254: 42(0,-2.1) 43(1.1,-0.75) 44(1.1,0.75) 45(0,2.1) 46(-1.1,0.75) 47(-1.1,-0.75) 48(0,-0.75) 49(0,0.75)
QFN48-6X6-4-49P-ALC280
  rect 0.203x0.991 smd: 1(-2.2,-3.1) 2(-1.8,-3.1) 3(-1.4,-3.1) 4(-1,-3.1) 5(-0.6,-3.1) 6(-0.2,-3.1) 7(0.2,-3.1) 8(0.6,-3.1) 9(1,-3.1) 10(1.4,-3.1) 11(1.8,-3.1) 12(2.2,-3.1) 25(2.2,3.1) 26(1.8,3.1) 27(1.4,3.1) 28(1,3.1) 29(0.6,3.1) 30(0.2,3.1) 31(-0.2,3.1) 32(-0.6,3.1) 33(-1,3.1) 34(-1.4,3.1) 35(-1.8,3.1) 36(-2.2,3.1)
  rect 0.991x0.203 smd: 13(3.1,-2.2) 14(3.1,-1.8) 15(3.1,-1.4) 16(3.1,-1) 17(3.1,-0.6) 18(3.1,-0.2) 19(3.1,0.2) 20(3.1,0.6) 21(3.1,1) 22(3.1,1.4) 23(3.1,1.8) 24(3.1,2.2) 37(-3.1,2.2) 38(-3.1,1.8) 39(-3.1,1.4) 40(-3.1,1) 41(-3.1,0.6) 42(-3.1,0.2) 43(-3.1,-0.2) 44(-3.1,-0.6) 45(-3.1,-1) 46(-3.1,-1.4) 47(-3.1,-1.8) 48(-3.1,-2.2)
  rect 4.394x4.394 smd: 49(0,0)
QFN48-6X6-4-49P-MP2939
  rect 0.203x0.711 smd: 1(-2.2,-2.95) 2(-1.8,-2.95) 3(-1.4,-2.95) 4(-1,-2.95) 5(-0.6,-2.95) 6(-0.2,-2.95) 7(0.2,-2.95) 8(0.6,-2.95) 9(1,-2.95) 10(1.4,-2.95) 11(1.8,-2.95) 12(2.2,-2.95) 25(2.2,2.95) 26(1.8,2.95) 27(1.4,2.95) 28(1,2.95) 29(0.6,2.95) 30(0.2,2.95) 31(-0.2,2.95) 32(-0.6,2.95) 33(-1,2.95) 34(-1.4,2.95) 35(-1.8,2.95) 36(-2.2,2.95)
  rect 0.711x0.203 smd: 13(2.95,-2.2) 14(2.95,-1.8) 15(2.95,-1.4) 16(2.95,-1) 17(2.95,-0.6) 18(2.95,-0.2) 19(2.95,0.2) 20(2.95,0.6) 21(2.95,1) 22(2.95,1.4) 23(2.95,1.8) 24(2.95,2.2) 37(-2.95,2.2) 38(-2.95,1.8) 39(-2.95,1.4) 40(-2.95,1) 41(-2.95,0.6) 42(-2.95,0.2) 43(-2.95,-0.2) 44(-2.95,-0.6) 45(-2.95,-1) 46(-2.95,-1.4) 47(-2.95,-1.8) 48(-2.95,-2.2)
  rect 4.699x4.699 smd: 49(0,0)
R0201
  rect 0.203x0.381 smd: 1(-0.225,0) 2(0.225,0)
R0402
  custom 0.12x0.12 smd: 1(0.39,0) 2(-0.39,0)
R0603
  rect 0.686x0.813 smd: 1(0.6,0) 2(-0.6,0)
R0805
  rect 0.864x1.372 smd: 1(0.88,0) 2(-0.88,0)
R1206
  rect 1.219x1.626 smd: 1(1.4,0) 2(-1.4,0)
RC2512-0_6H
  rect 2.108x3.988 smd: 1(-3.1,0) 2(3.1,0)
RC3720-SMT
  rect 3.759x1.016 smd: 1(0,1.008) 2(0,-1.008)
RJ45-C100KB-10809-L-8P
  round 1.295 hole 0.889: 1(-3.556,8.4) 2(-2.54,9.5) 3(-1.524,8.4) 4(-0.508,9.5) 5(0.508,8.4) 6(1.524,9.5) 7(2.54,8.4) 8(3.556,9.5)
  oval 1.727x3.607 hole 0.711x2.591: 9(-9.325,0) 10(9.325,0)
S0201
  rect 0.343x0.381 smd: 1(-0.225,0) 2(0.225,0)
S0402
  custom 0.125x0.125 smd: 1(0.39,0) 2(-0.39,0)
S0603
  rect 1.041x0.813 smd: 1(0.6,0) 2(-0.6,0)
S0805
  rect 1.346x1.372 smd: 1(0.88,0) 2(-0.88,0)
SC70-2_1-65-6P
  rect 1.27x0.279 smd: 1(1.02,-0.65) 2(1.02,0) 3(1.02,0.65) 4(-1.02,0.65) 5(-1.02,0) 6(-1.02,-0.65)
SHORT3720
  rect 3.759x1.537 smd: 1(0,1.008) 2(0,-1.008)
SOIC8-6-1_27-PM25LV010A
  rect 0.533x1.727 smd: 1(-1.905,-2.733) 2(-0.635,-2.733) 3(0.635,-2.733) 4(1.905,-2.733) 5(1.905,2.733) 6(0.635,2.733) 7(-0.635,2.733) 8(-1.905,2.733)
SOIC8-7_9-1_27
  rect 0.533x1.549 smd: 1(-1.905,-3.775) 2(-0.635,-3.775) 3(0.635,-3.775) 4(1.905,-3.775) 5(1.905,3.775) 6(0.635,3.775) 7(-0.635,3.775) 8(-1.905,3.775)
SOIC8-8-1_27
  rect 0.533x1.6 smd: 1(-1.905,-3.8) 2(-0.635,-3.8) 3(0.635,-3.8) 4(1.905,-3.8) 5(1.905,3.8) 6(0.635,3.8) 7(-0.635,3.8) 8(-1.905,3.8)
SOLDERJUMPER-2
  custom 0.381x0.381 smd: 1(-1.016,0) 2(1.016,0)
SON14-3X2-4-15P-SMT
  custom 0.05x0.05 smd: 1(-1.2,-1.076) 2(-0.8,-1.076) 3(-0.4,-1.076) 4(0,-1.076) 5(0.4,-1.076) 6(0.8,-1.076) 7(1.2,-1.076) 8(1.2,1.076) 9(0.8,1.076) 10(0.4,1.076) 11(0,1.076) 12(-0.4,1.076) 13(-0.8,1.076) 14(-1.2,1.076)
  rect 2.489x0.889 smd: 15(0,0)
SOT23-2_85-95-5P
  rect 0.787x0.559 smd: 1(1.2,-0.95) 2(1.2,0) 3(1.2,0.95) 4(-1.2,0.95) 5(-1.2,-0.95)
SOT23-5
  rect 1.016x0.711 smd: 1(1.2,-0.95) 2(1.2,0) 3(1.2,0.95) 4(-1.2,0.95) 5(-1.2,-0.95)
SOT23-5-2_8-95-5P-1_45H
  rect 1.346x0.559 smd: 1(1.325,-0.95) 2(1.325,0) 3(1.325,0.95) 4(-1.325,0.95) 5(-1.325,-0.95)
SOT23-5-2_8-95-5P-G708
  rect 1.194x0.533 smd: 1(1.5,-0.95) 2(1.5,0) 3(1.5,0.95) 4(-1.5,0.95) 5(-1.5,-0.95)
SOT23-6-2_8-95-6P-G5126TB1U
  rect 1.194x0.508 smd: 1(1.5,-0.95) 2(1.5,0) 3(1.5,0.95) 4(-1.5,0.95) 5(-1.5,0) 6(-1.5,-0.95)
SOT23_213-3_3-2
  rect 1.27x1.016 smd: 1(1.016,1.016) 2(1.016,-1.016) 3(-1.016,0)
SOT323_213-2_1-1_3-3P
  rect 0.559x0.61 smd: 1(0.925,0.65) 2(0.925,-0.65) 3(-0.925,0)
SOT353-1-2_125-65-5P
  rect 1.245x0.279 smd: 1(1.045,-0.65) 2(1.045,0) 3(1.045,0.65) 4(-1.045,0.65) 5(-1.045,-0.65)
SOT523_213-1_6-1-0_6H
  rect 0.457x0.406 smd: 1(0.675,0.5) 2(0.675,-0.5) 3(-0.675,0)
SOT563-1_6-5-6P-PJX138K
  rect 0.457x0.305 smd: 1(0.675,-0.5) 2(0.675,0) 3(0.675,0.5) 4(-0.675,0.5) 5(-0.675,0) 6(-0.675,-0.5)
SPAD-C197NP
  round 5.004 smd: 1(0,0)
SPAD-C315NP
  round 8.001 smd: 1(0,0)
SPAD-RE59X276NP
  rect 1.499x7.01 smd: 1(0,0)
SPAD-RE79X157NP
  rect 2.007x3.988 smd: 1(0,0)
SPAD-RE157X315NP
  rect 3.988x8.001 smd: 1(0,0)
SPAD-RE157X355NP
  rect 3.988x9.017 smd: 1(0,0)
SPAD-RE217X94NP
  rect 5.512x2.388 smd: 1(0,0)
SPAD-RE217X138NP
  rect 5.512x3.505 smd: 1(0,0)
SPAD-RE236X148NP
  rect 5.994x3.759 smd: 1(0,0)
SPAD-RE236X152NP
  rect 5.994x3.861 smd: 1(0,0)
SPAD-RE256X118NP
  rect 6.502x2.997 smd: 1(0,0)
SPAD-RE276X197NP
  rect 7.01x5.004 smd: 1(0,0)
SPAD-RE315X59NP
  rect 8.001x1.499 smd: 1(0,0)
SPAD-RE354X103NP
  rect 8.992x2.616 smd: 1(0,0)
SPAD-RE472X59NP
  rect 11.989x1.499 smd: 1(0,0)
SPAD-RE669X197NP
  rect 16.993x5.004 smd: 1(0,0)
SPAD-RE787X59NP
  rect 19.99x1.499 smd: 1(0,0)
SPAD-RE1024X59NP
  rect 26.01x1.499 smd: 1(0,0)
SPAD-ZGL-GDDR5X-2
  custom 1.303x1.303 smd: 1(0,0)
SSOP5-P-A-TOSHIBA-B
  rect 1.067x0.305 smd: 1(0.85,-0.65) 2(0.85,0) 3(0.85,0.65) 4(-0.85,0.65) 5(-0.85,-0.65)
SW-MLC-63WQR-4P
  round 0.965 hole 0.711: 1(-0.575,2.2) 2(0.575,2.2) 3(1.725,2.2) 4(-1.725,2.2)
  round 2.007 hole 0.991: 5(-1.6,0) 6(1.6,0)
SW-T3AL-23-Q-TR-4P
  rect 0.66x0.711 smd: 1(-1.475,0.95) 2(1.475,0.95) 3(-1.475,-0.95) 4(1.475,-0.95)
TP2050
  round 0.508 smd: 1(0,0)
TP2075
  round 0.508 smd: 1(0,0)
TP2650
  round 0.66 smd: 1(0,0)
TRF-10-1-24P-SMT
  rect 0.61x2.108 smd: 1(-5.5,-5.025) 2(-4.5,-5.025) 3(-3.5,-5.025) 4(-2.5,-5.025) 5(-1.5,-5.025) 6(-0.5,-5.025) 7(0.5,-5.025) 8(1.5,-5.025) 9(2.5,-5.025) 10(3.5,-5.025) 11(4.5,-5.025) 12(5.5,-5.025) 13(5.5,5.025) 14(4.5,5.025) 15(3.5,5.025) 16(2.5,5.025) 17(1.5,5.025) 18(0.5,5.025) 19(-0.5,5.025) 20(-1.5,5.025) 21(-2.5,5.025) 22(-3.5,5.025) 23(-4.5,5.025) 24(-5.5,5.025)
TSOT23-6-2_8-95-6P-1H
  rect 1.194x0.508 smd: 1(1.5,-0.95) 2(1.5,0) 3(1.5,0.95) 4(-1.5,0.95) 5(-1.5,0) 6(-1.5,-0.95)
TSSOP20-6_4-65
  rect 0.305x1.499 smd: 1(-2.925,-3.05) 2(-2.275,-3.05) 3(-1.625,-3.05) 4(-0.975,-3.05) 5(-0.325,-3.05) 6(0.325,-3.05) 7(0.975,-3.05) 8(1.625,-3.05) 9(2.275,-3.05) 10(2.925,-3.05) 11(2.925,3.05) 12(2.275,3.05) 13(1.625,3.05) 14(0.975,3.05) 15(0.325,3.05) 16(-0.325,3.05) 17(-0.975,3.05) 18(-1.625,3.05) 19(-2.275,3.05) 20(-2.925,3.05)
UB2-UARE9-4K1921-4P-L
  round 1.397 hole 0.787: 1(-3.5,7.05) 2(-1,7.05) 3(1,7.05) 4(3.5,7.05)
  oval 1.499x2.692 hole 0.889x2.108: 5(-7.85,7.85) 6(7.85,7.85)
  oval 1.499x2.388 hole 0.889x1.803: 7(-7.85,0) 8(7.85,0)
UB3-TAR24-9V1391-9P
  round 1.194 hole 0.787: 1(-3.5,5.6) 2(-1,5.6) 3(1,5.6) 4(3.5,5.6) 5(4,7.1) 6(2,7.1) 7(0,7.1) 8(-2,7.1) 9(-4,7.1)
  oval 1.397x2.007 hole 0.787x1.397: 10(-6.4,0) 11(6.4,0)
  oval 1.397x2.692 hole 0.787x2.108: 12(6.4,6.1) 13(-6.4,6.1)
UB31-DX07S024JJ2-24P-TBT
  round 0.813 hole 0.813 unplated: (-3.6,0)
  oval 0.813x0.762 hole 0.813x0.762 unplated: (3.6,0.065)
  custom 0.413x0.413 hole 0.61x1.905: 1(-4.32,2) 2(4.32,2)
  oval 1.245x0.711 hole 1.245x0.711: 3(-3.995,1.4) 4(3.995,1.4)
  oval 1.295x2.591 hole 0.711x2.007: 5(-4.32,-3.05) 6(4.32,-3.05)
  rect 0.279x0.889 smd: A1(-2.625,2.7) A2(-2.125,2.7) A3(-1.625,2.7) A4(-1.125,2.7) A5(-0.625,2.7) A6(-0.125,2.7) A7(0.375,2.7) A8(0.875,2.7) A9(1.375,2.7) A10(1.875,2.7) A11(2.375,2.7) A12(2.875,2.7)
  rect 0.279x0.787 smd: B1(2.625,1.1) B2(2.125,1.1) B3(1.625,1.1) B4(1.125,1.1) B5(0.625,1.1) B6(0.125,1.1) B7(-0.375,1.1) B8(-0.875,1.1) B9(-1.375,1.1) B10(-1.875,1.1) B11(-2.375,1.1) B12(-2.875,1.1)
UDFN10-2_5X1-5-9P
  rect 0.203x0.686 smd: 1(-1,-0.437) 2(-0.5,-0.437) 4(0.5,-0.437) 5(1,-0.437) 6(1,0.437) 7(0.5,0.437) 9(-0.5,0.437) 10(-1,0.437)
  rect 0.406x1.549 smd: 3(0,0)
UMT_213-3-1_3
  rect 1.016x0.762 smd: 1(0.991,0.66) 2(0.991,-0.66) 3(-0.991,0)
unnamed#2
  round 1.016 smd: 1(0,0)
WQFN20-3X3-4-21P
  rect 0.203x0.991 smd: 1(-0.8,-1.6) 2(-0.4,-1.6) 3(0,-1.6) 4(0.4,-1.6) 5(0.8,-1.6) 11(0.8,1.6) 12(0.4,1.6) 13(0,1.6) 14(-0.4,1.6) 15(-0.8,1.6)
  rect 0.991x0.203 smd: 6(1.6,-0.8) 7(1.6,-0.4) 8(1.6,0) 9(1.6,0.4) 10(1.6,0.8) 16(-1.6,0.8) 17(-1.6,0.4) 18(-1.6,0) 19(-1.6,-0.4) 20(-1.6,-0.8)
  rect 1.702x1.702 smd: 21(0,0)
XTL-2_05X1_65-1_4X1_1-0_6H
  rect 0.889x0.787 smd: 1(-0.7,-0.55) 2(0.7,-0.55) 3(0.7,0.55) 4(-0.7,0.55)
XTL-2X1_6-1_35X1_05
  rect 0.838x0.762 smd: 1(-0.675,-0.525) 2(0.675,-0.525) 3(0.675,0.525) 4(-0.675,0.525)
XTL-3_2X1_5-2_5-0_8H
  rect 0.991x1.803 smd: 1(-1.25,0) 2(1.25,0)
XTL-3_2X2_5-2_2X1_6-0_9H
  rect 1.397x1.194 smd: 1(-1.1,-0.8) 2(1.1,-0.8) 3(1.1,0.8) 4(-1.1,0.8)

## Nets
1V8_AON_EN: PR9057.2 PR67002.1 U13119.4(Y)
1V8_AON_S: PC9067.1 PC9068.1 PR9055.1 PU9004.8(OUT2#1) PU9004.9(OUT2#2)
1V8_MAIN_EN: PD9000.1(CATHODE) PQ9083.2(BASE) PR9006.1 PR9056.1 PR67233.1 R21589.2 R67323.2 U13114.BE1(GPIO4)
1V8_MAIN_EN_G: PQ9083.3(COLLECTOR) PQ9084.2(G) PR67230.2 PR67232.1
1V8_MAIN_S: PC9065.1 PC9066.1 PR9054.2 PU9004.13(VOUT1#1) PU9004.14(VOUT1#2)
3V_LDO: PC151.1 PR186.1 PR312.1 PR3020.1 PU9.3(VREG3)
5V_HSMBCK: D8559.1(CATHODE1) R21010.2
5V_HSMBDT: D8559.2(CATHODE2) R21011.2
12VL_EN: PR67225.1 R67313.1
51211V_DRVH: PQ9053.1(G1) PU9015.9(UGATE)
51211V_DRVL: PQ9053.8(G2) PU9015.6(LGATE)
51211V_EN: PR114.1 PR115.1 PR266.2 PU9015.3(EN)
51211V_FB: PR267.1 PR67003.1 PU9015.4(FB)
51211V_SW: PC222.1 PL12.1 PQ9053.9(S1/D2) PR112.1 PU9015.8(PHASE)
51211V_TRIP: PR265.2 PU9015.2(CS)
51211V_TST: PR268.2 PU9015.5(RF)
51211V_VBST: PR264.2 PU9015.10(BOOT)
+1.0V_PWRGD_G1: C94818.1 Q7842.2(BASE) R21170.2 R21173.1
+1.0V_PWRGD_G2: Q7840.2(G) Q7842.3(COLLECTOR) R21165.2
+1.2VSUS: C94521.1 C94522.1 C94523.1 C94524.1 C94525.1 C94526.1 C94527.1 C94528.1 C94529.1 C94530.1 C94531.1 C94532.1 C94533.1 C94534.1 C94862.1 C94865.1 C94868.1 C94870.1 C94872.1 C94875.1 C94877.1 C94879.1 C94881.1 C94882.1 C94883.1 C94884.1 C94885.1 C94886.1 C94887.1 C94888.1 C94893.1 C94895.1 C94897.1 C94899.1 C94901.1 C94903.1 C94904.1 C94905.1 C94907.1 C94909.1 C94910.1 C94912.1 C94914.1 C94915.1 C94916.1 C94918.1 C95911.1 C95912.1 C95913.1 C95914.1 CN2062.12(DM0_N/DBI0_N) CN2062.33(DM1_N/DBI1_N) CN2062.54(DM2_N/DBI2_N) CN2062.75(DM3_N/DBI3_N) CN2062.96(DBI8#) CN2062.111(VDD1) CN2062.112(VDD2) CN2062.117(VDD3) CN2062.118(VDD4) CN2062.123(VDD5) CN2062.124(VDD6) CN2062.129(VDD7) CN2062.130(VDD8) CN2062.135(VDD9) CN2062.136(VDD10) CN2062.141(VDD11) CN2062.142(VDD12) CN2062.147(VDD13) CN2062.148(VDD14) CN2062.153(VDD15) CN2062.154(VDD16) CN2062.159(VDD17) CN2062.160(VDD18) CN2062.163(VDD19) CN2062.178(DM4_N/DBI4_N) CN2062.199(DM5_N/DBI5_N) CN2062.220(DM6_N/DBI6_N) CN2062.241(DM7_N/DBI7_N) CN2063.12(DM0_N/DBI0_N) CN2063.33(DM1_N/DBI1_N) CN2063.54(DM2_N/DBI2_N) CN2063.75(DM3_N/DBI3_N) CN2063.96(DBI8#) CN2063.111(VDD1) CN2063.112(VDD2) CN2063.117(VDD3) CN2063.118(VDD4) CN2063.123(VDD5) CN2063.124(VDD6) CN2063.129(VDD7) CN2063.130(VDD8) CN2063.135(VDD9) CN2063.136(VDD10) CN2063.141(VDD11) CN2063.142(VDD12) CN2063.147(VDD13) CN2063.148(VDD14) CN2063.153(VDD15) CN2063.154(VDD16) CN2063.159(VDD17) CN2063.160(VDD18) CN2063.163(VDD19) CN2063.178(DM4_N/DBI4_N) CN2063.199(DM5_N/DBI5_N) CN2063.220(DM6_N/DBI6_N) CN2063.241(DM7_N/DBI7_N) PC2038.1 PJ2003.2 PJ9003.1 PU2001.19(VLDOIN) R151.2 R20821.2 R21108.1 R21387.1 R21395.1 R21396.1 R21397.1 R21398.1 R21399.1 R21400.1 R21401.1 R21402.1 R21403.1 R21404.1 R21405.2 R21410.1 R21411.1 R21414.1 R21422.1 R21423.1 R21424.1 R21425.1 R21426.1 R21427.1 R21428.1 R21429.1 R21430.1 R21431.1 R21432.2 U41.AA6(VDDQ#AA6) U41.AE12(VDDQ#AE12) U41.AF5(VDDQ#AF5) U41.AF6(VDDQ#AF6) U41.AG5(VDDQ#AG5) U41.AG9(VDDQ#AG9) U41.AJ12(VDDQ#AJ12) U41.AL11(VDDQ#AL11) U41.AP6(VDDQ#AP6) U41.AP7(VDDQ#AP7) U41.AR6(VDDQ#AR6) U41.AR12(VDDQ#AR12) U41.AT12(VDDQ#AT12) U41.AW6(VDDQ#AW6) U41.AY6(VDDQ#AY6) U41.J5(VDDQ#J5) U41.J6(VDDQ#J6) U41.K6(VDDQ#K6) U41.K12(VDDQ#K12) U41.L6(VDDQ#L6) U41.L12(VDDQ#L12) U41.R6(VDDQ#R6) U41.T6(VDDQ#T6) U41.W6(VDDQ#W6)
+1.8V: C96235.2 C96236.2 L4272.1 L4273.2 PQ9.1(S) PR9227.1 R20949.1 U13119.5(VCC) U13157.17(AVDD2)
+1.8V_AON: C95078.1 C95131.2 C95132.2 C95133.1 C95134.1 C95148.2 PR9001.1 PR9010.1 PR9018.2 PR9055.2 PR9063.1 PR9124.1 Q7857.2(G) Q7858.2(G) Q7858.5(G) Q7860.2(G) Q7860.5(G) Q7943.2(G) Q7944.2(G) R21502.2 R21507.2 R21536.2 R21537.2 R21538.2 R21542.2 R21543.2 R21544.2 R21545.2 R21546.2 R21547.2 R21548.1 R21552.1 R21559.1 R21560.1 R21561.1 R21562.1 R21569.1 R21570.1 R21571.1 R21572.1 R21583.1 R21584.1 R21588.1 R21589.1 R21590.1 R21591.1 R21592.1 R21593.1 R21594.1 R21595.1 R21596.1 R21597.1 R21598.1 R21599.1 R21600.1 R21601.1 R21602.2 R21608.2 R21610.1 R21616.1 R21617.1 R21618.1 R21881.1 R67309.2 R67320.1 R67331.1 U13114.BA10(1V8_AON_1) U13114.BB14(1V8_AON_2) U13114.BC14(1V8_AON_3) U13116.8(VCC) U13117.8(VCC) U13118.5(VCC) U13120.5(VCC)
+1.8V_MAIN: C95007.1 C95008.2 C95009.2 C95011.2 C95021.2 C95022.2 C95023.2 C95024.2 C95025.2 C95135.2 C95136.2 C95137.2 C95138.1 C95139.1 C95140.1 C95141.2 C95142.2 C95143.2 C95144.2 C95145.2 C95146.2 C95147.2 L4245.2 L4246.1 PR9054.1 PR67231.1 Q34.2(G) Q34.5(G) R21026.2 R21032.2 R21505.2 U13114.AM10(VDD18_01) U13114.AM11(VDD18_02) U13114.AN10(VDD18_03) U13114.AN11(VDD18_04) U13114.AR10(VDD18_05) U13114.AR11(VDD18_06) U13114.AT10(VDD18_07) U13114.AT11(VDD18_08) U13114.AV10(VDD18_09) U13114.AV11(VDD18_10) U13114.AW10(VDD18_11) U13114.AW11(VDD18_12) U13114.BB26(PEX_HVDD_1) U13114.BB27(PEX_HVDD_2) U13114.BB29(PEX_HVDD_3) U13114.BB32(PEX_HVDD_4) U13114.BC26(PEX_HVDD_5) U13114.BC27(PEX_HVDD_6) U13114.BC29(PEX_HVDD_7) U13114.BC30(PEX_HVDD_8) U13114.BC32(PEX_HVDD_9) U13114.BD27(PEX_HVDD_10) U13114.BD30(PEX_HVDD_11)
+1.8V_S5: JP10.2 PQ9.3(D) PR9225.1 PR9226.1
+1.8VPCU: PR66837.2 PR66866.1
+1V_GFX: C95002.2 C95003.2 C95004.2 C95005.2 C95012.1 C95013.2 C95014.2 C95015.2 C95016.2 C95066.1 C95067.1 C95068.2 C95069.1 C95071.1 C95072.1 C95073.1 C95074.1 C95075.1 C95076.2 C95077.1 PJ9004.2 U13114.BB15(IFP_IOVDD_1) U13114.BB17(IFP_IOVDD_2) U13114.BB18(IFP_IOVDD_3) U13114.BB20(IFP_IOVDD_4) U13114.BB21(IFP_IOVDD_5) U13114.BB23(IFP_IOVDD_6) U13114.BB33(PEX_DVDD_1) U13114.BB35(PEX_DVDD_2) U13114.BB36(PEX_DVDD_3) U13114.BC15(IFP_IOVDD_7) U13114.BC17(IFP_IOVDD_8) U13114.BC18(IFP_IOVDD_9) U13114.BC20(IFP_IOVDD_10) U13114.BC21(IFP_IOVDD_11) U13114.BC23(IFP_IOVDD_12) U13114.BC33(PEX_DVDD_4) U13114.BC35(PEX_DVDD_5) U13114.BC36(PEX_DVDD_6) U13114.BD33(PEX_DVDD_7) U13114.BD36(PEX_DVDD_8)
+1V_GFX_PG: PR9063.2 PR9077.2 R21608.1 U13118.2(A)
+1V_GFX_S: PC9076.1 PC9077.1 PC9078.1 PC9079.1 PJ9004.1 PQ9009.1(S1) PQ9009.2(S2) PQ9009.3(S3) PR9059.1 PR67010.1
+1V_S5: C94836.1 C94837.1 PJ3005.2 PQ9055.3(D) PQ9056.5(D) PR255.1 R21133.2 R21196.1 R21329.1 R21330.1 R21331.2 R21336.1 R21338.1 R21339.1 R21340.1 R21341.2 R21344.1 R21345.1 R21346.2 R21347.1 R21349.1 R21350.1 R21352.1 R21353.1 R21354.1
+1V_S5_ON: PR115.2 R67333.2
+1V_S5_SRC: PC217.1 PC219.1 PJ3005.1 PL12.2 PR67007.1
+1V_S5_VIN: PC220.1 PC221.1 PJ3004.2 PQ9053.2(D1)
+1V_SUS: C85.1 C260.1 C755.1 C96159.1 PC9383.1 PQ9055.1(S) PR41.1 PR43.1 PR44.1 PR86.1 PR255.2 Q20.3(D) R178.1 R180.2 R538.1 R539.1 R544.1 R571.2 R20751.1 R20757.2 R20822.2 R20823.2 R21107.2 U41.H30(VCCST#H30)
+2.5V: PQ40.1(S) PR298.1 R67195.2 R67197.2
+2.5VSUS: C94873.2 C94876.1 C94911.2 C94913.1 C96161.2 C96162.1 C96164.2 C96165.1 CN2062.257(VPP1) CN2062.259(VPP2) CN2063.257(VPP1) CN2063.259(VPP2) PJ3007.2 PQ40.3(D)
+3V: C94705.2 C94823.1 C95553.1 C95554.1 C95623.1 C95624.1 C95990.1 C96223.1 CN2074.2 CN2076.10 L4258.1 L4268.1 L4269.1 L4270.1 L4271.1 PR97.1 PR106.1 PR263.1 PR701.1 PR702.1 PR2016.1 PR6413.2 PR9121.2 PR9165.1 PR66851.2 PR67199.2 PR67201.2 Q7847.2(G) Q7896.2(G) Q7896.5(G) Q7901.2(G) Q7911.2(G) Q7911.5(G) Q7917.2(G) Q7930.2(G) Q7930.5(G) Q7931.2(G) Q7932.2(G) R222.1 R223.1 R813.2 R20881.2 R20889.2 R20900.1 R20941.2 R20943.2 R20955.1 R20964.2 R20973.1 R20974.1 R20987.1 R20988.1 R20994.1 R21039.1 R21052.2 R21053.2 R21058.1 R21060.1 R21088.2 R21089.2 R21090.2 R21092.2 R21093.2 R21099.2 R21101.2 R21132.1 R21172.1 R21174.1 R21176.2 R21177.2 R21178.2 R21193.2 R21194.2 R21195.2 R21198.2 R21200.2 R21201.2 R21202.2 R21203.2 R21204.2 R21205.2 R21207.2 R21210.2 R21212.2 R21214.2 R21215.2 R21216.2 R21235.1 R21251.1 R21309.1 R21311.1 R21313.1 R21316.2 R21318.2 R21319.2 R21327.1 R21328.1 R21342.2 R21359.1 R21386.2 R21389.2 R21390.2 R21391.2 R21416.2 R21417.2 R21418.2 R21457.2 R21587.1 R21720.2 R21725.2 R21747.1 R21769.1 R21789.2 R21970.1 R21977.1 R22001.2 R22007.1 R22087.1 R22092.2 R22100.1 R22101.1 R22137.2 R22138.1 R22140.1 R22163.2 R22167.2 R22168.2 R22171.2 R22191.1 R22212.2 R22214.2 R67025.1 R67041.2 R67148.1 R67196.2 R67228.2 R67229.2 R67231.2 R67233.2 R67235.2 R67239.2 R67262.2 R67290.1 R67351.2 R67353.1 R67366.2 R67370.2 R67388.1 R67398.1 U13080.5(IN) U13102.5(VCC) U13156.5(\S\H\D\N)
+3V3PD: C96013.2 Q7926.2(G) Q7926.5(G) Q7927.2(G) Q7949.2(G) Q7949.5(G) R67112.2 R67121.2 R67131.2 R67132.2 R67133.2 R67134.2 R67145.2 R67249.2 R67250.2 U13155.B1(VDDIO) U13155.H1(VIN_3V3)
+3V_2.5V_VDDSPD-CHA: C94859.1 C94860.1 CN2063.255(VDDSPD) R21386.1 R67195.1
+3V_2.5V_VDDSPD-CHB: C94890.2 C94891.1 CN2062.255(VDDSPD) R67196.1 R67197.1
+3V_AR: C718.2 C94602.1 C94603.2 C94604.2 C94605.2 C95994.1 L4266.2 R22035.1 R67041.1 R67149.2 R67150.2 U21.A2(VCC3P3_SVR#1) U21.A3(VCC3P3_SVR#2) U21.B3(VCC3P3_SVR#3) U21.H9(VCC3P3A)
+3V_DEEP_SUS: C420.1 C812.1 C94809.1 C94824.2 C94855.2 Q7909.2(G) Q7909.5(G) R17808.2 R21077.2 R21078.2 R21079.2 R21080.2 R21081.2 R21082.2 R21083.2 R21084.2 R21105.1 R21124.1 R21126.1 R21128.1 R21130.1 R21139.1 R21140.1 R21143.1 R21144.1 R21146.1 R21147.1 R21149.1 R21151.1 R21153.1 R21164.2 R21219.1 R21220.1 R21221.2 R21223.2 R21224.2 R21226.2 R21227.2 R21228.2 R21230.1 R21232.2 R21236.1 R21238.1 R21240.2 R21244.2 R21252.1 R21253.1 R21254.1 R21270.1 R21272.2 R21274.1 R21281.2 R21283.1 R21285.2 R21287.2 R21289.2 R21291.2 R21293.2 R21295.2 R21297.2 R21298.2 R21301.2 R21303.2 R21305.2 R21317.1 R21324.2 R21326.2 R21332.2 R21333.2 R21334.2 R21335.2 R21337.2 R21343.2 R21348.2 R21351.2 R21355.1 R21356.2 R21412.1 R22032.2 R67208.2 R67211.2 R67214.2 R67221.2 R67225.2 R67227.2 R67236.1 R67237.1 R67243.1 R67405.1 R67406.1 U53.5(VCC) U13064.5(VCC) U13098.5(VCC) U13103.8(VCC)
+3V_DVDD: C95902.2 C95903.2 L4269.2 R21475.1 U13108.3(DVDD)
+3V_DVDD_IO: C95904.2 C95905.2 L4270.2 U13108.18(DVDD_IO)
+3V_EC: C892.1 R966.2 R20900.2 U49.11(VCC)
+3V_EDP: C94647.1 C94648.1 C94649.1 C94650.1 C94652.1 C94658.1 L4268.2 R20912.1 R20913.1 R20916.1 R20924.1 R20929.1 R20930.1 R20934.1 R20936.1 R67381.2 U13079.1(VCC#1) U13079.6(VCC#2) U13079.20(VCC#3) U13079.28(VCC#4)
+3V_KB_P: R67025.2 U13093.27(VCC)
+3V_LDO_EC: D19.1(CATHODE) PR287.2 PR312.2 R382.2 R388.2 R816.2 R823.2 R20887.2 R20894.2 R20901.1 R22145.1 R67293.1 R67364.2
+3V_MINIDP: C94718.1 C94724.1 CN2043.20(DP_PWR) ESD8.6(NC#1) R20985.1 R22073.2
+3V_RTC: C94811.1 C94850.2 C94851.2 D8568.3(COMMON ANODE) R251.1 R618.1 R21137.1 R21142.1 R21231.2 U13113.BA22(VCCRTC)
+3V_RTC_1: CN2054.1 Q7935.1(EMITTER) R21138.1
+3V_RTC_2: D8568.1(CATHODE1) R21138.2
+3V_S5: C94785.1 C94989.2 C94990.2 L4250.1 L4259.1 PR169.1 PR310.1 PR311.1 Q7838.1(S) Q7939.2(G) R966.1 R21356.1 R21494.2 R22146.1 R22154.1 R67208.1 R67250.1 R67300.2 U13143.16(AVDD33)
+3V_SSD1: C95556.1 C95557.1 C95559.1 C95560.1 C95561.1 C95939.2 C95940.2 C95941.2 CN2069.2 CN2069.4 CN2069.12 CN2069.14 CN2069.16 CN2069.18 CN2069.70 CN2069.72 CN2069.74 R21725.1 R21738.1
+3V_SSD2: C95625.1 C95627.1 C95629.1 C95630.1 C95631.1 C95942.2 C95943.2 C95944.2 CN2070.2 CN2070.4 CN2070.12 CN2070.14 CN2070.16 CN2070.18 CN2070.70 CN2070.72 CN2070.74 R21789.1 R21801.1
+3V_TYPEC_DP: C93696.1 C94542.1 C94543.1 C94544.1 C94545.1 C94547.1 C95998.1 L4258.2 L4259.2 L4264.2 R20825.2 R20827.2 R20833.2 R20834.2 R20836.2 R20840.2 R20841.1 R67382.2 U13025.1(VCC#1) U13025.6(VCC#2) U13025.20(VCC#3) U13025.28(VCC#4)
+3V_U3_R: C95508.1 C95509.1 C95510.1 C95895.1 C95896.1 L4250.2 R21686.1 R21687.1 R21689.1 R21690.1 R21691.1 R21692.1 R21693.1 R21694.1 R21695.2 R22048.2 U13124.9(VDD#1) U13124.25(VDD#2)
+3V_UIF: C96256.2 C96257.1 Q7916.2(G) Q7916.5(G) Q7948.2(G) R67024.2 R67027.2 R67028.2 R67303.1 R67369.2 R67386.1 R67389.2 U13152.27(VCC)
+3VA: C95977.1 C95979.1 C95980.2 C95981.1 L4271.2 Q7915.2(G) Q7915.5(G) R67012.1 R67016.2 R67017.2 R67328.1 U13150.12(VDD_1) U13150.14(VDD) U13151.1(VDD) U13161.5(VOUT)
+3VPCU: C96252.2 L4264.1 PC124.1 PC126.1 PC5600.1 PC5608.1 PC5623.1 PC5634.1 PC5639.1 PC5653.1 PC5667.1 PC9377.1 PC9382.1 PL3.2 PQ9087.1(S) PQ9088.1(S) PR9.2 PR15.2 PR18.2 PR172.1 PR173.1 PR183.2 PR204.2 PR287.1 PR9003.1 PR66832.1 PR66838.2 PR66884.2 PR66931.1 PR66932.1 PR66968.1 PR67004.1 PR67235.1 PR67240.1 PU38.20(VCC) PU39.20(VCC) PU43.12(VCC) PU44.20(VCC) PU45.20(VCC) PU46.20(VCC) PU9010.9(VIN#1) PU9010.10(VIN#2) R20895.2 R20896.2 R20898.1 R20962.1 R20963.2 R20966.1 R20968.2 R22155.2 R22156.2 R67024.1 R67042.2 R67175.2 R67246.1 R67249.1 R67263.2 R67273.1 R67285.1 RP1.5(R10) RP1.10(R1) U13159.1(VIN1#1) U13159.2(VIN1#2)
+3VPCU_EC: C94634.1 C94635.1 C94636.1 C94637.1 C94638.1 C94639.1 C94640.1 L13.1 L4238.2 R20901.2 U49.26(VSTBY#1) U49.50(VSTBY#2) U49.92(VSTBY#3) U49.114(VSTBY#4) U49.121(VSTBY#5)
+3VPCU_ECPLL: C94642.1 L4238.1 U49.127(VSTBY(PLL))
+5V: C94921.2 C94938.2 C94939.2 C94964.2 C94965.2 C96227.1 C96228.2 C96229.1 C96230.2 CN2074.1 D8598.1 L4240.1 L4241.1 PR126.1 PR127.2 Q7833.3(VIN) Q7845.3(D) R229.1 R230.2 R21056.1 R21066.1 R21439.2 R22139.2 R22141.1 R22143.2 R67311.1 R67359.1 U13157.41(PVDD_L) U13157.42(AVDD1#2) U13157.43(AVDD1#1) U13157.44(PVDD_R) U13161.1(VIN)
+5V_FAN1: CN2045.1 R230.1
+5V_FAN2: CN2046.1 R22139.1
+5V_GPU_LED: CN2077.1 R22143.1
+5V_HDD: C669.2 C670.1 C675.1 C680.1 C689.1 C96242.2 CN11.15 CN11.16 CN11.17 CN11.18 R67359.2
+5V_HDMIC: C94764.1 CN2044.18(+5V) D8559.3(COMMON ANODE) ESD7.1(LINE-1) ESD7.10(NC#4) Q7833.1(VOUT)
+5V_KB_LED: C94784.2 CN2075.13 CN2075.14 R21056.2
+5V_KB_M: C96207.1 C96261.1 C96268.2 CN2049.1 R67302.2 R67402.1
+5V_PVDD: C94934.2 C94940.2 C94945.2 C94946.2 L4240.2 Q7845.1(S) U13108.41(PVDD1) U13108.46(PVDD2)
+5V_S5: C95496.1 C95522.1 C96267.2 PC9082.1 PR128.1 PR2024.1 PR2030.2 PR9013.1 PR9014.1 PR9015.1 PR9016.1 PR9053.1 PR9061.1 PR9070.1 PR9132.1 PR9209.1 PR9215.1 PR9237.1 PR9241.2 PR9256.1 PR66987.1 PR66988.1 PR66989.1 PR66997.1 PR66999.1 PR67001.1 PR67176.1 PU9005.1(VCC) Q7924.3(VIN) R21165.1 R67251.1 U13121.5(IN) U13125.5(IN) U13158.1(VIN1#1) U13158.2(VIN1#2)
+5V_TOBII: C96022.1 C96023.2 C96024.2 CN2079.2 Q7924.1(VOUT)
+5V_TP_PLASTIC: CN2078.2 R67311.2
+5V_TP_RGB: C94791.1 CN2076.11 CN2076.12 R21066.2
+5V_UIF: C96258.2 C96259.1 LED1.4 LED2.4 R67391.2 R67392.2
+5VA: C94927.2 C94928.2 C94962.2 C94963.2 L4241.2 R22091.1 U13108.40(AVDD1)
+5VPCU: C94776.2 C95534.1 C96253.2 CN2071.1 PC104.1 PC125.1 PC127.1 PC223.1 PL2.2 PR130.1 PR136.2 PR175.2 PR9223.2 PR67005.1 PR67006.1 PU5.6(VIN2#1) PU5.7(VIN2#2) PU9015.7(VCC) R21707.1 R21708.1 R22090.1 R67268.2 R67269.1 R67392.1 R67393.2 R67401.2 U13128.1(IN) U13159.6(VIN2#1) U13159.7(VIN2#2)
+5VPD: C96014.1 C96015.1 C96026.1 C96027.1 R67137.2 R67251.2 U13155.A11(PP_5V0#1) U13155.B11(PP_5V0#2) U13155.C11(PP_5V0#3) U13155.D11(PP_5V0#4)
+12V_PANEL: C94701.1 C94702.2 C96280.1 C96281.2 CN2042.39 CN2042.40 PJ9020.1 PJ9027.1 PR67172.1
+A3VPCU: C94641.1 L13.2 U49.74(AVCC)
+VCC3P3_LC: C94601.2 R454.1 R20845.1 R20846.1 R20847.1 U21.R6(VCC3P3_LC)
+VCC3P3_S0: C95892.2 C95893.1 C95894.1 L4266.1 R67053.2 R67055.2 R67056.2 R67151.1 R67152.1 U21.R13(VCC3P3_S0)
+VCC3P3_SX: C94600.2 Q7886.2(G) R20693.2 R20859.1 R20860.1 R20861.1 R20862.2 R22031.1 R22032.1 R22035.2 R67042.1 R67049.2 R67051.2 R67153.1 R67158.2 R67193.2 U21.F8(VCC3P3_SX)
+VCC_CORE: C767.1 C94384.1 C94385.1 C94386.1 C94387.1 C94388.1 C94389.1 C94390.1 C94391.1 C94392.1 C94393.1 C94394.1 C94395.1 C94396.1 C94397.1 C94398.1 C94399.1 C94400.1 C94401.1 C94402.1 C94403.1 C94404.1 C94405.1 C94406.1 C94407.1 C94408.1 C94409.1 C94410.1 C94411.1 C94412.1 C94413.1 C94414.1 C94415.1 C94416.1 C94417.1 C94418.1 C94423.1 C94424.1 C94425.1 C94426.1 C94432.1 C94433.1 C94434.1 C94435.1 C94436.1 C94437.1 C94438.1 C94439.1 C94440.1 C94441.1 C94442.1 C94443.1 C94444.1 C94445.1 C94446.1 C94447.1 C94448.1 C94449.1 C94450.1 C94451.1 C94452.1 C94453.1 C94454.1 C94455.1 C94456.1 C94457.1 C94458.1 C94459.1 C94460.1 C94461.1 C94462.1 C94463.1 C94464.1 C94465.1 C94466.1 C94467.1 C94468.1 C94469.1 C94470.1 C94471.1 C94472.1 C94473.1 C94474.1 C94475.1 C94476.1 C94477.1 C94478.1 C94479.1 C94480.1 C94481.1 C94482.1 C94483.1 C94484.1 C94485.1 C94486.1 C94487.1 C94488.1 C94489.1 C94490.1 C94491.1 C94492.1 C94493.1 C94494.1 PC47.1 PC50.1 PC9354.1 PC9384.1 PC9385.1 PC9386.1 PC9387.1 PC9388.1 PC9389.1 PC9390.1 PC9391.1 PC9491.1 PL9020.2 PL9021.2 PL9022.2 PR66868.2 R20812.1 U41.AA13(VCC#AA13) U41.AA31(VCC#AA31) U41.AA32(VCC#AA32) U41.AA33(VCC#AA33) U41.AA34(VCC#AA34) U41.AA35(VCC#AA35) U41.AA36(VCC#AA36) U41.AA37(VCC#AA37) U41.AA38(VCC#AA38) U41.AB29(VCC#AB29) U41.AB30(VCC#AB30) U41.AB31(VCC#AB31) U41.AB32(VCC#AB32) U41.AB35(VCC#AB35) U41.AB36(VCC#AB36) U41.AB37(VCC#AB37) U41.AB38(VCC#AB38) U41.AC13(VCC#AC13) U41.AC14(VCC#AC14) U41.AC29(VCC#AC29) U41.AC30(VCC#AC30) U41.AC31(VCC#AC31) U41.AC32(VCC#AC32) U41.AC33(VCC#AC33) U41.AC34(VCC#AC34) U41.AC35(VCC#AC35) U41.AC36(VCC#AC36) U41.AD13(VCC#AD13) U41.AD14(VCC#AD14) U41.AD31(VCC#AD31) U41.AD32(VCC#AD32) U41.AD33(VCC#AD33) U41.AD34(VCC#AD34) U41.AD35(VCC#AD35) U41.AD36(VCC#AD36) U41.AD37(VCC#AD37) U41.AD38(VCC#AD38) U41.AE13(VCC#AE13) U41.AE14(VCC#AE14) U41.AE30(VCC#AE30) U41.AE31(VCC#AE31) U41.AE32(VCC#AE32) U41.AE35(VCC#AE35) U41.AE36(VCC#AE36) U41.AE37(VCC#AE37) U41.AE38(VCC#AE38) U41.AF35(VCC#AF35) U41.AF36(VCC#AF36) U41.AF37(VCC#AF37) U41.AF38(VCC#AF38) U41.K13(VCC#K13) U41.K14(VCC#K14) U41.L13(VCC#L13) U41.L14(VCC#L14) U41.N13(VCC#N13) U41.N14(VCC#N14) U41.N30(VCC#N30) U41.N31(VCC#N31) U41.N32(VCC#N32) U41.N35(VCC#N35) U41.N36(VCC#N36) U41.N37(VCC#N37) U41.N38(VCC#N38) U41.P13(VCC#P13) U41.P14(VCC#P14) U41.P29(VCC#P29) U41.P30(VCC#P30) U41.P31(VCC#P31) U41.P32(VCC#P32) U41.P33(VCC#P33) U41.P34(VCC#P34) U41.P35(VCC#P35) U41.P36(VCC#P36) U41.R13(VCC#R13) U41.R31(VCC#R31) U41.R32(VCC#R32) U41.R33(VCC#R33) U41.R34(VCC#R34) U41.R35(VCC#R35) U41.R36(VCC#R36) U41.R37(VCC#R37) U41.R38(VCC#R38) U41.T29(VCC#T29) U41.T30(VCC#T30) U41.T31(VCC#T31) U41.T32(VCC#T32) U41.T35(VCC#T35) U41.T36(VCC#T36) U41.T37(VCC#T37) U41.T38(VCC#T38) U41.U29(VCC#U29) U41.U30(VCC#U30) U41.U31(VCC#U31) U41.U32(VCC#U32) U41.U33(VCC#U33) U41.U34(VCC#U34) U41.U35(VCC#U35) U41.U36(VCC#U36) U41.V13(VCC#V13) U41.V14(VCC#V14) U41.V31(VCC#V31) U41.V32(VCC#V32) U41.V33(VCC#V33) U41.V34(VCC#V34) U41.V35(VCC#V35) U41.V36(VCC#V36) U41.V37(VCC#V37) U41.V38(VCC#V38) U41.W13(VCC#W13) U41.W14(VCC#W14) U41.W29(VCC#W29) U41.W30(VCC#W30) U41.W31(VCC#W31) U41.W32(VCC#W32) U41.W35(VCC#W35) U41.W36(VCC#W36) U41.W37(VCC#W37) U41.W38(VCC#W38) U41.Y29(VCC#Y29) U41.Y30(VCC#Y30) U41.Y31(VCC#Y31) U41.Y32(VCC#Y32) U41.Y33(VCC#Y33) U41.Y34(VCC#Y34) U41.Y35(VCC#Y35) U41.Y36(VCC#Y36)
+VCC_GT: C194.1 C202.1 C94279.1 C94280.1 C94281.1 C94282.1 C94283.1 C94284.1 C94285.1 C94286.1 C94287.1 C94288.1 C94289.1 C94290.1 C94291.1 C94292.1 C94293.1 C94294.1 C94295.1 C94296.1 C94297.1 C94298.1 C94299.1 C94300.1 C94301.1 C94302.1 C94303.1 C94304.1 C94305.1 C94306.1 C94307.1 C94308.1 C94309.1 C94310.1 C94311.1 C94317.1 C94318.1 C94319.1 C94320.1 C94321.1 C94322.1 C94323.1 C94324.1 C94325.1 C94326.1 PC9411.1 PC9412.1 PC9413.1 PC9414.1 PC9421.1 PC9422.1 PC9423.1 PL8002.2 PL9019.2 PR66882.2 R20761.1 U41.AJ29(VCCGT#AJ29) U41.AJ30(VCCGT#AJ30) U41.AJ31(VCCGT#AJ31) U41.AJ32(VCCGT#AJ32) U41.AJ33(VCCGT#AJ33) U41.AJ34(VCCGT#AJ34) U41.AJ35(VCCGT#AJ35) U41.AJ36(VCCGT#AJ36) U41.AK31(VCCGT#AK31) U41.AK32(VCCGT#AK32) U41.AK33(VCCGT#AK33) U41.AK34(VCCGT#AK34) U41.AK35(VCCGT#AK35) U41.AK36(VCCGT#AK36) U41.AK37(VCCGT#AK37) U41.AK38(VCCGT#AK38) U41.AL13(VCCGT#AL13) U41.AL29(VCCGT#AL29) U41.AL30(VCCGT#AL30) U41.AL31(VCCGT#AL31) U41.AL32(VCCGT#AL32) U41.AL35(VCCGT#AL35) U41.AL36(VCCGT#AL36) U41.AL37(VCCGT#AL37) U41.AL38(VCCGT#AL38) U41.AM13(VCCGT#AM13) U41.AM14(VCCGT#AM14) U41.AM29(VCCGT#AM29) U41.AM30(VCCGT#AM30) U41.AM31(VCCGT#AM31) U41.AM32(VCCGT#AM32) U41.AM33(VCCGT#AM33) U41.AM34(VCCGT#AM34) U41.AM35(VCCGT#AM35) U41.AM36(VCCGT#AM36) U41.AN13(VCCGT#AN13) U41.AN14(VCCGT#AN14) U41.AN31(VCCGT#AN31) U41.AN32(VCCGT#AN32) U41.AN33(VCCGT#AN33) U41.AN34(VCCGT#AN34) U41.AN35(VCCGT#AN35) U41.AN36(VCCGT#AN36) U41.AN37(VCCGT#AN37) U41.AN38(VCCGT#AN38) U41.AP13(VCCGT#AP13) U41.AP14(VCCGT#AP14) U41.AP29(VCCGT#AP29) U41.AP30(VCCGT#AP30) U41.AP31(VCCGT#AP31) U41.AP32(VCCGT#AP32) U41.AP35(VCCGT#AP35) U41.AP36(VCCGT#AP36) U41.AP37(VCCGT#AP37) U41.AP38(VCCGT#AP38) U41.AR29(VCCGT#AR29) U41.AR30(VCCGT#AR30) U41.AR31(VCCGT#AR31) U41.AR32(VCCGT#AR32) U41.AR33(VCCGT#AR33) U41.AR34(VCCGT#AR34) U41.AR35(VCCGT#AR35) U41.AR36(VCCGT#AR36) U41.AT14(VCCGT#AT14) U41.AT31(VCCGT#AT31) U41.AT32(VCCGT#AT32) U41.AT33(VCCGT#AT33) U41.AT34(VCCGT#AT34) U41.AT35(VCCGT#AT35) U41.AT36(VCCGT#AT36) U41.AT37(VCCGT#AT37) U41.AT38(VCCGT#AT38) U41.AU14(VCCGT#AU14) U41.AU29(VCCGT#AU29) U41.AU30(VCCGT#AU30) U41.AU31(VCCGT#AU31) U41.AU32(VCCGT#AU32) U41.AU35(VCCGT#AU35) U41.AU36(VCCGT#AU36) U41.AU37(VCCGT#AU37) U41.AU38(VCCGT#AU38) U41.AV29(VCCGT#AV29) U41.AV30(VCCGT#AV30) U41.AV31(VCCGT#AV31) U41.AV32(VCCGT#AV32) U41.AV33(VCCGT#AV33) U41.AV34(VCCGT#AV34) U41.AV35(VCCGT#AV35) U41.AV36(VCCGT#AV36) U41.AW14(VCCGT#AW14) U41.AW31(VCCGT#AW31) U41.AW32(VCCGT#AW32) U41.AW33(VCCGT#AW33) U41.AW34(VCCGT#AW34) U41.AW35(VCCGT#AW35) U41.AW36(VCCGT#AW36) U41.AW37(VCCGT#AW37) U41.AW38(VCCGT#AW38) U41.AY29(VCCGT#AY29) U41.AY30(VCCGT#AY30) U41.AY31(VCCGT#AY31) U41.AY32(VCCGT#AY32) U41.AY35(VCCGT#AY35) U41.AY36(VCCGT#AY36) U41.AY37(VCCGT#AY37) U41.AY38(VCCGT#AY38) U41.BA13(VCCGT#BA13) U41.BA14(VCCGT#BA14) U41.BA29(VCCGT#BA29) U41.BA30(VCCGT#BA30) U41.BA31(VCCGT#BA31) U41.BA32(VCCGT#BA32) U41.BA33(VCCGT#BA33) U41.BA34(VCCGT#BA34) U41.BA35(VCCGT#BA35) U41.BA36(VCCGT#BA36) U41.BB13(VCCGT#BB13) U41.BB14(VCCGT#BB14) U41.BB31(VCCGT#BB31) U41.BB32(VCCGT#BB32) U41.BB33(VCCGT#BB33) U41.BB34(VCCGT#BB34) U41.BB35(VCCGT#BB35) U41.BB36(VCCGT#BB36) U41.BB37(VCCGT#BB37) U41.BB38(VCCGT#BB38) U41.BC29(VCCGT#BC29) U41.BC30(VCCGT#BC30) U41.BC31(VCCGT#BC31) U41.BC32(VCCGT#BC32) U41.BC35(VCCGT#BC35) U41.BC36(VCCGT#BC36) U41.BC37(VCCGT#BC37) U41.BC38(VCCGT#BC38) U41.BD13(VCCGT#BD13) U41.BD14(VCCGT#BD14) U41.BD29(VCCGT#BD29) U41.BD30(VCCGT#BD30) U41.BD31(VCCGT#BD31) U41.BD32(VCCGT#BD32) U41.BD33(VCCGT#BD33) U41.BD34(VCCGT#BD34) U41.BD35(VCCGT#BD35) U41.BD36(VCCGT#BD36) U41.BE31(VCCGT#BE31) U41.BE32(VCCGT#BE32) U41.BE33(VCCGT#BE33) U41.BE34(VCCGT#BE34) U41.BE35(VCCGT#BE35) U41.BE36(VCCGT#BE36) U41.BE37(VCCGT#BE37) U41.BE38(VCCGT#BE38) U41.BF13(VCCGT#BF13) U41.BF14(VCCGT#BF14) U41.BF29(VCCGT#BF29) U41.BF30(VCCGT#BF30) U41.BF31(VCCGT#BF31) U41.BF32(VCCGT#BF32) U41.BF35(VCCGT#BF35) U41.BF36(VCCGT#BF36) U41.BF37(VCCGT#BF37) U41.BF38(VCCGT#BF38) U41.BG29(VCCGT#BG29) U41.BG30(VCCGT#BG30) U41.BG31(VCCGT#BG31) U41.BG32(VCCGT#BG32) U41.BG33(VCCGT#BG33) U41.BG34(VCCGT#BG34) U41.BG35(VCCGT#BG35) U41.BG36(VCCGT#BG36) U41.BH33(VCCGT#BH33) U41.BH34(VCCGT#BH34) U41.BH35(VCCGT#BH35) U41.BH36(VCCGT#BH36) U41.BH37(VCCGT#BH37) U41.BH38(VCCGT#BH38) U41.BJ37(VCCGT#BJ37) U41.BJ38(VCCGT#BJ38) U41.BL36(VCCGT#BL36) U41.BL37(VCCGT#BL37) U41.BM36(VCCGT#BM36) U41.BM37(VCCGT#BM37) U41.BN36(VCCGT#BN36) U41.BN37(VCCGT#BN37) U41.BN38(VCCGT#BN38) U41.BP37(VCCGT#BP37) U41.BP38(VCCGT#BP38) U41.BR37(VCCGT#BR37) U41.BT37(VCCGT#BT37)
+VCC_SA: C94504.1 C94505.1 C94506.1 C94507.1 C94508.1 C94509.1 C94510.1 C94511.1 C94512.1 C94513.1 C94518.1 C94519.1 C95909.1 PC9430.1 PC9431.1 PC9432.1 PC9433.1 PC9435.1 PL6.2 PR66890.2 R20819.2 U41.J30(VCCSA#J30) U41.K29(VCCSA#K29) U41.K30(VCCSA#K30) U41.K31(VCCSA#K31) U41.K32(VCCSA#K32) U41.K33(VCCSA#K33) U41.K34(VCCSA#K34) U41.K35(VCCSA#K35) U41.L31(VCCSA#L31) U41.L32(VCCSA#L32) U41.L35(VCCSA#L35) U41.L36(VCCSA#L36) U41.L37(VCCSA#L37) U41.L38(VCCSA#L38) U41.M29(VCCSA#M29) U41.M30(VCCSA#M30) U41.M31(VCCSA#M31) U41.M32(VCCSA#M32) U41.M33(VCCSA#M33) U41.M34(VCCSA#M34) U41.M35(VCCSA#M35) U41.M36(VCCSA#M36)
+VCCAMPHY_1P0: C94840.1 C94842.1 R21345.2 U13113.U21(VCCMPHY_1P0#8-U21) U13113.U23(VCCMPHY_1P0#8-U23) U13113.U25(VCCMPHY_1P0#8-U25) U13113.U26(VCCMPHY_1P0#8-U26) U13113.V26(VCCMPHY_1P0)
+VCCAMPHYPLL_1P0: C94843.1 C96167.1 R21347.2 U13113.A43(VCCMPHYPLL_1P0#8-A43) U13113.B43(VCCMPHYPLL_1P0)
+VCCAPLLEBB: C96034.1 R21350.2 U13113.V28(VCCAPLLEBB_1P0)
+VCCATS: C94854.2 R21342.1 U13113.AD13(VCCATS)
+VCCCLK1: R21336.2 U13113.N17(VCCCLK1)
+VCCCLK2: R21340.2 U13113.R17(VCCCLK2) U13113.V17(VCCCLK2#8-V17)
+VCCCLK3: R21338.2 U13113.R19(VCCCLK3)
+VCCCLK4: R21339.2 U13113.U20(VCCCLK4)
+VCCCLK5: C94838.1 C96166.1 R21344.2 U13113.K2(VCCCLK5#8-K2) U13113.K3(VCCCLK5)
+VCCDSW3P3: C94830.2 C94848.1 R21355.2 U13113.BA24(VCCDSW_3P3) U13113.W15(VCCDSW_3P3#8-W15)
+VCCDSW_1.0V: C94832.1 R21329.2 U13113.BA29(DCPDSW_1P0)
+VCCHDAPLL_1P0: R21354.2 U13113.AN19(VCCHDAPLL_1P0)
+VCCIO: C94495.1 C94496.1 C94497.1 C94498.1 C94499.1 PQ9056.1(S1) PQ9056.2(S2) PQ9056.3(S3) PR111.1 PR66938.1 R116.1 R145.1 R194.1 R566.2 R20752.1 R20758.2 R20824.1 R21106.2 R21170.1 R67321.1 U41.AG12(VCCIO#AG12) U41.G15(VCCIO#G15) U41.G17(VCCIO#G17) U41.G19(VCCIO#G19) U41.G21(VCCIO#G21) U41.H15(VCCIO#H15) U41.H16(VCCIO#H16) U41.H17(VCCIO#H17) U41.H19(VCCIO#H19) U41.H20(VCCIO#H20) U41.H21(VCCIO#H21) U41.H26(VCCIO#H26) U41.H27(VCCIO#H27) U41.J15(VCCIO#J15) U41.J16(VCCIO#J16) U41.J17(VCCIO#J17) U41.J19(VCCIO#J19) U41.J20(VCCIO#J20) U41.J21(VCCIO#J21) U41.J26(VCCIO#J26) U41.J27(VCCIO#J27)
+VCCPCIE3PLL_1P0: C94844.1 C96168.1 R21349.2 U13113.C44(VCCPCIE3PLL_1P0) U13113.C45(VCCPCIE3PLL_1P0#8-C45)
+VCCPGPPA: R21332.1 U13113.BA31(VCCPGPPA)
+VCCPGPPBCH: C94831.2 R21333.1 U13113.BC42(VCCPGPPBCH#8-BC42) U13113.BD40(VCCPGPPBCH)
+VCCPGPPD: R21351.1 U13113.BA45(VCCPGPPD#8-BA45) U13113.BB45(VCCPGPPD) U13113.BC44(VCCPGPPD#8-BC44) U13113.BC45(VCCPGPPD#8-BC45)
+VCCPGPPEF: C94833.2 R21334.1 U13113.AJ41(VCCPGPPEF#8-AJ41) U13113.AL41(VCCPGPPEF)
+VCCPGPPG: C94834.2 R21335.1 U13113.AD41(VCCPGPPG)
+VCCPLL: C94539.2 R20823.1 U41.H28(VCCPLL#H28) U41.J28(VCCPLL#J28)
+VCCPLL_OC: C94536.2 C94537.2 R20821.1 U41.BH13(VCCPLL_OC#BH13) U41.G11(VCCPLL_OC#G11)
+VCCPRIM_1.0V_AC17: C94845.1 C96035.1 R21352.2 U13113.AC17(VCCPRIM_1P0#8-AC17)
+VCCPRIM_1.0V_AJ20: C94841.2 R21346.1 U13113.AJ20(VCCPRIM_1P0#8-AJ20) U13113.AJ21(VCCPRIM_1P0#8-AJ21) U13113.AJ23(VCCPRIM_1P0) U13113.AJ25(VCCPRIM_1P0#8-AJ25)
+VCCPRIM_1.0V_AJ20_AA23: C94829.1 R21330.2 U13113.AA23(VCCPRIM_1P0#8-AA23) U13113.AA26(VCCPRIM_1P0#8-AA26) U13113.AA28(VCCPRIM_1P0#8-AA28) U13113.AC23(VCCPRIM_1P0#8-AC23) U13113.AC26(VCCPRIM_1P0#8-AC26) U13113.AC28(VCCPRIM_1P0#8-AC28) U13113.AE23(VCCPRIM_1P0#8-AE23) U13113.AE26(VCCPRIM_1P0#8-AE26) U13113.Y23(VCCPRIM_1P0#8-Y23) U13113.Y25(VCCPRIM_1P0#8-Y25)
+VCCPRIM_1.0V_AJ20_AD15: C96036.1 R21341.1 U13113.AD15(VCCPRIM_1P0#8-AD15)
+VCCPRIM_1.0V_AL22: C94828.2 R21331.1 U13113.AL22(VCCPRIM_1P0#8-AL22)
+VCCPRIM_3P3: C94835.2 R21337.1 U13113.AN5(VCCPRIM_3P3#8-AN5)
+VCCRTCPRIM_3.3V: C94852.2 C94853.2 R21343.1 U13113.BA20(VCCRTCPRIM_3P3)
+VCCSPI: R21348.1 U13113.BE41(VCCSPI#8-BE41) U13113.BE42(VCCSPI) U13113.BE43(VCCSPI#8-BE43)
+VCCSTG: C273.2 R20822.1 R20824.2 U41.G30(VCCSTG) U41.H29(VCCSTG#H29)
+VCCUSB2PLL_1P0: C96249.1 R21353.2 U13113.AJ5(VCCUSB2PLL_1P0#8-AJ5) U13113.AL5(VCCUSB2PLL_1P0)
+VDDQ: PC2034.1 PR2023.1 R21407.2 R21434.2
+VDDQC: C94535.1 R151.1 U41.Y12(VDDQC)
+VIN: PC7.1 PC12.1 PC128.1 PC135.1 PC136.1 PC139.1 PC140.1 PC161.1 PC170.1 PC172.1 PC2023.1 PC2024.1 PC2025.1 PC2027.1 PC2028.1 PC5595.1 PC5596.1 PC5598.1 PC5601.1 PC5602.1 PC5603.1 PC9011.1 PC9392.1 PC9393.1 PC9394.1 PC9395.1 PC9396.1 PC9397.1 PC9398.1 PC9399.1 PC9400.1 PC9401.1 PC9402.1 PC9403.1 PC9404.1 PC9405.1 PC9406.1 PC9407.1 PC9409.1 PC9410.1 PC9415.1 PC9416.1 PC9417.1 PC9418.1 PC9419.1 PC9420.1 PC9429.1 PC9496.1 PJ3004.1 PJ9010.1 PJ9024.1 PJ9027.2 PQ2.5(D) PQ21.2(D1) PQ22.2(D1) PQ30.5(D) PQ9057.5(D) PR2.1 PR3.2 PR59.1 PR84.1 PR116.1 PR171.1 PR2021.1 PR9032.2 PR66840.1 PR66972.1 PR67174.1 PR67195.1 PR67230.1 PU38.1(VIN#1) PU38.14(VIN#2) PU39.1(VIN#1) PU39.14(VIN#2) PU44.1(VIN#1) PU44.14(VIN#2) PU45.1(VIN#1) PU45.14(VIN#2) PU46.1(VIN#1) PU46.14(VIN#2) R21438.1
+VIN_FBVDDQ: PC9102.1 PC9103.1 PC9106.1 PC9107.1 PC9194.1 PC9436.1 PC9438.1 PC9440.1 PC9441.1 PC9442.1 PJ9002.2 PQ9013.5(D) PQ9051.5(D) PR9142.1
+VIN_GPU_TOTAL: PC9025.1 PJ9002.1 PJ9024.2 PJ9025.2 PR67196.1 PR67197.1
