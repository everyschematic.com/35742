# Allegro board DAZGLMB1ED0 dazglmb1ed0-d-ver a-165 (.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB_OC5#: length 7.1
  TOP w0.14: U13113.Y41 300.79,72.48 301.06,72.75 301.06,73.04 301.21,73.19 301.21,73.52 301.11,73.63 301.11,73.98 301.16,74.03 301.16,74.95 301.01,75.1 301.01,75.53 299.87,76.67 299.11,76.67 298.6,77.18 R21082.1
USB_OC6#: length 8.3
  TOP w0.102: 300.22,74.79 300.48,74.54 300.48,74.3 300.33,74.03 U13113.W44
  TOP w0.14: v1(296.74,78.99) 297.05,78.68 297.05,78.02 296.87,77.85 R21083.1 297,77.41 297.25,77.41 298.39,76.27 298.39,75.68 298.9,75.18 299.41,75.18 299.51,75.28 299.99,75.28 300.22,75.05 300.22,74.79
USB_OC7#: length 7.1
  TOP w0.102: U13113.W43 300.09,73.53 300.09,74.13 299.83,74.39
  TOP w0.14: 299.83,74.39 299.6,74.39 299.2,74.79 298.94,74.79 296.41,77.31 295.8,77.31 295.68,77.44 R21084.1
USBON#: length 217.7
  TOP w0.14: v1(27.12,85.13) 27.51,85.52 U13125.4 27.51,86.5 v1(26.61,86.5) ; U13121.4 22.76,62.77 v1(22.98,62.55) ; U49.99 191.6,68.38 v1(191.66,68.44)
  IN1 w0.089: v1(22.98,62.55) 22.8,62.74 22.8,68.36 24.45,70.02 24.45,72.36 26.45,74.35 26.45,80.95 27.12,81.63 v1(27.12,85.13)
  IN3 w0.079: v1(191.66,68.44) 191.13,67.91 183.16,67.91 182.44,67.19 179.67,67.19 178.79,66.31 176.26,66.31 175.96,66.01 172.04,66.01 166.21,60.18 166.21,56.15 164.48,54.42 162.19,54.42 160.41,56.2 148.16,56.2 146.46,54.5 141.54,54.5 140.45,55.59 134.74,55.59 133.79,54.64 118.21,54.64 117.48,55.37 103.08,55.37 100.77,53.06 92.74,53.06 88.85,49.17 74.28,49.17 73.54,49.91 69.93,49.91 68.33,51.51 65.94,51.51 64.44,53 64.24,53 62.06,55.18 61.66,55.18 59.97,56.88 57.01,56.88 56.38,57.51 52.14,57.51 51.79,57.15 48.63,57.15 46.98,58.8 41.22,58.8 37.88,62.15 29.6,62.15 28.68,61.23 25.18,61.23 24.37,62.04 23.5,62.04 v1(22.98,62.55)
USBP1+: length 85.4
  TOP w0.14: U13113.AD7 303.1,55.31 302.92,55.31 302.62,55.61 v2(302.53,55.61) ; v1(361.03,51.03) 361.27,51.27 361.41,51.27 361.53,51.15 U13128.3
  IN5 w0.089: v2(302.53,55.61) 302.01,55.61 301.78,55.38 301.78,54.05 305.23,50.6 307.56,50.6 308.41,51.45 314.09,51.45 314.98,50.56 317.38,50.56 317.48,50.47 321.27,50.47 322.31,51.51 322.31,51.74 323.96,53.39 325.45,53.39 327.47,55.41 327.96,55.41 328.13,55.24 329.21,55.24 330.22,56.25 330.22,57.08 331.1,57.96 331.56,57.96 333.08,59.49 334.74,59.49 336.94,61.69 338.51,61.69 339.85,63.02 339.85,64.34 340.14,64.63 341.31,64.63 343.01,62.94 343.01,61.62 343.61,61.01 358.98,61.01 361.09,58.9 361.09,56.52 359.79,55.22 359.79,51.87 360.51,51.15 360.9,51.15 v1(361.03,51.03)
USBP1+_C: length 16.8
  TOP w0.14: v1(366.3,51.03) 366.17,51.15 U13128.10 ; v1(364.26,59.83) 364.43,59.66 364.87,59.66 365.02,59.8 L4255.3 365.92,59.8 R21697.1
  IN5 w0.089: v1(366.3,51.03) 366.05,51.27 365.37,51.27 365.13,51.52 365.13,52.4 364.9,52.63 363.55,52.63 363.02,53.16 363.02,54.84 361.73,56.13 361.73,58.48 362.76,59.51 363.94,59.51 v1(364.26,59.83)
USBP1+_C_R: length 11.4
  TOP w0.14: R21697.2 366.91,59.8 L4255.4 367.88,59.8 368.8,60.72 369.19,60.72 U13127.7 369.37,60.72 372.46,60.72 373.51,59.67 TP64.1 374.91,59.67 376.1,60.86 CN2067.3
USBP1-: length 85.4
  TOP w0.14: v1(361.03,51.78) 361.27,51.53 361.41,51.53 361.53,51.65 U13128.2 ; v2(302.53,55) 302.74,55 303.11,54.63 U13113.AD5
  IN5 w0.089: v2(302.53,55) 302.53,55.19 302.49,55.23 302.4,55.23 302.19,55.44 302.08,55.44 301.95,55.31 301.95,54.12 305.3,50.77 307.49,50.77 308.34,51.62 314.16,51.62 315.05,50.73 317.45,50.73 317.55,50.64 321.2,50.64 322.14,51.58 322.14,51.81 323.89,53.56 325.38,53.56 327.4,55.58 328.03,55.58 328.2,55.41 329.14,55.41 330.05,56.32 330.05,57.15 331.04,58.13 331.49,58.13 333.01,59.66 334.67,59.66 336.87,61.86 338.44,61.86 339.68,63.09 339.68,64.41 340.07,64.8 341.38,64.8 343.17,63.01 343.17,61.69 343.68,61.18 359.05,61.18 361.26,58.97 361.26,56.45 359.96,55.15 359.96,51.94 360.58,51.32 360.75,51.32 361.03,51.6 v1(361.03,51.78)
USBP1-_C: length 16.8
  TOP w0.14: U13128.11 365.56,51.65 365.79,51.42 365.97,51.42 v1(366.3,51.75) ; R21699.1 365.6,58.89 L4255.2 365.09,59 364.7,59.39 364.42,59.39 364.26,59.22 v1(364.26,58.98)
  IN5 w0.089: v1(366.3,51.75) 365.99,51.44 365.44,51.44 365.3,51.59 365.3,52.47 364.97,52.8 363.62,52.8 363.19,53.23 363.19,54.91 361.89,56.2 361.89,58.41 362.83,59.34 363.89,59.34 v1(364.26,58.98)
USBP1-_C_R: length 11.4
  TOP w0.14: CN2067.2 376.11,59.5 376.21,59.6 376.21,59.84 376.09,59.96 375.58,59.96 375.03,59.4 TP67.1 373.4,59.4 372.35,60.46 371.13,60.46 U13127.4 371.03,60.46 368.91,60.46 367.92,59.46 367.92,59.15 367.77,59 L4255.1 366.91,59 R21699.2
USBP2+: length 308.4
  TOP w0.14: v1(22.94,39.32) L4247.3 21.73,39.32 R21673.1 ; U13113.AG10 304.08,56.92 v2(303.78,57.22)
  IN1 w0.089: v1(22.94,39.32) 22.86,39.39 22.2,39.39 21.87,39.71 21.87,41.62 24.97,44.71 26.74,44.71 27.64,45.61 30.58,45.61 31.93,44.26 32.49,44.26 32.92,43.83 35.95,43.83 38.36,46.24 45.86,46.24 46.48,46.85 51.76,46.85 52.8,47.9 57.75,47.9 58.87,46.78 59.68,46.78 59.89,46.98 60.78,46.98 60.98,46.78 60.98,44.41 61.89,43.5 62.94,43.5 63.57,42.86 64.92,42.86 65.71,42.08 66.59,42.08 67.74,43.22 69.54,43.22 70.34,44.02 72.04,44.02 72.87,43.2 73.43,43.2 73.75,43.52 76.37,43.52 77.11,44.26 83.85,44.26 85.29,45.7 85.85,45.7 86.51,46.36 97.4,46.36 99.77,48.73 174.19,48.73 176.49,51.04 177.6,51.04 178.28,51.71 179.46,51.71 179.82,51.35 194.22,51.35 195.98,49.6 229.74,49.6 230.3,49.04 257.39,49.04 257.56,49.2 265.22,49.2 266.27,50.25 268.99,50.25 269.02,50.21 280.3,50.21 283.01,52.92 283.01,53.47 283.23,53.69 284.5,53.69 284.8,53.39 284.8,52.5 285.6,51.7 293.68,51.7 295.54,53.56 302.66,53.56 303.04,53.94 303.04,56.72 303.35,57.03 303.59,57.03 v2(303.78,57.22)
USBP2+_R: length 12.1
  TOP w0.14: CN2064.3 10.89,40 10.76,39.87 10.76,39.39 11.03,39.12 11.23,39.12 11.98,39.87 TP13164.1 14.07,39.87 15.21,38.73 17.68,38.73 17.75,38.79 18.63,38.79 U13122.7 18.77,38.79 19.08,38.79 19.76,39.46 20.11,39.46 L4247.4 20.73,39.32 R21673.2
USBP2-: length 308.3
  TOP w0.14: v1(22.94,40.12) L4247.2 21.73,40.12 R21674.1 ; U13113.AG8 304.08,56.15 v2(303.73,56.51)
  IN1 w0.089: v1(22.94,40.12) 22.94,39.94 22.56,39.56 22.27,39.56 22.04,39.78 22.04,41.55 25.04,44.55 26.81,44.55 27.71,45.44 30.51,45.44 31.86,44.09 32.42,44.09 32.85,43.67 36.02,43.67 38.43,46.07 45.93,46.07 46.55,46.69 51.83,46.69 52.87,47.73 57.68,47.73 58.8,46.61 59.75,46.61 59.96,46.81 60.71,46.81 60.81,46.71 60.81,44.34 61.82,43.33 62.87,43.33 63.5,42.69 64.85,42.69 65.64,41.91 66.66,41.91 67.81,43.05 69.61,43.05 70.41,43.86 71.97,43.86 72.8,43.03 73.5,43.03 73.82,43.35 76.44,43.35 77.18,44.09 83.92,44.09 85.36,45.53 85.92,45.53 86.58,46.19 97.47,46.19 99.84,48.57 174.26,48.57 176.56,50.87 177.67,50.87 178.35,51.55 179.39,51.55 179.75,51.18 194.15,51.18 195.91,49.43 229.67,49.43 230.23,48.87 257.46,48.87 257.63,49.04 265.29,49.04 266.34,50.08 268.92,50.08 268.95,50.05 280.37,50.05 283.18,52.85 283.18,53.4 283.3,53.52 284.43,53.52 284.63,53.32 284.63,52.43 285.53,51.53 293.75,51.53 295.61,53.39 302.73,53.39 303.21,53.87 303.21,56.65 303.42,56.86 303.58,56.86 303.73,56.71 v2(303.73,56.51)
USBP2-_R: length 12.2
  TOP w0.14: CN2064.2 10.9,41.36 12.12,40.14 TP13161.1 14.18,40.14 15.32,38.99 16.78,38.99 U13122.4 17.02,38.99 17.57,38.99 17.64,39.06 18.97,39.06 19.65,39.73 19.84,39.73 20.23,40.12 L4247.1 20.73,40.12 R21674.2
USBP3+: length 302.9
  TOP w0.102: 300.66,50.2 300.68,50.22 300.72,50.22 301.12,50.61 301.95,50.61 302.28,50.94 302.28,51.4 303.17,52.29 303.17,52.87 U13113.AE2
  TOP w0.14: v1(23.92,49.01) 23.92,49.11 23.79,49.24 23.54,49.24 22.89,48.59 22.54,48.59 L4251.3 21.85,48.33 R21680.1 ; v1(298.35,50.16) 298.35,50.13 298.65,49.84 298.89,49.84 298.99,49.74 300.2,49.74 300.66,50.2
  IN5 w0.089: v1(298.35,50.16) 298.04,49.84 297.76,49.84 297.69,49.77 289.65,49.77 288.16,51.26 270.7,51.26 269.54,52.42 265.04,52.42 263.94,51.32 259.53,51.32 257.62,49.41 232.93,49.41 232.54,49.02 231.05,49.02 230.18,49.89 199.51,49.89 199.15,50.25 195.87,50.25 195.08,51.05 188.3,51.05 187.77,51.58 178.07,51.58 177.63,51.15 176.33,51.15 175.05,49.86 95.11,49.86 93.3,48.05 92.17,48.05 90.76,46.64 87.4,46.64 85.33,44.57 74.26,44.57 73.98,44.29 68.57,44.29 67.38,45.48 65.3,45.48 63.32,47.46 62.07,47.46 61.08,48.45 61.08,49.62 60.62,50.08 59.81,50.08 58.95,49.22 53.84,49.22 53.11,49.95 50.49,49.95 49.02,48.48 46.16,48.48 46,48.32 36.59,48.32 34.11,45.84 34.11,45.2 33.06,44.15 26.65,44.15 23.08,47.72 23.08,49.11 23.36,49.38 23.86,49.38 23.92,49.32 v1(23.92,49.01)
USBP3+_R: length 24
  TOP w0.14: R21680.2 20.86,48.33 L4251.4 20.21,48.33 20.06,48.48 19.98,48.48 19.7,48.2 19.7,47.79 19.27,47.37 19.19,47.29 18.76,47.29 U13123.7 18.64,47.29 18.01,47.29 17.94,47.23 15.17,47.23 14.51,47.89 14.51,53.66 13.95,54.22 13.95,59.7 13.74,59.91 TP13176.1 12.16,59.91 10.9,58.65 CN2065.3
USBP3-: length 302.9
  TOP w0.102: 300.85,50.01 300.88,50.04 300.88,50.08 301.18,50.38 302.01,50.38 302.48,50.86 302.48,51.32 303.37,52.21 303.37,52.67 303.46,52.75 U13113.AE1
  TOP w0.14: R21681.1 21.85,49.13 L4251.2 22.55,48.86 22.78,48.86 23.43,49.51 23.57,49.51 v1(23.92,49.86) ; v1(298.33,49.48) 298.42,49.57 298.77,49.57 298.88,49.47 300.31,49.47 300.85,50.01
  IN5 w0.089: v1(23.92,49.86) 23.61,49.55 23.29,49.55 22.92,49.18 22.92,47.65 26.58,43.98 33.12,43.98 34.27,45.13 34.27,45.77 36.66,48.15 46.07,48.15 46.23,48.31 49.09,48.31 50.56,49.79 53.04,49.79 53.77,49.05 59.02,49.05 59.88,49.91 60.55,49.91 60.91,49.55 60.91,48.38 62,47.3 63.25,47.3 65.23,45.32 67.31,45.32 68.51,44.12 74.05,44.12 74.33,44.4 85.4,44.4 87.47,46.47 90.83,46.47 92.24,47.88 93.37,47.88 95.18,49.69 175.11,49.69 176.4,50.98 177.7,50.98 178.14,51.41 187.7,51.41 188.23,50.88 195.01,50.88 195.81,50.08 199.08,50.08 199.44,49.72 230.11,49.72 230.98,48.85 232.61,48.85 233,49.24 257.69,49.24 259.6,51.16 264.01,51.16 265.1,52.25 269.47,52.25 270.63,51.09 288.09,51.09 289.58,49.6 297.76,49.6 297.83,49.67 298.14,49.67 v1(298.33,49.48)
USBP3-_R: length 24
  TOP w0.14: CN2065.2 10.8,60 10.66,59.86 10.66,59.73 10.87,59.53 11.39,59.53 12.03,60.18 TP13173.1 13.85,60.18 14.22,59.81 14.22,54.33 14.78,53.77 14.78,48 15.28,47.49 16.77,47.49 U13123.4 17.03,47.49 17.83,47.49 17.9,47.56 19.08,47.56 19.43,47.91 19.43,48.31 19.88,48.76 19.91,48.76 20.28,49.13 L4251.1 20.86,49.13 R21681.2
USBP4+: length 317.1
  TOP w0.102: 301.74,51.94 301.75,51.95 301.79,51.95 301.92,52.09 301.92,52.82 302.13,53.02 302.13,53.34 302.13,53.43 302.41,53.72 U13113.AC3
  TOP w0.14: R21698.1 28.9,74.39 L4254.3 29.08,74.57 v1(29.81,74.57) ; 301.74,51.94 300.56,50.77 299.99,50.77 v1(299.82,50.94)
  IN1 w0.089: v1(48.66,55.08) 48.39,55.08 48.19,55.28 48.19,57.38 47.09,58.49 45.04,58.49 44.25,59.27 40.86,59.27 32.93,67.21 32.93,68.51 28.8,72.64 28.8,74.57 29.16,74.93 29.53,74.93 29.81,74.65 v1(29.81,74.57)
  IN4 w0.089: v1(48.66,55.08) 48.56,55.08 48.33,54.86 48.33,54.7 51.72,51.31 53.89,51.31 55.92,49.28 57.34,49.28 59.1,47.52 59.1,44.89 59.43,44.56 59.43,41.11 59.2,40.87 59.2,39.82 60.1,38.92 61.99,38.92 63.93,36.98 63.93,33.77 64.53,33.17 67.29,33.17 69.16,35.04 73.7,35.04 78.14,39.49 78.89,39.49 81,41.59 84.07,41.59 84.76,42.28 86.97,42.28 88.57,43.88 91.31,43.88 91.86,44.43 92.51,44.43 92.82,44.74 92.82,44.94 93.3,45.42 97.87,45.42 100.04,47.59 174.44,47.59 175.38,48.53 179.83,48.53 180.26,48.96 182.17,48.96 182.87,48.27 185.52,48.27 185.81,48.55 189.13,48.55 189.28,48.4 195.22,48.4 196.49,49.67 205.86,49.67 206.12,49.93 229.15,49.93 230.21,48.88 256.54,48.88 257.27,48.14 264.15,48.14 265.7,49.7 269.92,49.7 270.13,49.91 287.72,49.91 289.38,48.25 291.55,48.25 293.3,50 296.62,50 297.42,50.81 298.96,50.81 298.99,50.84 299.71,50.84 v1(299.82,50.94)
USBP4+_R: length 10.7
  TOP w0.14: CN2066.3 20.37,77.83 TP13152.1 21.6,77.83 23.14,76.29 v1(23.14,75.55) 23.88,75.55 24.6,74.83 25.24,74.83 D8596.1 26.11,74.83 26.68,74.83 27.01,74.5 L4254.4 27.58,74.5 R21698.2
USBP4-: length 317
  TOP w0.102: U13113.AC2 302.33,53.25 302.33,52.94 302.13,52.74 302.13,52 301.88,51.75 301.88,51.74
  TOP w0.14: v1(299.82,50.28) 300.03,50.5 300.64,50.5 301.88,51.74 ; R21696.1 28.9,75.4 L4254.2 29.06,75.25 v1(29.81,75.25)
  IN1 w0.089: v1(29.81,75.25) 29.66,75.1 29.09,75.1 28.63,74.64 28.63,72.57 32.76,68.44 32.76,67.14 40.79,59.11 44.18,59.11 44.97,58.32 47.02,58.32 48.03,57.31 48.03,55.21 v1(47.87,55.06)
  IN4 w0.089: v1(47.87,55.06) 48.16,54.77 48.16,54.63 51.65,51.15 53.82,51.15 55.85,49.11 57.27,49.11 58.93,47.45 58.93,44.82 59.27,44.49 59.27,41.18 59.03,40.94 59.03,39.76 60.03,38.75 61.92,38.75 63.76,36.91 63.76,33.7 64.46,33 67.36,33 69.23,34.88 73.76,34.88 78.21,39.32 78.96,39.32 81.07,41.43 84.14,41.43 84.83,42.11 87.04,42.11 88.64,43.71 91.38,43.71 91.93,44.26 92.58,44.26 92.98,44.67 92.98,44.87 93.37,45.25 97.94,45.25 100.11,47.43 174.51,47.43 175.45,48.36 179.9,48.36 180.33,48.79 182.1,48.79 182.8,48.1 185.59,48.1 185.88,48.39 189.06,48.39 189.21,48.24 195.29,48.24 196.56,49.5 205.93,49.5 206.19,49.76 229.08,49.76 230.14,48.71 256.47,48.71 257.2,47.98 264.22,47.98 265.77,49.53 269.99,49.53 270.2,49.74 287.65,49.74 289.31,48.09 291.62,48.09 293.37,49.84 296.69,49.84 297.49,50.64 299.03,50.64 299.06,50.67 299.43,50.67 v1(299.82,50.28)
USBP4-_R: length 10.7
  TOP w0.14: R21696.2 27.58,75.3 L4254.1 26.96,75.3 26.76,75.09 26.11,75.09 D8597.1 25.24,75.09 24.72,75.09 24.08,75.73 v1(24.08,76.46) 23.35,76.46 21.71,78.1 TP13153.1 20.44,78.1 CN2066.2
USBP5+: length 330.8
  TOP w0.102: v1(303.65,51.61) 303.8,51.77 303.8,53.33 304.15,53.68 U13113.AF3
  TOP w0.14: R67147.1 30.33,76.92 30.18,76.78 30.18,76.47 30.38,76.27 v1(30.47,76.27)
  IN1 w0.089: v1(30.47,76.27) 30.21,76.27 30.14,76.2 30.14,75.89 30.62,75.41 30.62,73.23 37.93,65.91 37.93,63.81 40.74,61 45.65,61 46.81,62.16 52.41,62.16 54.98,64.73 59.39,64.73 59.93,64.19 59.93,63.21 60.83,62.31 60.83,61.43 61.95,60.3 62.97,60.3 64.26,59.01 64.26,56.1 65.53,54.83 65.53,53.24 66.4,52.37 66.4,51.71 67.14,50.97 67.34,50.97 68.84,49.47 73.6,49.47 73.73,49.34 78.06,49.34 78.59,49.87 82.16,49.87 82.65,50.36 94.63,50.36 97.82,53.55 110.81,53.55 112.32,55.06 115.38,55.06 116.05,54.38 118.53,54.38 119.23,53.68 126.55,53.68 127.08,54.21 167.31,54.21 173.58,60.48 181.7,60.48 181.75,60.53 184.43,60.53 184.81,60.16 186.94,60.16 187.42,60.65 191.92,60.65 194.66,63.39 194.66,64.23 195.85,65.42 196.4,65.42 197.88,66.89 203.75,66.89 207.51,63.14 207.51,59.1 212.15,54.46 263.45,54.46 263.81,54.82 276.64,54.82 277.16,55.35 277.16,58.6 278.24,59.67 280.95,59.67 282.27,60.99 282.66,60.99 284.07,62.4 292.79,62.4 293.25,61.93 298.96,61.93 299.44,61.46 299.44,60.6 301.52,58.51 302.9,58.51 302.98,58.43 303.97,58.43 304.25,58.14 304.25,57.94 304.44,57.75 304.44,53.18 303.21,51.95 303.21,51.69 303.39,51.5 303.54,51.5 v1(303.65,51.61)
USBP5+_C: length 10.2
  TOP w0.14: CN2079.4 30.02,85.5 30.39,85.13 30.64,85.13 31.14,84.63 31.14,82.54 30.12,81.53 30.12,80.31 D13065.1 30.58,79.36 30.62,79.32 C96021.1 30.32,78.54 30.32,78 R67147.2
USBP5-: length 330.8
  TOP w0.102: v1(303.17,51.16) 303.21,51.21 303.82,51.21 304.07,51.46 304.07,51.85 304.01,51.91 304.01,53.01 U13113.AF2
  TOP w0.14: R67146.1 29.92,76.61 29.92,76.42 v1(29.76,76.27)
  IN1 w0.089: v1(29.76,76.27) 29.98,76.05 29.98,75.82 30.45,75.34 30.45,73.16 37.76,65.84 37.76,63.74 40.67,60.83 45.72,60.83 46.88,61.99 52.48,61.99 55.05,64.56 59.32,64.56 59.76,64.12 59.76,63.14 60.66,62.24 60.66,61.36 61.89,60.13 62.9,60.13 64.09,58.94 64.09,56.03 65.36,54.76 65.36,53.17 66.23,52.3 66.23,51.64 67.07,50.8 67.27,50.8 68.77,49.3 73.53,49.3 73.66,49.17 78.13,49.17 78.66,49.7 82.23,49.7 82.72,50.19 94.7,50.19 97.89,53.39 110.88,53.39 112.39,54.89 115.31,54.89 115.98,54.21 118.46,54.21 119.16,53.51 126.62,53.51 127.15,54.04 167.38,54.04 173.65,60.32 181.77,60.32 181.82,60.37 184.36,60.37 184.74,60 187.01,60 187.49,60.48 191.99,60.48 194.83,63.32 194.83,64.16 195.92,65.25 196.47,65.25 197.95,66.73 203.68,66.73 207.34,63.07 207.34,59.03 212.08,54.3 263.52,54.3 263.88,54.66 276.71,54.66 277.33,55.28 277.33,58.53 278.31,59.51 281.02,59.51 282.34,60.82 282.73,60.82 284.14,62.23 292.72,62.23 293.19,61.77 298.89,61.77 299.27,61.39 299.27,60.53 301.45,58.35 302.83,58.35 302.92,58.26 303.9,58.26 304.09,58.07 304.09,57.87 304.27,57.68 304.27,53.25 303.04,52.02 303.04,51.62 303.17,51.49 v1(303.17,51.16)
USBP5-_C: length 10.2
  TOP w0.14: R67146.2 29.92,77.7 30.06,77.84 30.06,78.54 29.76,78.83 C96020.1 29.49,79.81 D13064.1 29.85,80.17 29.85,81.64 30.87,82.65 30.87,84.52 30.52,84.87 30.39,84.87 30.02,84.5 CN2079.3
USBP6+: length 281.8
  TOP w0.102: U13113.AB2 301.72,52.99 301.72,52.38 301.54,52.21 301.54,52.18 301.54,52.17
  TOP w0.14: CN2068.3 59.64,73.75 59.51,73.63 58.52,73.63 56.53,71.64 56.53,66.46 55.55,65.48 55.55,57.65 56.95,56.24 56.95,55.76 57.45,55.27 57.45,54.45 v1(57.22,54.22) ; v1(298.17,51.26) 298.32,51.41 300.78,51.41 301.54,52.17
  IN5 w0.089: v1(57.22,54.22) 57.32,54.12 57.32,53.44 56.98,53.1 56.98,52.35 58.35,50.98 60.08,50.98 60.33,50.74 61.49,50.74 65.87,46.36 67.19,46.36 68.04,45.51 72.61,45.51 72.99,45.89 74.69,45.89 75.4,45.18 85.27,45.18 87.13,47.03 90.6,47.03 92,48.44 93.13,48.44 94.95,50.25 174.86,50.25 176.7,52.1 187.92,52.1 188.4,51.61 195.07,51.61 195.6,51.08 198.93,51.08 199.73,50.28 237.21,50.28 237.61,49.88 257.51,49.88 259.92,52.29 264.14,52.29 264.73,52.89 269.85,52.89 271.01,51.73 288.78,51.73 289.8,50.72 293.21,50.72 293.69,50.24 296.73,50.24 297.58,51.09 297.58,51.29 297.74,51.45 297.98,51.45 v1(298.17,51.26)
USBP6-: length 281.7
  TOP w0.102: U13113.AB3 301.59,53.68 301.52,53.6 301.52,52.47 301.39,52.34 301.36,52.34
  TOP w0.14: v1(298.17,51.93) 298.42,51.68 300.71,51.68 301.36,52.34 ; CN2068.5 59.63,73.25 59.52,73.36 58.63,73.36 56.8,71.53 56.8,66.35 55.82,65.36 55.82,57.76 57.22,56.35 57.22,55.87 57.72,55.38 57.72,54.41 v1(57.88,54.25)
  IN5 w0.089: v1(57.88,54.25) 57.49,53.85 57.49,53.37 57.14,53.03 57.14,52.42 58.42,51.15 60.15,51.15 60.4,50.9 61.56,50.9 65.94,46.52 67.26,46.52 68.11,45.68 72.54,45.68 72.92,46.06 74.76,46.06 75.47,45.35 85.21,45.35 87.06,47.2 90.53,47.2 91.93,48.61 93.07,48.61 94.88,50.42 174.79,50.42 176.63,52.26 187.99,52.26 188.47,51.78 195.14,51.78 195.67,51.25 199,51.25 199.8,50.45 237.27,50.45 237.68,50.05 257.44,50.05 259.85,52.46 264.07,52.46 264.67,53.05 269.92,53.05 271.08,51.9 288.85,51.9 289.87,50.89 293.28,50.89 293.76,50.41 296.66,50.41 297.41,51.16 297.41,51.36 297.67,51.62 298.02,51.62 298.17,51.77 v1(298.17,51.93)
USBP7+: length 62
  TOP w0.14: v2(306.06,55.39) 306.14,55.31 306.4,55.31 U13113.AL7
  IN5 w0.089: v1(339.2,67.09) 339.48,67.09 339.65,67.26 339.65,67.32 339.34,67.63 339.06,67.63 338.33,66.91 338.33,66.75 337.94,66.36 337.94,65.83 334.39,62.27 332.1,62.27 330.6,60.78 329.77,60.78 328.92,59.92 327.56,59.92 326.41,58.77 324.25,58.77 323.24,57.75 322.85,57.75 322.19,57.09 320.24,57.09 319.22,58.12 318.14,58.12 316.89,56.86 315.23,56.86 314.64,57.46 307.68,57.46 307.04,56.81 307.04,56.46 306.69,56.12 306.69,55.94 306.5,55.75 306.43,55.75 v2(306.06,55.39)
  BOTTOM w0.14: R22008.1 348.95,77.5 348.95,76.78 348.29,76.12 346.99,76.12 346.71,76.4 346.07,76.4 345.91,76.24 342.36,76.24 341.15,75.03 341.15,74.28 341.6,73.83 341.6,72.99 340.85,72.24 340.85,70.97 v1(340.38,70.5) 340.88,70 340.88,68.77 340.39,68.28 339.84,68.28 339.38,67.82 339.38,67.26 v1(339.2,67.09)
USBP7+_C: length 3.5
  TOP w0.14: D13041.1 348.48,78.63 v1(349.17,79.32) 349.35,79.5 CN2042.21
  BOTTOM w0.14: R22008.2 348.57,78.71 v1(349.17,79.32)
USBP7-: length 62
  TOP w0.14: v2(306.06,56) 306.32,56 U13113.AL8
  IN5 w0.089: v1(340,67.09) 339.82,67.27 339.82,67.39 339.41,67.8 338.99,67.8 338.17,66.98 338.17,66.82 337.77,66.43 337.77,65.9 334.32,62.44 332.03,62.44 330.53,60.94 329.7,60.94 328.85,60.09 327.49,60.09 326.34,58.93 324.18,58.93 323.17,57.92 322.78,57.92 322.12,57.26 320.31,57.26 319.29,58.28 318.07,58.28 316.82,57.03 315.3,57.03 314.71,57.62 307.61,57.62 306.87,56.88 306.87,56.53 306.52,56.18 306.52,56.01 306.43,55.92 306.15,55.92 v2(306.06,56)
  BOTTOM w0.14: v1(340,67.09) 339.67,67.41 339.67,67.73 339.95,68.01 340.5,68.01 341.15,68.66 341.15,70 v1(341.65,70.5) 341.12,71.04 341.12,72.13 341.87,72.88 341.87,73.94 341.42,74.39 341.42,74.92 342.47,75.97 346.02,75.97 346.18,76.13 346.6,76.13 346.88,75.86 348.4,75.86 349.21,76.67 349.21,77.5 R22009.1
USBP7-_C: length 3.5
  TOP w0.14: D13040.1 349.52,79.02 349.67,79.17 349.75,79.17 v1(349.93,79.34) 349.62,79.65 349.62,79.88 349.85,80.11 CN2042.22
  BOTTOM w0.14: R22009.2 349.65,79.14 349.85,79.34 v1(349.93,79.34)
USBP8+: length 77.5
  TOP w0.14: v1(300.73,52.67) 300.73,52.71 300.87,52.85 300.87,53.33 301.02,53.48 301.14,53.48 301.28,53.34 U13113.AA2
  IN5 w0.089: v1(300.73,52.67) 300.6,52.54 300.6,52.37 301.31,51.65 302.03,51.65 303.17,50.51 304.19,50.51 305.01,49.69 311.89,49.69 312.36,50.16 316.88,50.16 317.47,49.57 322.3,49.57 322.96,50.24 323.97,50.24 325.42,51.68 325.42,52.58 326.57,53.73 330.9,53.73 332.25,55.08 332.25,57.73 333.41,58.89 335.95,58.89 337.57,60.51 340.95,60.51 341.28,60.83 341.28,63.59 341.1,63.77 v1(340.83,63.77)
  BOTTOM w0.14: R20953.1 353.52,77.49 353.52,76.51 352.88,75.86 349.53,75.86 348.33,74.67 347.57,74.67 346.1,73.19 344.17,73.19 342.74,71.76 342.74,69.53 v1(342.23,69.03) 342.73,68.53 342.73,67.29 341.05,65.61 341.05,64 341.02,63.96 341.02,63.96 v1(340.83,63.77)
USBP8+_C: length 4
  TOP w0.14: CN2042.27 352.35,80.2 352.45,80.1 352.5,80.1 352.58,80.02 352.58,79.71 v1(352.24,79.37) 352.6,79.01 D8553.1
  BOTTOM w0.14: v1(352.24,79.37) 352.3,79.37 352.58,79.08 352.58,78.74 352.69,78.64 353,78.64 R20953.2
USBP8-: length 77.5
  TOP w0.14: v1(300.27,52.16) 300.83,52.16 301.28,52.61 U13113.AA1
  IN5 w0.089: v1(341.62,63.77) 341.45,63.6 341.45,60.76 341.02,60.34 337.64,60.34 336.02,58.73 333.48,58.73 332.42,57.66 332.42,55.01 330.97,53.56 326.64,53.56 325.59,52.51 325.59,51.61 324.04,50.07 323.03,50.07 322.36,49.4 317.4,49.4 316.81,49.99 312.43,49.99 311.96,49.52 304.94,49.52 304.12,50.34 303.1,50.34 301.96,51.49 301.25,51.49 300.57,52.16 v1(300.27,52.16)
  BOTTOM w0.14: v1(341.62,63.77) 341.32,64.07 341.32,65.5 343,67.18 343,68.52 v1(343.5,69.03) 343,69.53 343,71.65 344.28,72.93 346.21,72.93 347.68,74.4 348.44,74.4 349.64,75.59 352.99,75.59 353.79,76.4 353.79,77.5 R20954.1
USBP8-_C: length 4.1
  TOP w0.14: D8554.1 353.61,78.71 v1(352.95,79.37) 352.85,79.47 CN2042.28
  BOTTOM w0.14: R20954.2 353.57,79.37 v1(352.95,79.37)
USBP9+: length 187.5
  TOP w0.14: U13113.AJ7 305.41,55.49 v2(304.95,55.03)
  IN4 w0.089: v1(177.01,49.11) 176.7,49.42 176.7,49.55 176.74,49.59 180.06,49.59 180.27,49.38 183.24,49.38 183.67,48.95 187.62,48.95 188.15,49.48 189.66,49.48 190.17,48.97 195.17,48.97 196.26,50.06 205.47,50.06 206,50.6 237.39,50.6 238.48,49.51 256.9,49.51 257.46,48.95 264.3,48.95 265.66,50.31 287.88,50.31 289.47,48.72 291.46,48.72 293.76,51.02 293.76,51.44 295.33,53.01 300.51,53.01 300.89,53.39 303.19,53.39 304.38,54.58 304.38,55.07 304.57,55.26 304.72,55.26 v2(304.95,55.03)
  BOTTOM w0.14: R21051.1 129.44,55.23 129.64,55.03 130.63,55.03 132.5,53.16 163.84,53.16 166.54,50.46 171.88,50.46 v1(172.41,50.99) 172.93,50.48 176.36,50.48 176.83,50 176.83,49.29 v1(177.01,49.11)
USBP9+_R: length 9.6
  TOP w0.14: v1(125.41,55.59) 125.38,55.59 124.99,55.98 124.99,56.75 125.65,57.41 126.17,57.41 126.31,57.27 126.31,56.74 126.43,56.62 CN2049.3
  BOTTOM w0.14: R21051.2 128.66,55.3 128.38,55.02 128.05,55.02 D8567.1 127.01,55.03 125.42,55.03 125.23,55.22 125.23,55.41 v1(125.41,55.59)
USBP9-: length 187.5
  TOP w0.14: U13113.AJ8 305.46,56.18 v2(304.92,55.64)
  IN4 w0.089: v2(304.92,55.64) 304.71,55.43 304.51,55.43 304.21,55.13 304.21,54.65 303.12,53.56 300.82,53.56 300.44,53.18 295.26,53.18 293.59,51.51 293.59,51.09 291.39,48.89 289.54,48.89 287.95,50.47 265.59,50.47 264.23,49.11 257.53,49.11 256.97,49.67 238.55,49.67 237.46,50.77 205.93,50.77 205.4,50.23 196.19,50.23 195.1,49.14 190.24,49.14 189.73,49.65 188.08,49.65 187.55,49.11 183.74,49.11 183.31,49.55 180.34,49.55 180.12,49.76 176.67,49.76 176.53,49.62 176.53,49.37 v1(176.28,49.11)
  BOTTOM w0.14: v1(176.28,49.11) 176.56,49.39 176.56,49.89 176.25,50.21 172.9,50.21 v1(172.41,49.72) 171.94,50.19 166.43,50.19 163.73,52.89 132.39,52.89 130.52,54.77 129.51,54.77 129.44,54.7 R21050.1
USBP9-_R: length 9.6
  TOP w0.14: CN2049.2 126.37,57.87 126.17,57.68 125.54,57.68 124.72,56.86 v1(124.72,55.59)
  BOTTOM w0.14: R21050.2 128.66,54.41 128.31,54.75 127.92,54.75 127.53,54.37 D8566.1 127.13,54.77 125.31,54.77 124.96,55.11 124.96,55.35 v1(124.72,55.59)
USBPWR0:
  vias: v1(25.65,82.74) v3(24.63,82.49) v3(24.68,84.07) v3(24.73,83.28)
USBPWR2: length 1.8
  TOP w0.203: v1(372.77,59.02) 371.68,59.02 371.47,58.81 U13127.2
  vias: v1(365.88,53.13) v1(368.93,54.41) v1(369.61,54.41) v1(370.38,54.41)
USBPWR3: length 3.3
  TOP w0.203: v1(16.12,49.04) 16.31,49.23 U13123.2
  TOP w0.254: v1(16.06,40.69) 16.08,40.72 U13122.2
  BOTTOM w0.254: v1(16.12,49.04) 16.2,48.96 C95516.2 ; C95501.2 16.12,40.63 v1(16.06,40.69)
  vias: v1(15.97,45.36) v1(16,44.64) v1(15.97,43.93) v1(16.94,66.03) v1(16.94,65.35) v1(16.94,64.66)
VA: length 258
  TOP w0.508: PC14.1 191.29,171.75 PC13.1
  IN1 w0.508: v1(92.12,84.7) 93.14,85.72 93.85,85.72 95.04,86.91 103.09,86.91 107.54,91.36 107.54,97.78 109.44,99.69 112.19,99.69 114.17,101.67 114.17,120.64 113.41,121.4 113.41,155.16 117.52,159.27 117.52,169 126.21,177.69 126.21,178.15 128.54,180.48 183.66,180.48 190.43,173.71 190.43,172.9 v1(192.3,171.03)
  IN2 w0.508: v1(68.96,50.11) 68.79,49.94 67.83,49.94 66.24,51.53 66.24,52.75 65.64,53.36 64.79,53.36 64.64,53.51 64.63,53.51 60.06,58.08 60.06,63 61.64,64.58 v1(61.65,64.58)
  IN4 w0.508: v1(61.65,64.58) 60.88,64.58 60.07,65.4 60.07,76.42 62.12,78.48 76.25,78.48 77.01,79.24 83.13,79.24 86.25,82.36 89.78,82.36 v1(92.12,84.7)
  BOTTOM w0.381: PR31.1 69.57,51.1 68.98,50.51 68.98,50.13 v1(68.96,50.11)
VA1: length 4.4
  TOP w0.508: v1(207.79,170.73) 207.79,169.36 PQ1.5
  BOTTOM w0.508: PC1.1 v1(207.79,170.73)
  vias: v1(193.09,163.95)
VA2: length 3.8
  BOTTOM w0.508: v1(209.95,166.21) 209.95,166.44 209.06,167.33 PC2.1 208.12,168.28 PR28.1
  vias: v1(210.71,165.62)
VCORE_CS1: length 1.6
  BOTTOM w0.14: PR66841.2 PR66941.1 266.49,157.3 v1(266.57,157.22)
VCORE_CS2: length 0.7
  BOTTOM w0.14: PR66843.2 PR66944.1
VCORE_CS3: length 0.7
  BOTTOM w0.14: PR66844.2 PR66948.1
VCORE_CSUMA: length 16.1
  TOP w0.14: PR66877.1 272.21,162.83 272.44,162.6 273.12,162.6 v1(273.29,162.43) 273.63,162.09 273.63,159.22 271.19,156.79 270.63,156.79 270.25,156.4 269.44,156.4 269.06,156.79 267.38,156.79 266.26,157.9 PR66855.2 PR66857.1 265.25,157.95 PR66858.2
VCORE_PWM1: length 0.5
  TOP w0.14: PR66939.1 PR66825.2
VCORE_PWM2: length 0.5
  TOP w0.14: PR66942.1 PR66826.2
VCORE_PWM3: length 0.5
  TOP w0.14: PR66945.1 PR66827.2
VGA_XTALIN: length 9.6
  TOP w0.102: 147.45,113.11 147.39,113.17 147.39,113.56 146.76,114.19 U13114.BL6
  TOP w0.14: 147.45,113.11 147.51,113.06 147.51,108 C95159.1 147.48,107.56 147.24,107.56 147.03,107.35 147.03,106.44 147.15,106.32 147.82,106.32 Y1004.1
VGA_XTALOUT: length 9.6
  TOP w0.102: 146.91,112.97 146.91,113.36 U13114.BM6
  TOP w0.14: Y1004.3 146.71,105.81 C95160.1 146.96,107.79 147.19,108.02 147.19,112.69 146.91,112.97
VGPU_CORE_SENSE: length 46.8
  TOP w0.203: U13114.BK45 174.41,114.56 174.41,113.86 U13114.BM45 174.7,112.87 175.81,112.87 177.21,111.47 177.21,107.08 175.69,105.55 173.65,105.55 172.54,104.44 172.54,102.66 170.33,100.45 154.2,100.45 153.49,99.74 151.05,99.74 150.74,100.04 v1(147.01,100.04) 145.59,100.04 145.1,100.52 PR9009.2
VGT_VCCSENSE: length 69.2
  TOP w0.14: U41.AH38 245.18,131.78 v1(245.56,132.16) ; v1(270.27,158.69) PR66883.2
  IN1 w0.089: v1(245.56,132.16) 245.99,132.59 263.88,132.59 267.9,136.61 269.86,136.61 273.55,140.29 273.55,143.24 274.61,144.3 274.61,156.09 273.23,157.47 271.34,157.47 271.05,157.77 268.28,157.77 268.19,157.86 268.19,158.09 268.28,158.18 270.45,158.18 270.53,158.26 270.53,158.43 v1(270.27,158.69)
  BOTTOM w0.14: PR66882.1 R20761.2 250.56,138.24 245.56,133.24 v1(245.56,132.16)
VGT_VSSSENSE: length 70.2
  TOP w0.14: v1(270.94,158.72) 270.79,158.86 270.79,159.67 PR66886.2 ; U41.AH37 244.86,130.06 v1(244.79,130.06)
  IN1 w0.089: v1(270.94,158.72) 270.94,158.2 271.48,157.65 273.3,157.65 274.78,156.16 274.78,144.23 273.72,143.16 273.72,140.22 269.64,136.14 268.09,136.14 264.08,132.12 246.48,132.12 245.64,131.28 245.64,130.9 v1(244.79,130.06)
  BOTTOM w0.14: v1(244.79,130.06) 244.9,130.06 245.26,130.41 245.26,131.66 245.03,131.89 245.03,133.44 250.49,138.9 PR66888.1 R549.1
VL:
  vias: v1(83.33,77.16)
VMA_CLK0: length 32.6
  TOP w0.121: v4(173.71,130.7) 173.77,130.7 174.06,130.99 U13114.AG45
  TOP w0.14: v4(199.59,136.95) U13135.K11
  IN1 w0.127: v4(197.52,132.91) 197.75,132.68 197.75,132.34 197.45,132.05 191.61,132.05 190.22,130.66 178.09,130.66 177.46,131.28 174.21,131.28 173.99,131.06 173.99,130.98 173.71,130.7 v4(173.71,130.7)
  IN5 w0.127: v4(199.59,136.95) 199.73,136.82 199.73,136.62 199.6,136.5 199.6,134.1 199.28,133.77 198.11,133.77 197.73,133.39 197.73,133.15 197.52,132.94 v4(197.52,132.91)
VMA_CLK0#: length 32.6
  TOP w0.121: U13114.AG46 174.76,130.99 174.47,130.7 v4(174.41,130.7)
  TOP w0.14: v4(200.24,136.95) U13135.K10
  IN1 w0.127: v4(198.22,132.91) 197.98,132.67 197.98,132.25 197.54,131.82 191.71,131.82 190.32,130.43 178,130.43 177.37,131.06 174.31,131.06 174.24,130.99 174.24,130.87 v4(174.41,130.7)
  IN5 w0.127: v4(200.24,136.95) 199.95,136.66 199.95,136.53 199.83,136.4 199.83,134 199.37,133.54 198.21,133.54 197.96,133.3 197.96,133.19 198.22,132.94 v4(198.22,132.91)
VMA_CLK1: length 32.6
  TOP w0.14: U13114.AK46 174.44,128.6 v4(174.41,128.6) ; v4(199.59,121.8) U13136.K11
  IN1 w0.127: v4(197.81,125.75) 197.53,125.47 197.53,125.21 197.61,125.14 198.44,125.14 198.97,124.61 198.97,122.23 199.32,121.88 199.52,121.88 v4(199.59,121.8)
  IN5 w0.127: v4(174.41,128.6) 174.23,128.6 174.11,128.72 174.11,128.88 174.25,129.02 177.65,129.02 177.7,128.97 182.48,128.97 185.27,126.18 197.98,126.18 198.06,126.1 198.06,125.99 197.99,125.92 v4(197.81,125.75)
VMA_CLK1#: length 32.7
  TOP w0.14: v4(173.71,128.6) 173.74,128.6 U13114.AK45 ; v4(200.24,121.8) U13136.K10
  IN1 w0.081: v4(200.24,121.8) 199.92,122.13 199.39,122.13
  IN1 w0.127: v4(198.47,125.75) 198.47,125.44 199.2,124.71 199.2,122.32 199.39,122.13
  IN5 w0.127: v4(198.47,125.75) 198.28,125.93 198.28,126.2 198.08,126.41 185.36,126.41 182.57,129.2 177.79,129.2 177.74,129.25 174.16,129.25 173.88,128.97 173.88,128.77 v4(173.71,128.6)
VMA_DQ0: length 19.7
  TOP w0.102: 179.45,138.32 178.79,138.32 178.48,138.01 U13114.U51
  TOP w0.17: 179.45,138.32 179.65,138.32 180.36,137.61 181.25,137.61 181.54,137.31 v4(181.54,137.02)
  TOP w0.216: v4(194.39,141.5) U13135.V4
  IN1 w0.14: v4(181.54,137.02) 181.59,137.02 181.96,137.38 183.1,137.38 183.46,137.02 186.66,137.02 191.08,141.44 193.34,141.44 193.51,141.27 194.16,141.27 v4(194.39,141.5)
VMA_DQ1: length 21.8
  TOP w0.102: U13135.V3 194.72,141.94 194.51,142.16 193.36,142.16 v4(193.14,142.37)
  TOP w0.216: v4(176.51,138.33) 176.19,138.01 U13114.U48
  IN1 w0.14: v4(176.51,138.33) 176.51,138.06 177.03,137.53 181.33,137.53 181.72,137.93 183.34,137.93 183.69,137.58 186.35,137.58 190.88,142.11 192.88,142.11 v4(193.14,142.37)
VMA_DQ2: length 21.2
  TOP w0.102: 179.47,138.65 178.73,138.65 178.45,138.37 178.07,138.37 177.72,138.01 U13114.U50
  TOP w0.17: v4(182.69,137.02) 182.69,137.11 181.56,138.24 180.49,138.24 180.08,138.65 179.47,138.65 ; v4(195.04,140.85) U13135.U4
  IN1 w0.081: v4(195.04,140.85) 194.72,140.53 193.52,140.53
  IN1 w0.14: v4(182.69,137.02) 183.24,136.47 187.01,136.47 191.33,140.78 193.26,140.78 193.52,140.53
VMA_DQ3: length 22.3
  TOP w0.17: U13135.U3 195.37,141.83 v4(195.69,141.5)
  TOP w0.216: v4(177.21,138.33) 176.89,138.01 U13114.U49
  IN1 w0.081: 194.84,141.83 U13135.U3 v4(195.69,141.5)
  IN1 w0.14: 194.84,141.83 194.55,142.11 193.92,142.11 193.16,142.87 190.86,142.87 186.18,138.19 183.87,138.19 183.58,138.48 181.48,138.48 181.1,138.09 177.44,138.09 v4(177.21,138.33)
VMA_DQ4: length 25.6
  TOP w0.17: v4(197.64,140.85) 197.32,141.18 U13135.P4
  TOP w0.216: v4(178.61,139.1) 178.29,139.41 U13114.R51
  IN1 w0.081: 197.32,143.79 U13135.P4 v4(197.64,140.85)
  IN1 w0.14: v4(178.61,139.1) 179.03,139.52 180.57,139.52 180.62,139.57 184.09,139.57 184.35,139.31 185.72,139.31 191.09,144.68 196.43,144.68 197.32,143.79
VMA_DQ5: length 24.8
  TOP w0.17: v4(196.99,141.5) U13135.P3
  TOP w0.216: U13114.R50 177.61,139.41 v4(177.91,139.11)
  IN1 w0.081: 196.67,143.65 196.67,141.83 v4(196.99,141.5)
  IN1 w0.14: v4(177.91,139.11) 178.35,138.67 180.89,138.67 181.24,139.02 183.82,139.02 184.09,138.75 185.95,138.75 190.77,143.58 192.59,143.58 193.03,144.02 196.29,144.02 196.52,143.79 196.67,143.65
VMA_DQ6: length 31.6
  TOP w0.17: v4(198.29,141.5) U13135.N4
  TOP w0.216: U13114.R47 175.46,139.4 v4(175.01,138.94)
  IN1 w0.14: v4(198.29,141.5) 198.66,141.87 198.66,142.94 198.89,143.17 198.89,143.79 196.9,145.79 190.11,145.79 184.86,140.53 180.67,140.53 180.16,140.02 175.38,140.02 175.01,139.65 v4(175.01,138.94)
VMA_DQ7: length 29.9
  TOP w0.17: v4(197.64,142.15) U13135.N3
  TOP w0.216: U13114.U46 174.79,138.01 v4(175.11,138.33)
  IN1 w0.081: 198.06,143.78 198.06,143.25 197.97,143.15 197.97,142.48 v4(197.64,142.15)
  IN1 w0.14: 198.06,143.78 198.06,143.83 196.67,145.23 190.82,145.23 185.47,139.87 184.58,139.87 184.32,140.12 180.74,140.12 180.39,139.77 175.74,139.77 175.43,139.46 175.43,138.65 v4(175.11,138.33)
VMA_DQ8: length 23.9
  TOP w0.102: v4(193.2,136.96) 193.2,136.64 193.53,136.3 194.39,136.3 U13135.V11
  TOP w0.216: v4(174.41,137) 174.72,137.31 U13114.V46
  IN5 w0.14: v4(174.41,137) 174.79,137.38 178.1,137.38 178.28,137.2 178.28,136.38 179.14,135.53 189.43,135.53 191.47,137.56 192.59,137.56 v4(193.2,136.96)
VMA_DQ9: length 25
  TOP w0.102: U13135.V12 194.39,135.65 193.79,135.65 193.53,135.4
  TOP w0.216: 193.53,135.4 193.22,135.08 v4(193.09,135.08) ; U13114.Y45 174.03,135.91 v4(173.71,136.23)
  IN5 w0.14: v4(173.71,136.23) 174.09,135.86 174.09,133.87 174.21,133.75 177.69,133.75 177.92,133.52 184.88,133.52 185.19,133.21 191.22,133.21 v4(193.09,135.08)
VMA_DQ10: length 22.6
  TOP w0.216: U13135.U11 v4(195.04,136.3) ; U13114.Y47 175.46,135.94 v4(175.14,136.26)
  IN5 w0.14: v4(195.04,136.3) 195.01,136.27 192.87,136.27 192.7,136.11 191.88,136.11 190.18,134.41 178.86,134.41 177.69,135.57 175.53,135.57 175.14,135.97 v4(175.14,136.26)
VMA_DQ11: length 24.1
  TOP w0.102: U13135.U12 195.04,135.65 v4(195.04,135)
  TOP w0.216: U13114.Y46 174.73,135.91 v4(174.41,136.23)
  IN5 w0.14: v4(174.41,136.23) 175.32,135.32 177.44,135.32 178.91,133.85 191.03,133.85 192.69,135.51 194.53,135.51 v4(195.04,135)
VMA_DQ12: length 24.6
  TOP w0.17: v4(179.69,137.02) 179.69,137.1 179.13,137.66 177.9,137.66 U13114.V50
  TOP w0.216: v4(197.64,136.3) U13135.P11
  IN5 w0.14: v4(197.64,136.3) 198.13,136.79 198.13,137.61 196.92,138.82 190.56,138.82 188.38,136.64 180.03,136.64 179.69,136.98 v4(179.69,137.02)
VMA_DQ13: length 25.6
  TOP w0.216: U13114.V47 175.49,137.31 v4(175.81,137) ; U13135.P12 196.99,135.65 v4(196.99,135.65)
  IN5 w0.081: 193.06,136.63 193.06,136.63 196.5,136.63 196.67,136.46 196.67,135.98 v4(196.99,135.65)
  IN5 w0.14: v4(175.81,137) 175.53,136.72 175.53,135.95 175.66,135.83 178.2,135.83 179.06,134.96 189.75,134.96 191.75,136.95 192.42,136.95 192.75,136.63 193.06,136.63
VMA_DQ14: length 24.9
  TOP w0.102: v4(198.94,136.3) 198.29,136.3 U13135.N11
  TOP w0.17: v4(180.27,137.02) 179.28,138.01 U13114.U52
  IN5 w0.14: v4(180.27,137.02) 180.65,137.4 188.03,137.4 190.04,139.41 197.66,139.41 199.02,138.06 199.02,137.42 198.94,137.35 v4(198.94,136.3)
VMA_DQ15: length 24.5
  TOP w0.102: U13135.N12 197.64,135.65 v4(197.64,135)
  TOP w0.17: v4(178.67,136.95) 178.62,136.95 U13114.V51
  IN5 w0.081: v4(197.64,135) 197.64,135.75 197.32,136.07 197.32,137.15
  IN5 w0.14: v4(178.67,136.95) 178.76,136.86 178.76,136.59 179.27,136.08 188.84,136.08 190.95,138.19 196.34,138.19 197.32,137.21 197.32,137.15
VMA_DQ16: length 42.4
  TOP w0.102: v4(206.22,136.31) 205.43,136.31 U13135.B11
  TOP w0.216: U13114.AJ44 173.32,129.61 v4(173.01,129.93)
  IN5 w0.14: v4(206.22,136.31) 206.67,135.86 206.67,133.94 206.5,133.77 206.5,132.94 205.08,131.52 205.08,130.92 202.05,127.9 184.78,127.9 182.77,129.91 177.74,129.91 177.36,129.53 173.4,129.53 v4(173.01,129.93)
VMA_DQ17: length 35.9
  TOP w0.102: v4(179.42,131.01) 179.1,131.33 176.48,131.33 U13114.AG48
  TOP w0.17: v4(205.44,135.65) U13135.B12
  IN5 w0.14: v4(179.42,131.01) 179.96,130.47 182.98,130.47 184.92,128.53 200.86,128.53 204.87,132.55 204.87,133.18 205.21,133.51 205.37,133.51 205.83,133.96 205.83,135.27 v4(205.44,135.65)
VMA_DQ18: length 38.9
  TOP w0.17: v4(204.79,136.95) U13135.C11
  TOP w0.216: U13114.AJ45 174.02,129.61 v4(173.71,129.93)
  IN4 w0.14: v4(173.71,129.93) 174.08,129.56 177.36,129.56 177.57,129.76 184.93,129.76 185.32,129.37 201.32,129.37 204.86,132.91 204.86,133.23 205.18,133.54 205.35,133.54 205.83,134.03 205.83,135.26 205.81,135.28 205.81,135.94 v4(204.79,136.95)
VMA_DQ19: length 33.7
  TOP w0.102: U13135.C12 204.79,135.65 v4(204.79,135)
  TOP w0.216: v4(177.21,130.7) 176.89,131.01 U13114.AG49
  IN5 w0.14: v4(177.21,130.7) 178.55,130.7 179.27,131.41 180.21,131.41 180.59,131.03 183.19,131.03 185.06,129.16 200.46,129.16 204.07,132.78 204.07,133.41 204.42,133.75 204.42,134.63 v4(204.79,135)
VMA_DQ20: length 36.4
  TOP w0.17: v4(202.84,136.3) U13135.F11
  TOP w0.216: U13114.AF46 174.72,131.71 v4(174.41,132.03)
  IN5 w0.081: 202.84,136.3 203.34,135.81 203.34,135.52 203.17,135.35 203.17,134.79
  IN5 w0.14: 203.17,134.79 203.17,134.75 203.47,134.45 203.47,134.07 203.21,133.81 203.21,132.78 200.27,129.83 185.16,129.83 183.4,131.6 180.89,131.6 180.77,131.72 178.81,131.72 178.17,131.08 175.33,131.08 174.41,132 v4(174.41,132.03) ; 202.84,136.3 v4(202.84,136.3)
VMA_DQ21: length 33.3
  TOP w0.17: v4(202.19,135.65) U13135.F12
  TOP w0.216: U13114.AF47 175.42,131.71 v4(175.11,132.03)
  IN5 w0.081: v4(202.19,135.65) 202.52,135.33 202.52,134.68
  IN5 w0.14: 202.52,134.68 202.57,134.63 202.57,133.03 201.54,132 200.93,132 199.64,130.7 185.26,130.7 183.82,132.14 178.45,132.14 177.69,131.38 175.73,131.38 175.11,132 v4(175.11,132.03)
VMA_DQ22: length 31.7
  TOP w0.17: U13135.G11 201.87,136.63 v4(202.19,136.95)
  TOP w0.216: v4(176.51,132.03) 176.47,132.03 U13114.AF48
  IN5 w0.081: v4(202.19,136.95) U13135.G11 201.87,133.82
  IN5 w0.14: 201.87,133.82 201.87,133.71 199.59,131.43 185.32,131.43 184.06,132.69 178.42,132.69 177.36,131.64 176.9,131.64 v4(176.51,132.03)
VMA_DQ23: length 30.9
  TOP w0.17: v4(175.11,132.8) 175.42,133.11 U13114.AD47 ; v4(201.54,136.3) U13135.G12
  IN5 w0.14: v4(201.54,136.3) 200.72,135.48 200.72,133.36 199.6,132.23 185.3,132.23 184.35,133.19 175.47,133.19 175.11,132.82 v4(175.11,132.8)
VMA_DQ24: length 36.1
  TOP w0.216: U13114.AD49 176.89,133.11 v4(177.21,132.8) ; v4(205.44,140.85) U13135.B4
  IN1 w0.14: v4(205.44,140.85) 205.25,140.66 205.25,138.72 204.51,137.98 201.4,137.98 201.16,137.73 201.16,134.43 200.62,133.9 191.18,133.9 189.43,132.15 178.35,132.15 177.7,132.8 v4(177.21,132.8)
VMA_DQ25: length 40.2
  TOP w0.216: U13114.AD48 176.19,133.11 v4(176.51,132.8) ; v4(205.44,142.15) U13135.B3
  IN1 w0.14: v4(176.51,132.8) 176.88,132.43 176.88,132.35 177.21,132.02 177.69,132.02 178.12,131.6 190,131.6 191.27,132.87 193.38,132.87 193.85,133.34 201.14,133.34 201.39,133.6 205.35,133.6 205.81,134.05 205.81,138.38 206.05,138.62 206.05,140.8 205.85,141 205.85,141.75 v4(205.44,142.15)
VMA_DQ26: length 37.6
  TOP w0.102: v4(174.41,132.8) 174.41,133.54 174.68,133.81 U13114.AC46
  TOP w0.216: v4(204.79,141.5) 204.63,141.34 U13135.C4
  IN1 w0.081: v4(204.79,141.5) U13135.C4 204.47,140.68
  IN1 w0.14: v4(174.41,132.8) 174.41,132.82 174.77,133.19 177.95,133.19 178.43,132.71 188.41,132.71 193.02,137.32 197.8,137.32 198.22,136.9 198.99,136.9 199.55,137.45 200.22,137.45 200.53,137.76 200.53,137.89 201.16,138.52 203.69,138.52 204.33,139.17 204.33,139.77 204.51,139.95 204.51,140.64 204.47,140.68
VMA_DQ27: length 38.4
  TOP w0.102: U13135.C3 204.79,142.15 v4(204.79,142.8)
  TOP w0.216: U13114.AC47 175.01,134.26 v4(174.98,134.26)
  IN1 w0.081: 203.91,141.83 204.57,141.83 204.79,142.05 v4(204.79,142.8)
  IN1 w0.14: 203.91,141.83 203.63,141.55 203.63,139.24 203.46,139.07 200.92,139.07 200.13,138.27 199.5,138.27 198.98,137.75 198.98,137.66 198.76,137.44 198.45,137.44 198.03,137.87 192.71,137.87 188.11,133.27 178.61,133.27 178.41,133.47 175.31,133.47 174.98,133.8 v4(174.98,134.26)
VMA_DQ28: length 32.4
  TOP w0.102: v4(202.01,140.08) 202.19,140.27 202.19,140.85 U13135.F4
  TOP w0.216: v4(175.11,134.9) 175.42,135.21 U13114.AA47
  IN1 w0.14: v4(202.01,140.08) 202.01,139.77 201.85,139.62 200.7,139.62 199.9,138.82 199.27,138.82 198.87,138.41 192.47,138.41 187.88,133.82 177.57,133.82 177.49,133.74 175.58,133.74 175.43,133.9 175.43,134.57 v4(175.11,134.9)
VMA_DQ29: length 32.8
  TOP w0.216: U13114.AA46 174.76,135.15 v4(174.46,134.85) ; v4(202.84,141.5) U13135.F3
  IN1 w0.14: v4(202.84,141.5) 202.76,141.5 202.15,140.89 202.1,140.89 201.66,140.44 201.6,140.44 201.5,140.34 201.11,140.34 200.93,140.16 200.47,140.16 199.67,139.37 199.03,139.37 198.63,138.96 192.22,138.96 187.7,134.43 178.3,134.43 177.46,135.27 174.88,135.27 v4(174.46,134.85)
VMA_DQ30: length 32
  TOP w0.216: v4(173.71,134.9) 174.02,135.21 U13114.AA45 ; v4(201.54,141.5) U13135.G4
  IN1 w0.14: v4(201.54,141.5) 201.49,141.5 200.7,140.71 200.21,140.71 199.41,139.91 198.79,139.91 198.38,139.5 191.96,139.5 187.47,135.02 178.66,135.02 178.11,135.56 174.37,135.56 v4(173.71,134.9)
VMA_DQ31: length 35.5
  TOP w0.102: U13135.G3 202.19,142.15 v4(202.19,142.8)
  TOP w0.216: U13114.Y44 173.32,135.91 v4(173.01,136.23)
  IN1 w0.14: v4(202.19,142.8) 201.79,143.2 201.33,143.2 200.71,142.58 200.71,141.42 200.42,141.13 199.81,141.13 199.15,140.47 197.8,140.47 197.15,139.82 193.31,139.82 193,140.12 191.74,140.12 187.43,135.82 182.79,135.82 182.32,136.29 178.53,136.29 178.08,135.84 173.39,135.84 v4(173.01,136.23)
VMA_DQ32: length 19.1
  TOP w0.102: v4(193.67,117.25) 194.39,117.25 U13136.B4
  TOP w0.216: U13114.AW51 178.57,122.3 v4(178.61,122.3)
  IN5 w0.14: v4(178.61,122.3) 178.61,122.32 178.97,122.68 180.54,122.68 185.97,117.25 v4(193.67,117.25)
VMA_DQ33: length 18.1
  TOP w0.216: v4(179.31,121.53) 178.99,121.21 U13114.BA52 ; v4(194.39,116.6) 194.39,116.6 U13136.B3
  IN5 w0.14: v4(179.31,121.53) 179.77,121.07 181.28,121.07 185.74,116.6 v4(194.39,116.6)
VMA_DQ34: length 21.4
  TOP w0.102: U13136.C4 195.04,117.9 v4(194.39,117.9)
  TOP w0.216: v4(177.21,122.3) 177.52,122.61 U13114.AW50
  IN5 w0.14: v4(177.21,122.3) 178.15,123.24 180.78,123.24 185.74,118.28 194.02,118.28 v4(194.39,117.9)
VMA_DQ35: length 23.5
  TOP w0.216: U13114.BA51 178.29,121.21 v4(178.61,121.53) ; v4(195.04,117.25) U13136.C3
  IN5 w0.081: 195.37,115 U13136.C3 v4(195.04,117.25)
  IN5 w0.14: v4(178.61,121.53) 178.61,121.33 179.42,120.51 180.88,120.51 182.14,119.25 182.14,118.46 184.99,115.6 190.24,115.6 190.78,115.07 192.95,115.07 193.14,114.87 195.24,114.87 195.37,115 195.37,115
VMA_DQ36: length 28.5
  TOP w0.216: v4(177.91,121.53) 177.87,121.53 U13114.BA50 ; v4(197.64,117.25) U13136.F4
  IN5 w0.081: 197.97,115.57 197.97,116.28 197.64,116.61 v4(197.64,117.25)
  IN5 w0.14: v4(177.91,121.53) 177.91,121.24 178.26,120.89 178.26,119.92 178.86,119.32 179.26,119.32 185.31,113.28 196.58,113.28 197.59,114.28 197.59,115.19 197.74,115.34 197.97,115.57
VMA_DQ37: length 26.3
  TOP w0.102: U13114.BB50 177.91,120.87 179.85,120.87 180.04,120.68 ; U13136.F3 197.64,116.6 v4(197.64,115.95)
  TOP w0.216: v4(180.57,120.15) 180.04,120.68
  IN5 w0.14: v4(197.64,115.95) 197.51,115.95 196.68,115.13 196.68,115.13 196.49,114.93 196.49,114.13 196.29,113.93 185.42,113.93 180.57,118.79 v4(180.57,120.15)
VMA_DQ38: length 34.6
  TOP w0.216: v4(198.29,117.9) U13136.G4 ; U13114.BA49 v4(176.52,121.55)
  IN5 w0.14: v4(176.52,121.55) 176.37,121.55 176.27,121.45 176.27,121.02 176.91,120.39 176.91,119.28 184.25,111.93 197.54,111.93 199.23,113.63 199.23,115.05 199.46,115.28 199.46,116.74 v4(198.29,117.9)
VMA_DQ39: length 31.2
  TOP w0.216: v4(198.29,116.6) U13136.G3 ; U13114.AW49 176.82,122.61 v4(176.51,122.3)
  IN5 w0.081: v4(198.29,116.6) 198.62,116.28 198.62,115.63
  IN5 w0.14: v4(176.51,122.3) 176.93,121.87 176.93,121.43 177.46,120.9 177.46,119.93 184.79,112.6 197.19,112.6 198.4,113.82 198.4,115.42 198.62,115.63
VMA_DQ40: length 20.2
  TOP w0.102: U13136.B11 194.38,122.46 193.74,122.46 v4(193.59,122.61)
  TOP w0.216: U13114.AV48 176.19,123.31 v4(176.51,123.63)
  IN1 w0.14: v4(176.51,123.63) 176.88,123.25 178.33,123.25 179.09,124.02 180.11,124.02 180.34,123.78 180.88,123.78 181.1,123.56 182.19,123.56 183.46,122.29 192.41,122.29 192.73,122.61 v4(193.59,122.61)
VMA_DQ41: length 19.4
  TOP w0.102: U13136.B12 194.39,123.1 193.53,123.1
  TOP w0.216: 193.53,123.1 192.89,123.1 v4(192.62,123.37) ; v4(177.19,124.39) U13114.AT49
  IN1 w0.14: v4(192.62,123.37) 192.15,122.9 183.64,122.9 182.42,124.12 181.33,124.12 181.12,124.32 180.61,124.32 180.13,124.81 177.64,124.81 177.22,124.39 v4(177.19,124.39)
VMA_DQ42: length 24.9
  TOP w0.216: v4(195.04,122.45) U13136.C11 ; U13114.AT47 175.42,124.71 v4(175.11,124.4)
  IN1 w0.14: v4(195.04,122.45) 195.33,122.74 195.33,123.25 195.48,123.4 195.48,124 194.83,124.65 194.83,124.8 194.57,125.05 191.65,125.05 190.67,124.07 184.04,124.07 182.89,125.23 181.01,125.23 180.9,125.33 176.04,125.33 v4(175.11,124.4)
VMA_DQ43: length 21.5
  TOP w0.102: U13136.C12 195.04,123.1 v4(195.04,123.75)
  TOP w0.216: v4(176.51,124.4) 176.47,124.4 U13114.AT48
  IN1 w0.14: v4(176.51,124.4) 176.51,124.42 177.15,125.06 180.39,125.06 180.77,124.68 182.65,124.68 183.81,123.51 190.93,123.51 191.56,124.15 194.53,124.15 194.93,123.75 v4(195.04,123.75)
VMA_DQ44: length 30.3
  TOP w0.216: v4(174.41,124.4) 174.72,124.71 U13114.AT46 ; v4(196.99,122.45) U13136.F11
  IN1 w0.081: 197.32,121.17 197.32,122.05 196.99,122.38 v4(196.99,122.45)
  IN1 w0.14: v4(174.41,124.4) 174.05,124.76 173.48,124.76 173.35,124.63 173.35,123.21 173.87,122.68 180.41,122.68 180.66,122.43 181.59,122.43 183.42,120.61 196.75,120.61 197.32,121.17
VMA_DQ45: length 23
  TOP w0.102: v4(196.99,123.75) 196.99,123.1 U13136.F12
  TOP w0.216: v4(179.33,123.6) 179.25,123.69 178.63,123.69 U13114.AV51
  IN1 w0.081: 196.41,121.36 196.67,121.63 196.67,122.04 196.67,122.7 196.99,123.03 v4(196.99,123.75)
  IN1 w0.14: 196.41,121.36 183.45,121.36 181.81,123 180.87,123 180.64,123.23 179.71,123.23 v4(179.33,123.6)
VMA_DQ46: length 25.4
  TOP w0.216: v4(180.58,121.5) 180.58,122.32 179.71,123.19 179.08,123.19 U13114.AV52 ; v4(198.29,122.45) U13136.G11
  IN1 w0.14: v4(198.29,122.45) 198.52,122.23 198.52,121.63 198.98,121.18 198.98,120.54 197.67,119.23 182.85,119.23 v4(180.58,121.5)
VMA_DQ47: length 25.8
  TOP w0.102: U13114.AV49 177.24,122.93 179.39,122.93 179.63,122.68
  TOP w0.216: v4(179.99,122.32) 179.63,122.68 ; U13136.G12 197.64,123.1 v4(197.64,123.1)
  IN1 w0.081: v4(197.64,123.1) 197.97,122.78 197.97,122.21
  IN1 w0.14: 197.97,122.21 198.01,122.16 198.01,120.87 197.04,119.9 183.34,119.9 181.35,121.89 180.43,121.89 v4(179.99,122.32)
VMA_DQ48: length 41.2
  TOP w0.216: U13114.AJ48 176.19,129.61 v4(176.51,129.93) ; U13136.V11 v4(205.44,121.8)
  IN1 w0.14: v4(176.51,129.93) 176.9,129.53 177.39,129.53 177.64,129.79 190.67,129.79 191.61,130.72 199.1,130.72 199.92,131.54 202.74,131.54 203.28,130.99 205.89,128.39 205.89,127.09 207.16,125.82 207.16,122.4 206.42,121.66 205.59,121.66 v4(205.44,121.8)
VMA_DQ49: length 37.3
  TOP w0.216: U13114.AJ46 174.79,129.61 v4(175.11,129.93) ; v4(205.44,123.1) U13136.V12
  IN1 w0.14: v4(175.11,129.93) 175.11,129.9 176.01,129 177.36,129 177.66,128.69 191.43,128.69 192.36,129.63 201.68,129.63 202.38,128.92 203.17,128.92 204.35,127.74 204.35,126.83 205.37,125.81 205.37,125.31 205.81,124.88 205.81,123.47 v4(205.44,123.1)
VMA_DQ50: length 40.5
  TOP w0.216: U13114.AJ47 175.49,129.61 v4(175.81,129.93) ; v4(204.14,121.8) U13136.U11
  IN1 w0.081: v4(204.14,121.8) U13136.U11 205.72,122.13
  IN1 w0.14: 205.72,122.13 206.58,122.99 206.58,125.39 205,126.97 205,128.36 203.19,130.17 192.08,130.17 191.14,129.24 176.5,129.24 v4(175.81,129.93)
VMA_DQ51: length 34.1
  TOP w0.216: U13114.AK49 176.88,128.91 v4(177.2,128.59) ; v4(204.79,122.45) 204.79,122.45 204.47,122.77 U13136.U12
  IN1 w0.081: v4(204.79,122.45) U13136.U12 204.47,124.63
  IN1 w0.14: v4(177.2,128.59) 177.66,128.13 191.64,128.13 192.59,129.08 201.09,129.08 201.97,128.2 202.81,128.2 203.73,127.28 203.73,125.7 204.47,124.96 204.47,124.63
VMA_DQ52: length 34.4
  TOP w0.216: v4(202.84,121.8) U13136.P11 ; v4(175.82,127.82) 175.76,127.82 U13114.AM47
  IN1 w0.081: v4(202.84,121.8) 203.17,122.13 203.17,123.36
  IN1 w0.14: v4(175.82,127.82) 175.82,127.81 176.2,127.42 177.79,127.42 177.95,127.58 191.86,127.58 192.31,128.03 201.12,128.03 202.11,127.03 202.88,126.27 202.88,125.41 203.23,125.05 203.34,125.05 203.73,124.66 203.73,123.92 203.17,123.36
VMA_DQ53: length 32.4
  TOP w0.216: v4(202.84,123.1) U13136.P12 ; v4(175.1,127.83) 175.08,127.83 U13114.AM46
  IN1 w0.081: 202.52,123.98 202.52,123.43 v4(202.84,123.1)
  IN1 w0.14: 202.52,123.98 202.59,124.04 202.59,124.68 202.31,124.96 202.31,125.9 200.72,127.48 192.54,127.48 192.08,127.03 178.26,127.03 178.12,127.17 175.76,127.17 175.1,127.82 v4(175.1,127.83)
VMA_DQ54: length 30.5
  TOP w0.102: U13114.AN48 176.49,127.14 176.98,127.14 177.21,126.91 v4(177.21,126.52)
  TOP w0.216: v4(201.54,121.8) U13136.N11
  IN1 w0.14: v4(201.54,121.8) 200.62,122.73 200.62,125.61 199.84,126.39 192.99,126.39 192.47,125.87 181.3,125.87 181.1,126.08 178.2,126.08 177.76,126.52 177.22,126.52 v4(177.21,126.52)
VMA_DQ55: length 29.5
  TOP w0.216: v4(176.51,126.52) 176.81,126.81 U13114.AN49 ; v4(201.54,123.1) U13136.N12
  IN1 w0.14: v4(201.54,123.1) 201.17,123.48 201.17,125.84 200.08,126.93 192.76,126.93 192.29,126.46 178.33,126.46 177.87,126.91 176.9,126.91 176.51,126.52 v4(176.51,126.52)
VMA_DQ56: length 43.3
  TOP w0.216: v4(173.01,127.81) 173.31,127.51 U13114.AM44 ; v4(205.44,117.9) U13136.V4
  IN5 w0.14: v4(173.01,127.81) 173.01,127.81 173.4,127.42 177.54,127.42 177.87,127.75 181.93,127.75 185.64,124.04 191.28,124.04 191.43,124.19 200.52,124.19 201.37,125.04 205.32,125.04 205.84,124.52 205.84,119.49 205.1,118.75 205.1,118.25 v4(205.44,117.9)
