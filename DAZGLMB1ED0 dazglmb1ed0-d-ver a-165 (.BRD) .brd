# Allegro board DAZGLMB1ED0 dazglmb1ed0-d-ver a-165 (.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GPU_CLK#_C: length 1.8
  TOP w0.102: R22125.1 v1(226.33,167.25) C94750.2
  BOTTOM w0.102: v1(226.33,167.25) R22135.2
GPU_CLK_C: length 1.8
  TOP w0.102: R22124.1 v1(225.45,167.25) C94749.2
  BOTTOM w0.102: v1(225.45,167.25) R22134.2
GPU_D0: length 138.3
  TOP w0.102: v1(222.91,165.62) 223.31,165.62 223.51,165.83 223.51,166.06 223.41,166.16 C94751.1 ; v2(155.51,116.66) 155.51,116.9 155.4,117.01 U13114.BG18
  IN1 w0.089: v1(222.91,165.62) 223.46,165.62 223.51,165.57 223.51,165.32 223.3,165.1 220.53,165.1 218.34,162.92 214.7,162.92 210.27,158.49 210.27,114.64 204.58,108.94 199.91,108.94 189.55,98.58 169.5,98.58 168.49,99.58 162.28,99.58 158.25,103.61 158.25,104.27 158.02,104.5 158.02,105.87 157.39,106.5 157.39,113.61 156.33,114.67 156.18,114.67 155.72,115.13 155.72,115.43 155.24,115.92 155.24,116.58 155.32,116.66 v2(155.51,116.66)
GPU_D0#: length 138.3
  TOP w0.102: C94743.1 v1(223.92,165.62) ; U13114.BF18 155.49,117.38 v2(155.54,117.38)
  IN1 w0.089: v2(155.54,117.38) 155.54,117.32 154.97,116.76 154.97,115.81 155.46,115.32 155.46,115.02 156.07,114.41 156.22,114.41 157.12,113.5 157.12,106.39 157.75,105.76 157.75,104.39 157.98,104.16 157.98,103.5 162.16,99.32 168.38,99.32 169.39,98.31 189.66,98.31 200.02,108.68 204.69,108.68 210.54,114.53 210.54,158.38 214.81,162.65 218.45,162.65 220.64,164.84 223.41,164.84 223.78,165.21 223.78,165.49 v1(223.92,165.62)
GPU_D0#_C: length 1.9
  TOP w0.102: R22123.1 v1(223.92,167.2) C94743.2
  BOTTOM w0.102: v1(223.92,167.2) R22133.2
GPU_D0_C: length 1.9
  TOP w0.102: C94751.2 v1(223.03,167.17) R22122.1
  BOTTOM w0.102: v1(223.03,167.17) R22132.2
GPU_D1: length 134.1
  TOP w0.102: v2(156.21,115.96) 156.38,115.96 156.56,116.14 U13114.BH20 ; v1(220.49,165.65) C94744.1
  IN1 w0.089: v1(220.49,165.65) 220.7,165.65 220.81,165.76 220.81,166.07 220.69,166.2 219.71,166.2 219.44,165.92 219.44,164.85 218.94,164.36 218.2,163.62 214.29,163.62 209.81,159.13 209.81,114.84 204.5,109.53 199.67,109.53 189.26,99.11 174.63,99.11 173.62,100.13 162.49,100.13 159.15,103.47 159.15,105.88 157.87,107.17 157.87,113.93 156.75,115.04 156.75,116.08 156.59,116.25 156.31,116.25 156.21,116.15 v2(156.21,115.96)
GPU_D1#: length 134.1
  TOP w0.102: v1(221.25,165.65) C94754.1 ; v2(156.21,116.66) U13114.BG20
  IN1 w0.089: v1(221.25,165.65) 221.08,165.83 221.08,166.18 220.8,166.46 219.6,166.46 219.17,166.03 219.17,164.96 218.75,164.55 218.09,163.88 214.18,163.88 209.54,159.24 209.54,114.95 204.39,109.8 199.56,109.8 189.15,99.38 174.74,99.38 173.73,100.4 162.61,100.4 159.42,103.59 159.42,105.99 158.14,107.28 158.14,114.04 157.02,115.15 157.02,116.19 156.7,116.51 156.36,116.51 v2(156.21,116.66)
GPU_D1#_C: length 1.7
  TOP w0.102: C94754.2 v1(221.25,167.12) R22121.1
  BOTTOM w0.102: v1(221.25,167.12) R22131.2
GPU_D1_C: length 1.7
  TOP w0.102: R22120.1 v1(220.49,167.12) C94744.2
  BOTTOM w0.102: v1(220.49,167.12) R22130.2
GPU_D2: length 132.9
  TOP w0.102: v1(218.08,165.62) 218.31,165.85 218.31,165.93 C94747.1 ; v2(156.2,118.76) 156.55,118.41 U13114.BE20
  IN1 w0.089: v1(218.08,165.62) 218.19,165.62 218.29,165.52 218.29,165.25 217.74,164.7 213.78,164.7 208.8,159.72 208.8,115.25 204.22,110.67 199.35,110.67 188.94,100.26 175.09,100.26 174.16,101.18 162.93,101.18 160.36,103.76 160.36,106.32 159.49,107.19 159.49,108.85 160,109.35 160,113.67 159.15,114.52 159.15,117.85 158.21,118.79 157.25,118.79 156.79,118.33 156.51,118.33 156.2,118.63 v2(156.2,118.76)
GPU_D2#: length 132.9
  TOP w0.102: U13114.BF20 156.56,117.85 156.34,118.06 v2(156.21,118.06) ; v1(218.76,165.62) 218.84,165.7 C94748.1
  IN1 w0.089: v1(218.76,165.62) 218.56,165.42 218.56,165.14 217.85,164.43 213.89,164.43 209.07,159.61 209.07,115.14 204.33,110.41 199.46,110.41 189.05,99.99 174.98,99.99 174.05,100.92 162.82,100.92 160.09,103.65 160.09,106.21 159.23,107.08 159.23,108.96 159.74,109.47 159.74,113.55 158.88,114.41 158.88,117.74 158.1,118.52 157.36,118.52 157.3,118.46 156.9,118.06 v2(156.21,118.06)
GPU_D2#_C: length 1.7
  TOP w0.102: C94748.2 v1(218.84,167.12) R22119.1
  BOTTOM w0.102: v1(218.84,167.12) R22129.2
GPU_D2_C: length 1.7
  TOP w0.102: C94747.2 v1(218.08,167.12) R22118.1
  BOTTOM w0.102: v1(218.08,167.12) R22128.2
GPU_DDCCLK: length 159.5
  TOP w0.137: 149.19,114.03 149.19,114.58 U13114.BK9
  TOP w0.14: 149.19,114.03 149.45,113.78 149.45,113.07 v2(149.5,113.02)
  IN1 w0.089: v2(149.5,113.02) 149.63,112.89 149.63,112.64 149.71,112.55 150.07,112.55 152.92,109.71 154.05,109.71 154.85,108.92 154.85,107.52 155.85,106.52 155.85,105.52 155.58,105.25 155.58,105.12 155.34,104.88 155.34,104.11 154.71,103.47 154.71,102.58 155.37,101.92 155.37,100.14 158.57,96.94 190.49,96.94 200.67,107.12 204.83,107.12 211.75,114.03 211.75,155.43 213.76,157.44 213.76,159.37 215.72,161.33 218.84,161.33 221.14,163.63 225.94,163.63 227.92,165.61 227.92,167.89 228.15,168.12 228.15,168.94 v1(227.15,169.94)
  BOTTOM w0.102: Q34.4 227.87,170 228.01,170.15 R21026.1 227.73,170.53 v1(227.15,169.94) ; v2(149.5,113.02) 149.03,112.55 149.03,109.01 R21532.2
GPU_DDCDATA: length 157.1
  TOP w0.137: 148.86,113.99 U13114.BL9
  TOP w0.14: v2(149.45,112.28) 149.02,112.72 149.02,113.15 149.21,113.34 149.21,113.64 148.86,113.99
  IN1 w0.089: v1(229.74,167.1) 228.9,167.94 228.34,167.94 228.19,167.78 228.19,165.5 226.05,163.36 221.25,163.36 218.95,161.07 215.84,161.07 214.03,159.26 214.03,157.33 212.01,155.32 212.01,113.92 204.94,106.85 200.78,106.85 190.6,96.67 158.46,96.67 155.1,100.03 155.1,101.81 154.44,102.47 154.44,103.58 155.07,104.22 155.07,104.99 155.31,105.23 155.31,105.36 155.58,105.63 155.58,106.4 154.58,107.41 154.58,108.8 153.94,109.44 152.8,109.44 149.96,112.28 v2(149.45,112.28)
  BOTTOM w0.102: R21533.1 149.36,109.65 149.36,111.76 149.45,111.85 v2(149.45,112.28) ; Q34.1 228.87,167.48 228.72,167.33 R21032.1 v1(229.74,167.1)
GPU_PEX_RST_HOLD#: length 10.2
  TOP w0.127: v2(144.31,116.66) U13114.BG3
  BOTTOM w0.14: R21595.2 136.8,113.5 TP13113.1 138.11,114.82 141.49,114.82 143.07,116.4 144.05,116.4 v2(144.31,116.66)
GPU_TBT_AUXN: length 248.6
  TOP w0.14: U13114.BM9 148.6,113.25 148.6,112.37 149.34,111.63 149.34,109.67 150.75,108.26 150.75,107.55 v1(150.87,107.43) 151.02,107.28 R21880.2 ; v1(334.41,47.84) 334.95,48.38 C94556.1
  IN4 w0.089: v1(150.87,107.43) 150.68,107.24 150.68,105.62 150.57,105.5 150.57,102.84 151.26,102.14 151.7,102.14 151.85,101.99 152.47,101.99 152.75,101.71 152.75,101.07 158.81,95.01 171.05,95.01 174.22,91.84 198.96,91.84 199.23,92.12 222.52,92.12 223.18,91.46 276.46,91.46 281.64,86.28 281.64,85.9 284.09,83.46 288.34,83.46 289.51,82.29 294,82.29 295.16,81.13 295.44,81.13 296.27,80.29 297.17,79.39 297.17,79.11 298.01,78.28 307.29,78.28 308.58,76.99 311.72,76.99 311.88,76.83 319.78,76.83 321.03,75.58 321.78,75.58 323,74.36 324.15,74.36 326.28,72.23 326.28,70.96 326.61,70.63 329.84,70.63 329.99,70.48 330.7,70.48 332,69.18 332.51,69.18 333.4,68.29 333.4,66.64 333.78,66.26 333.78,61.69 332,59.91 332,53.81 332.51,53.31 338.86,53.31 339.24,52.92 339.24,52.01 339.11,51.89 v1(339.11,51.6)
  BOTTOM w0.14: v1(334.41,47.84) 334.26,48 334.26,48.2 335.11,49.05 336.56,49.05 v1(339.11,51.6) 339.07,51.65 339.07,52.05 339.24,52.22 339.24,53.18 340.82,54.77 341.36,54.77 C94567.2
GPU_TBT_AUXP: length 248.6
  TOP w0.14: C94555.1 334.03,48.12 v1(333.75,47.84) ; U13114.BM8 148.28,113.39 148.28,112.24 149.02,111.5 149.02,109.54 150.43,108.13 150.43,107.66 v1(150.21,107.43) 150.01,107.23 R21879.2
  IN4 w0.089: v1(338.6,52.04) 339.01,52.04 339.06,52.09 339.06,52.85 338.78,53.13 332.43,53.13 331.82,53.74 331.82,59.98 333.6,61.76 333.6,66.19 333.22,66.57 333.22,68.22 332.43,69 331.92,69 330.63,70.3 329.92,70.3 329.77,70.45 326.54,70.45 326.11,70.88 326.11,72.15 324.07,74.18 322.93,74.18 321.71,75.4 320.95,75.4 319.71,76.65 311.81,76.65 311.65,76.81 308.51,76.81 307.22,78.1 297.93,78.1 297,79.04 297,79.32 296.15,80.17 295.37,80.95 295.09,80.95 293.93,82.11 289.44,82.11 288.27,83.28 284.02,83.28 281.46,85.83 281.46,86.2 276.38,91.29 223.1,91.29 222.45,91.94 199.31,91.94 199.03,91.67 174.14,91.67 170.98,94.83 158.73,94.83 152.57,101 152.57,101.63 152.4,101.81 151.77,101.81 151.62,101.96 151.19,101.96 150.39,102.76 150.39,105.58 150.5,105.69 150.5,107.32 150.49,107.33 150.49,107.36 150.41,107.43 v1(150.21,107.43)
  BOTTOM w0.14: C94566.2 340.69,55.08 338.92,53.31 338.92,52.35 v1(338.6,52.04) 338.6,51.54 336.43,49.37 334.98,49.37 333.94,48.33 333.94,48.04 v1(333.75,47.84)
GPU_TBT_D0: length 239.8
  TOP w0.14: v1(329.43,58.74) 329.29,58.6 329.29,58.38 329.42,58.24 329.83,58.24 C93687.1 ; v1(149.83,110.35) 150.54,111.07 150.54,111.57 151.91,112.95 151.91,113.63 152.13,113.85 152.43,113.85 152.52,113.94 152.52,114.05 U13114.BL14
  IN4 w0.089: v1(149.83,110.35) 149.83,110.54 149.73,110.63 149.47,110.63 149.3,110.46 149.3,108.88 149.55,108.63 149.55,104.49 149.42,104.36 149.42,102.99 150.92,101.49 151.41,101.49 158.54,94.37 170.78,94.37 174.33,90.82 194.77,90.82 195.52,90.06 198.67,90.06 200.08,91.47 222.08,91.47 222.73,90.82 223.37,90.82 223.56,90.62 223.56,90.36 223.65,90.27 223.94,90.27 224.03,90.36 224.03,90.62 224.22,90.82 224.66,90.82 224.85,90.62 224.85,90.36 224.94,90.27 225.24,90.27 225.32,90.36 225.32,90.62 225.52,90.82 225.96,90.82 226.15,90.62 226.15,90.36 226.24,90.27 226.53,90.27 226.62,90.36 226.62,90.62 226.81,90.82 227.25,90.82 227.44,90.62 227.44,90.36 227.53,90.27 227.83,90.27 227.91,90.36 227.91,90.62 228.11,90.82 228.55,90.82 228.74,90.62 228.74,90.36 228.83,90.27 229.12,90.27 229.21,90.36 229.21,90.62 229.4,90.82 229.84,90.82 230.04,90.62 230.04,90.36 230.12,90.27 230.42,90.27 230.51,90.36 230.51,90.62 230.7,90.82 231.14,90.82 231.33,90.62 231.33,90.36 231.42,90.27 231.71,90.27 231.8,90.36 231.8,90.62 231.99,90.82 232.43,90.82 232.63,90.62 232.63,90.36 232.72,90.27 233.01,90.27 233.1,90.36 233.1,90.62 233.29,90.82 233.73,90.82 233.92,90.62 233.92,90.36 234.01,90.27 234.3,90.27 234.39,90.36 234.39,90.62 234.58,90.82 235.02,90.82 235.22,90.62 235.22,90.36 235.31,90.27 235.6,90.27 235.69,90.36 235.69,90.62 235.88,90.82 236.32,90.82 236.51,90.62 236.51,90.36 236.6,90.27 236.89,90.27 236.98,90.36 236.98,90.62 237.18,90.82 237.61,90.82 237.81,90.62 237.81,90.36 237.9,90.27 238.19,90.27 238.28,90.36 238.28,90.62 238.47,90.82 238.91,90.82 239.1,90.62 239.1,90.36 239.19,90.27 239.48,90.27 239.57,90.36 239.57,90.62 239.77,90.82 240.21,90.82 240.4,90.62 240.4,90.36 240.49,90.27 240.78,90.27 240.87,90.36 240.87,90.62 241.06,90.82 241.5,90.82 241.69,90.62 241.69,90.36 241.78,90.27 242.08,90.27 242.16,90.36 242.16,90.62 242.36,90.82 242.8,90.82 242.99,90.62 242.99,90.36 243.08,90.27 243.37,90.27 243.46,90.36 243.46,90.62 243.65,90.82 244.09,90.82 244.29,90.62 244.29,90.36 244.37,90.27 244.67,90.27 244.75,90.36 244.75,90.62 244.95,90.82 245.39,90.82 245.58,90.62 245.58,90.36 245.67,90.27 245.96,90.27 246.05,90.36 246.05,90.62 246.24,90.82 246.68,90.82 246.88,90.62 246.88,90.36 246.96,90.27 247.26,90.27 247.35,90.36 247.35,90.62 247.54,90.82 275.64,90.82 279.39,87.06 279.94,87.06 280.99,86.01 280.99,85.64 284.12,82.52 288.37,82.52 289.35,81.54 293.42,81.54 294.48,80.48 295.17,80.48 296.13,79.52 296.13,79.14 297.64,77.63 307.02,77.63 308.31,76.34 311.45,76.34 311.7,76.09 316.83,76.09 318.1,74.82 321.45,74.82 323.03,73.24 324.12,73.24 325.52,71.85 325.52,70.7 326.31,69.92 328.34,69.92 329.82,68.44 330.47,68.44 332.94,65.98 332.94,65.04 332.13,64.23 332.13,62.2 329.1,59.18 329.1,58.79 329.15,58.74 v1(329.43,58.74)
GPU_TBT_D0#: length 239.9
  TOP w0.14: C94548.1 329.92,57.92 329.29,57.92 328.82,58.39 v1(328.82,58.51) ; v1(149.8,111.01) 150.22,111.43 150.22,111.71 151.67,113.15 151.67,113.73 152.01,114.07 152.01,114.57 U13114.BK14
  IN4 w0.089: v1(328.82,58.51) 328.92,58.61 328.92,59.25 331.95,62.27 331.95,64.3 332.76,65.11 332.76,65.9 330.4,68.26 329.74,68.26 328.27,69.74 326.23,69.74 325.34,70.63 325.34,71.77 324.05,73.07 322.96,73.07 321.38,74.64 318.03,74.64 316.76,75.91 311.63,75.91 311.38,76.17 308.24,76.17 306.95,77.46 297.56,77.46 295.96,79.06 295.96,79.44 295.1,80.3 294.41,80.3 293.35,81.36 289.27,81.36 288.29,82.34 284.04,82.34 280.82,85.56 280.82,85.93 279.87,86.88 279.32,86.88 275.57,90.64 247.61,90.64 247.52,90.55 247.52,90.28 247.33,90.09 246.89,90.09 246.7,90.28 246.7,90.55 246.61,90.64 246.32,90.64 246.23,90.55 246.23,90.28 246.04,90.09 245.6,90.09 245.4,90.28 245.4,90.55 245.31,90.64 245.02,90.64 244.93,90.55 244.93,90.28 244.74,90.09 244.3,90.09 244.11,90.28 244.11,90.55 244.02,90.64 243.73,90.64 243.64,90.55 243.64,90.28 243.44,90.09 243,90.09 242.81,90.28 242.81,90.55 242.72,90.64 242.43,90.64 242.34,90.55 242.34,90.28 242.15,90.09 241.71,90.09 241.52,90.28 241.52,90.55 241.43,90.64 241.14,90.64 241.05,90.55 241.05,90.28 240.85,90.09 240.41,90.09 240.22,90.28 240.22,90.55 240.13,90.64 239.84,90.64 239.75,90.55 239.75,90.28 239.56,90.09 239.12,90.09 238.93,90.28 238.93,90.55 238.84,90.64 238.54,90.64 238.46,90.55 238.46,90.28 238.26,90.09 237.82,90.09 237.63,90.28 237.63,90.55 237.54,90.64 237.25,90.64 237.16,90.55 237.16,90.28 236.97,90.09 236.53,90.09 236.33,90.28 236.33,90.55 236.25,90.64 235.95,90.64 235.86,90.55 235.86,90.28 235.67,90.09 235.23,90.09 235.04,90.28 235.04,90.55 234.95,90.64 234.66,90.64 234.57,90.55 234.57,90.28 234.38,90.09 233.94,90.09 233.74,90.28 233.74,90.55 233.66,90.64 233.36,90.64 233.27,90.55 233.27,90.28 233.08,90.09 232.64,90.09 232.45,90.28 232.45,90.55 232.36,90.64 232.07,90.64 231.98,90.55 231.98,90.28 231.79,90.09 231.35,90.09 231.15,90.28 231.15,90.55 231.06,90.64 230.77,90.64 230.68,90.55 230.68,90.28 230.49,90.09 230.05,90.09 229.86,90.28 229.86,90.55 229.77,90.64 229.48,90.64 229.39,90.55 229.39,90.28 229.19,90.09 228.76,90.09 228.56,90.28 228.56,90.55 228.47,90.64 228.18,90.64 228.09,90.55 228.09,90.28 227.9,90.09 227.46,90.09 227.27,90.28 227.27,90.55 227.18,90.64 226.89,90.64 226.8,90.55 226.8,90.28 226.6,90.09 226.16,90.09 225.97,90.28 225.97,90.55 225.88,90.64 225.59,90.64 225.5,90.55 225.5,90.28 225.31,90.09 224.87,90.09 224.68,90.28 224.68,90.55 224.59,90.64 224.3,90.64 224.21,90.55 224.21,90.28 224.01,90.09 223.57,90.09 223.38,90.28 223.38,90.55 223.29,90.64 222.66,90.64 222.01,91.29 200.16,91.29 198.75,89.88 195.45,89.88 194.69,90.64 174.26,90.64 170.71,94.19 158.46,94.19 151.34,101.31 150.85,101.31 149.25,102.91 149.25,104.44 149.37,104.56 149.37,108.55 149.12,108.81 149.12,110.53 149.4,110.81 149.6,110.81 v1(149.8,111.01)
GPU_TBT_D1: length 235
  TOP w0.14: C94553.1 328.5,56.89 328.36,56.89 328.11,57.14 v1(327.86,57.14) ; v2(150.62,114.57) U13114.BK12
  IN4 w0.089: v1(327.86,57.14) 328.04,57.14 328.11,57.22 328.11,57.4 327.55,57.96 327.55,60.04 328.01,60.49 328.01,63.29 328.14,63.41 328.14,64.69 328.82,65.37 328.82,66.69 328.42,67.1 327.63,67.1 326.95,67.78 325.01,67.78 324.61,68.19 324.61,68.83 323.21,70.22 322.19,70.22 319.93,72.48 314.52,72.48 312.47,74.53 309.63,74.53 309.58,74.48 307.5,74.48 307.31,74.28 297.79,74.28 296.29,75.78 296.29,76.72 294.33,78.68 291.59,78.68 290.96,79.32 289.4,79.32 288,80.72 283.56,80.72 282.68,81.6 282.68,81.87 281.27,83.28 280.92,83.28 275.4,88.8 263.1,88.8 262.9,88.99 262.9,89.25 262.81,89.34 262.52,89.34 262.43,89.25 262.43,88.99 262.24,88.8 261.8,88.8 261.61,88.99 261.61,89.25 261.52,89.34 261.23,89.34 261.14,89.25 261.14,88.99 260.95,88.8 260.51,88.8 260.31,88.99 260.31,89.25 260.22,89.34 259.93,89.34 259.84,89.25 259.84,88.99 259.65,88.8 259.21,88.8 259.02,88.99 259.02,89.25 258.93,89.34 258.64,89.34 258.55,89.25 258.55,88.99 258.35,88.8 257.91,88.8 257.72,88.99 257.72,89.25 257.63,89.34 257.34,89.34 257.25,89.25 257.25,88.99 257.06,88.8 256.62,88.8 256.43,88.99 256.43,89.25 256.34,89.34 256.05,89.34 255.96,89.25 255.96,88.99 255.76,88.8 221.78,88.8 220.62,89.96 200.81,89.96 199.3,88.45 194.37,88.45 193.88,88.94 174.13,88.94 170.17,92.89 157.92,92.89 150.82,99.99 150.06,99.99 149.32,100.73 148.94,100.73 148.56,101.11 148.56,101.24 148.23,101.57 147.96,101.57 147.45,102.07 144.68,102.07 144.24,102.51 144.24,103.34 143.65,103.93 143.65,107.91 143.74,108 143.74,109.37 146.4,112.03 147.29,112.03 148.86,113.61 149.42,113.61 150.08,114.27 150.31,114.27 v2(150.62,114.57)
GPU_TBT_D1#: length 235
  TOP w0.14: v2(150.61,113.88) 150.94,114.21 U13114.BL12 ; v1(327.98,56.48) 328.37,56.48 328.46,56.57 328.76,56.57 C94554.1
  IN4 w0.089: v2(150.61,113.88) 150.4,114.09 150.16,114.09 149.5,113.43 148.94,113.43 147.36,111.85 146.48,111.85 143.92,109.29 143.92,107.93 143.83,107.84 143.83,104.01 144.42,103.42 144.42,102.58 144.75,102.25 147.53,102.25 148.03,101.74 148.31,101.74 148.74,101.31 148.74,101.18 149.02,100.91 149.4,100.91 150.13,100.17 150.9,100.17 158,93.07 170.24,93.07 174.2,89.11 193.96,89.11 194.44,88.62 199.22,88.62 200.73,90.14 220.7,90.14 221.86,88.97 255.69,88.97 255.78,89.06 255.78,89.33 255.97,89.52 256.41,89.52 256.6,89.33 256.6,89.06 256.69,88.97 256.99,88.97 257.07,89.06 257.07,89.33 257.27,89.52 257.71,89.52 257.9,89.33 257.9,89.06 257.99,88.97 258.28,88.97 258.37,89.06 258.37,89.33 258.56,89.52 259,89.52 259.2,89.33 259.2,89.06 259.28,88.97 259.58,88.97 259.66,89.06 259.66,89.33 259.86,89.52 260.3,89.52 260.49,89.33 260.49,89.06 260.58,88.97 260.87,88.97 260.96,89.06 260.96,89.33 261.15,89.52 261.59,89.52 261.79,89.33 261.79,89.06 261.87,88.97 262.17,88.97 262.26,89.06 262.26,89.33 262.45,89.52 262.89,89.52 263.08,89.33 263.08,89.06 263.17,88.97 275.47,88.97 280.99,83.46 281.34,83.46 282.85,81.95 282.85,81.68 283.63,80.9 288.07,80.9 289.48,79.49 291.03,79.49 291.66,78.86 294.41,78.86 296.47,76.79 296.47,75.86 297.87,74.46 307.23,74.46 307.43,74.65 309.51,74.65 309.56,74.71 312.55,74.71 314.59,72.66 320.01,72.66 322.27,70.4 323.28,70.4 324.78,68.9 324.78,68.26 325.09,67.96 327.02,67.96 327.71,67.28 328.49,67.28 329,66.77 329,65.3 328.32,64.61 328.32,63.34 328.19,63.21 328.19,60.42 327.73,59.96 327.73,58.04 328.29,57.48 328.29,56.79 v1(327.98,56.48)
GPU_TBT_D2: length 237.3
  TOP w0.14: v2(150.85,112.97) 150.82,113 150.82,113.37 U13114.BM12 ; C94551.1 330.1,55.93 329.86,55.69 329.18,55.69 v1(329.03,55.85)
  IN4 w0.089: v2(150.85,112.97) 150.72,112.97 150.34,112.59 150.34,112.13 149.93,111.73 149.42,111.73 148.61,110.91 146.75,110.91 145.03,109.19 145.03,108.11 144.6,107.68 144.6,104.38 145,103.98 147.72,103.98 148.2,103.5 148.2,102.86 148.61,102.45 149.04,102.45 150.67,100.83 151.16,100.83 158.27,93.72 170.51,93.72 174.33,89.9 194.44,89.9 195.07,89.27 198.8,89.27 200.35,90.82 221.58,90.82 222.78,89.62 248.38,89.62 248.47,89.71 248.47,89.97 248.67,90.17 249.11,90.17 249.3,89.97 249.3,89.71 249.39,89.62 249.68,89.62 249.77,89.71 249.77,89.97 249.96,90.17 250.4,90.17 250.59,89.97 250.59,89.71 250.68,89.62 250.98,89.62 251.06,89.71 251.06,89.97 251.26,90.17 251.7,90.17 251.89,89.97 251.89,89.71 251.98,89.62 252.27,89.62 252.36,89.71 252.36,89.97 252.55,90.17 252.99,90.17 253.18,89.97 253.18,89.71 253.27,89.62 253.57,89.62 253.65,89.71 253.65,89.97 253.85,90.17 254.29,90.17 254.48,89.97 254.48,89.71 254.57,89.62 254.86,89.62 254.95,89.71 254.95,89.97 255.14,90.17 275.35,90.17 281.1,84.42 281.3,84.42 283.6,82.12 283.6,81.87 283.92,81.54 288.42,81.54 289.08,80.89 293.15,80.89 294.21,79.83 294.81,79.83 295.16,79.48 295.16,79.1 297.33,76.93 301.34,76.93 302.15,76.12 302.94,76.12 303.02,76.04 304.13,76.04 304.56,75.61 305.41,75.61 305.97,76.17 307.57,76.17 308.13,75.61 309.58,75.61 309.84,75.35 316.43,75.35 318.15,73.63 321.38,73.63 322.24,72.76 322.24,72.25 322.96,71.54 324.17,71.54 324.51,71.21 324.51,70.19 325.47,69.23 327.91,69.23 329.81,67.33 330.55,67.33 331.36,66.51 331.36,62.55 328.42,59.61 328.42,58.27 328.95,57.73 328.95,56.4 328.72,56.18 328.72,55.94 328.82,55.85 v1(329.03,55.85)
GPU_TBT_D2#: length 237.4
  TOP w0.14: v1(328.37,55.8) 328.79,55.37 330.06,55.37 C94552.1 ; U13114.BM11 150.26,113.04 v2(150.16,112.95)
  IN4 w0.089: v2(150.16,112.95) 150.16,112.21 149.86,111.9 149.35,111.9 148.54,111.09 146.68,111.09 144.85,109.26 144.85,108.18 144.43,107.76 144.43,104.31 144.93,103.8 147.65,103.8 148.03,103.42 148.03,102.79 148.54,102.28 148.97,102.28 150.59,100.65 151.08,100.65 158.2,93.54 170.44,93.54 174.26,89.72 194.36,89.72 194.99,89.09 198.88,89.09 200.43,90.64 221.51,90.64 222.71,89.44 248.46,89.44 248.65,89.64 248.65,89.9 248.74,89.99 249.03,89.99 249.12,89.9 249.12,89.64 249.31,89.44 249.75,89.44 249.95,89.64 249.95,89.9 250.04,89.99 250.33,89.99 250.42,89.9 250.42,89.64 250.61,89.44 251.05,89.44 251.24,89.64 251.24,89.9 251.33,89.99 251.62,89.99 251.71,89.9 251.71,89.64 251.9,89.44 252.34,89.44 252.54,89.64 252.54,89.9 252.63,89.99 252.92,89.99 253.01,89.9 253.01,89.64 253.2,89.44 253.64,89.44 253.83,89.64 253.83,89.9 253.92,89.99 254.21,89.99 254.3,89.9 254.3,89.64 254.5,89.44 254.93,89.44 255.13,89.64 255.13,89.9 255.22,89.99 275.28,89.99 281.03,84.24 281.22,84.24 283.42,82.04 283.42,81.79 283.85,81.37 288.35,81.37 289,80.71 293.08,80.71 294.14,79.65 294.73,79.65 294.98,79.41 294.98,79.03 297.25,76.75 301.26,76.75 302.08,75.94 302.87,75.94 302.94,75.86 304.06,75.86 304.49,75.43 305.48,75.43 306.04,75.99 307.5,75.99 308.06,75.43 309.51,75.43 309.76,75.18 316.35,75.18 318.08,73.45 321.31,73.45 322.07,72.69 322.07,72.18 322.88,71.37 324.1,71.37 324.33,71.14 324.33,70.12 325.39,69.05 327.84,69.05 329.74,67.15 330.48,67.15 331.19,66.44 331.19,62.63 328.24,59.68 328.24,58.19 328.77,57.66 328.77,56.48 328.55,56.25 328.55,55.97 v1(328.37,55.8)
GPU_TBT_D3: length 234.1
  TOP w0.14: C94549.1 328.44,54.7 v1(328.34,54.8) ; v2(149.89,114.58) 149.89,114.23 149.98,114.14 150.18,114.14 U13114.BL11
  IN4 w0.089: v1(328.34,54.8) 328.34,54.68 328.14,54.47 327.58,54.47 326.97,55.08 326.97,60.16 327.15,60.34 327.15,66.79 326.66,67.28 323.74,67.28 323.36,67.66 323.36,68.16 321.18,70.35 320.41,70.35 320.34,70.42 320.34,71.39 319.75,71.97 319.3,71.97 318.61,71.29 314.27,71.29 313,72.56 313,73.34 312.28,74.06 309.83,74.06 309.78,74.01 307.79,74.01 307.13,73.35 306.81,73.35 306.34,73.81 297.6,73.81 294.08,77.33 292.19,77.33 290.68,78.83 288.92,78.83 288.57,79.18 284.44,79.18 282.21,81.41 282.21,81.68 281.09,82.79 280.74,82.79 275.21,88.33 220.88,88.33 220.06,89.15 207.19,89.15 206.7,88.66 200.86,88.66 200.17,87.98 192.77,87.98 192.43,88.33 173.87,88.33 169.78,92.42 157.21,92.42 150.55,99.08 149.96,99.08 148.86,100.17 148.1,100.17 147.59,100.68 145.18,100.68 143.28,102.58 143.28,103.42 143.02,103.67 143.02,108 142.86,108.17 142.86,109.33 145.61,112.08 145.61,112.57 146.3,113.25 147.29,113.25 149.07,115.03 149.52,115.03 149.59,114.95 149.59,114.88 v2(149.89,114.58)
GPU_TBT_D3#: length 234
  TOP w0.14: v2(149.85,115.21) 150.15,114.91 U13114.BK11 ; C94550.1 328.65,54.14 v1(328.34,54.14)
  IN4 w0.089: v1(328.34,54.14) 328.19,54.3 327.5,54.3 326.79,55.01 326.79,60.29 326.97,60.47 326.97,66.72 326.59,67.1 323.67,67.1 323.18,67.58 323.18,68.09 321.1,70.17 320.34,70.17 320.16,70.35 320.16,71.31 319.68,71.8 319.37,71.8 318.69,71.11 314.2,71.11 312.82,72.49 312.82,73.26 312.2,73.88 309.9,73.88 309.85,73.83 307.87,73.83 307.21,73.17 306.73,73.17 306.27,73.64 297.52,73.64 294.01,77.15 292.11,77.15 290.61,78.66 288.84,78.66 288.5,79 284.36,79 282.03,81.33 282.03,81.6 281.02,82.61 280.67,82.61 275.13,88.15 220.8,88.15 219.98,88.97 207.26,88.97 206.78,88.48 200.93,88.48 200.25,87.8 192.7,87.8 192.35,88.15 173.8,88.15 169.7,92.24 157.13,92.24 150.48,98.9 149.88,98.9 148.79,99.99 148.03,99.99 147.52,100.5 145.11,100.5 143.1,102.51 143.1,103.35 142.84,103.6 142.84,107.93 142.68,108.1 142.68,109.4 145.44,112.16 145.44,112.64 146.22,113.43 147.22,113.43 148.99,115.21 v2(149.85,115.21)
GPU_THROTTING#: length 132.5
  TOP w0.14: v1(67.18,56.1) 67.58,55.7 PR67219.2 ; R67308.2 127.78,113 128.11,112.67 128.25,112.67 128.26,112.67 R67380.2 128.79,112.57 128.79,112.23 D13095.1 131.32,111.13 v1(131.39,111.07)
  IN2 w0.089: v1(131.39,111.07) 130.91,110.58 130.91,105.35 130.51,104.95 130.51,88.9 128.57,86.96 128.57,84.14 127.76,83.33 127.76,78.38 133.45,72.69 133.45,69.26 v1(134.36,68.34)
  IN3 w0.079: v1(67.18,56.1) 67.26,56.01 68.6,56.01 69.58,55.03 69.58,54.19 70.11,53.66 73.17,53.66 74.04,52.79 85.84,52.79 87.78,54.73 99.86,54.73 101.48,56.34 101.48,59.59 102.84,60.96 106.59,60.96 107.36,60.18 124.18,60.18 126.72,62.73 129.69,62.73 132.2,65.24 132.2,66.87 133.67,68.34 v1(134.36,68.34)
GPUEVENT#: length 14.4
  TOP w0.14: U13114.BD1 142.69,119.11 140.99,117.41 139.93,117.41 139.9,117.44 R21588.2 139.31,117.16 139.05,116.9 137.72,116.9 137.54,117.09 137.54,117.59 137.13,118 v1(135.68,118) 135.43,118 134.77,118.66 134.77,121.12 135.02,121.38 D8589.2
GPUEVENT#_PCH: length 233.5
  TOP w0.14: D8589.1 132.74,120.77 v1(132.74,120.49) ; U13113.AR29 308.3,66.26 v2(308.07,66.03)
  IN1 w0.14: v1(205.53,75.12) 205.27,75.38 205.27,77.4 205.73,77.86 205.73,78.11 198.62,85.22 198.62,88.64 199.51,89.53 199.51,92.56 198.45,93.62 157.2,93.62 151.49,99.32 151.25,99.32 150.56,98.62 146.73,98.62 146.58,98.47 141.38,98.47 140.72,99.13 138.08,99.13 137.92,98.98 134.56,98.98 133.91,99.63 129.78,99.63 128.47,100.94 128.47,111.21 128.8,111.54 128.8,113.05 128.47,113.38 128.47,114.57 132.02,118.13 132.02,119.78 v1(132.74,120.49)
  IN3 w0.079: v2(308.07,66.03) 307.13,66.98 300.75,66.98 299.36,68.36 298.22,68.36 297.51,67.66 296.18,67.66 295.17,68.67 293.75,68.67 291.16,71.26 285.2,71.26 281.39,75.06 281.39,76.34 275.7,82.04 213.21,82.04 208.83,77.66 208.83,76.9 207.06,75.12 v1(205.53,75.12)
GPUT_CLK: length 56.4
  BOTTOM w0.14: Q7858.6 147.47,98.52 147.73,98.26 149.41,98.26 150.42,97.25 151.91,97.25 153.99,95.17 162.99,95.17 166.3,91.85 167.95,91.85 172.64,87.16 172.64,77.97 176.18,74.43 179.2,74.43 v1(179.85,73.78) 182.07,71.56 185.67,71.56 186.3,70.93 R22061.2
GPUT_DATA: length 54.8
  BOTTOM w0.14: Q7860.3 149.89,98.52 150.62,97.78 152.24,97.78 154.21,95.81 163.1,95.81 166.54,92.37 168.22,92.37 173.16,87.43 173.16,78.19 176.4,74.95 179.47,74.95 182.34,72.08 v1(182.82,72.08) 185.89,72.08 187.27,70.7 R22062.2
GSPI0_MOSI: length 11.6
  TOP w0.102: v1(315.39,66.01) 314.96,66.43 313.88,66.43 313.7,66.25 312.96,66.25 U13113.BD28
  TOP w0.14: v1(321.41,65.24) R21327.2
  IN3 w0.079: v1(315.39,66.01) 317.93,63.47 319.43,63.47 320.7,64.74 320.9,64.74 v1(321.41,65.24)
GSPI1_MOSI: length 13.2
  TOP w0.14: U13113.AT29 309.06,66.94 v2(308.91,67.09)
  BOTTOM w0.14: R21328.2 319.56,69.18 319.02,69.18 318.92,69.08 318.21,69.08 318.16,69.13 316.35,69.13 316.03,68.81 316.03,68.34 315.73,68.04 315.23,68.04 314.82,67.63 v1(312.62,67.63) 310,67.63 309.9,67.53 309.34,67.53 v2(308.91,67.09)
GT_PWM4: length 0.5
  TOP w0.14: PR66949.1 PR66835.2
GT_PWM5: length 0.5
  TOP w0.14: PR66952.1 PR66836.2
H_CPU_SVIDALRT#: length 17
  TOP w0.14: R545.1 271.47,129.76 v1(271.37,129.86) 271.34,129.89 v1(270.66,129.89) ; U41.BH31 261,126.48 v1(261.32,126.81)
  IN1 w0.089: v1(270.66,129.89) 270.45,130.09 268.08,130.09 267.33,130.84 266.03,130.84 265.55,130.36 262.3,130.36 261.82,130.84 260.94,130.84 260.54,130.44 260.54,127.59 v1(261.32,126.81)
H_CPU_SVIDDAT: length 25
  TOP w0.14: U41.BH29 260.81,124.57 v1(260.76,124.52) ; R544.2 271.29,126.2 271.28,126.2 R543.1 270.83,126.71 v1(270.48,126.36)
  IN1 w0.089: v1(260.76,124.52) 260.15,125.13 260.15,130.71 260.68,131.23 262.15,131.23 262.63,130.75 265.39,130.75 265.87,131.23 267.84,131.23 268.55,130.52 270.65,130.52 271.27,129.91 271.27,128.59 270.86,128.19 270.86,127.68 270.48,127.3 v1(270.48,126.36)
H_PM_DOWN: length 128.8
  TOP w0.102: v1(305.26,51.38) 305.26,51.63 305.55,51.93 305.55,52.36 305.31,52.59 305.31,53 U13113.AH2
  TOP w0.14: v1(271.52,131.26) 271.77,131.01 R559.1
  IN1 w0.089: v1(271.52,131.26) 271.52,130.88 272.25,130.15 272.25,128.31 271.73,127.78 271.73,127.13 271.34,126.75 271.34,125.49 270.15,124.3 266.65,124.3 265.72,123.37 265.72,116.3 270.04,111.98 270.04,111.76 272.05,109.75 272.05,109 273.78,107.28 273.78,106.37 274.38,105.77 274.38,102.99 276.02,101.35 276.02,98.23 278.44,95.81 278.44,81.24 281.62,78.06 281.62,73.74 284.12,71.24 284.12,68.29 284.75,67.66 298.09,67.66 298.6,68.16 299.6,68.16 301.34,66.43 302.63,66.43 303.21,65.85 303.21,63.43 305.84,60.8 305.84,59.97 306.07,59.74 306.73,59.74 307.6,58.87 307.6,58.54 308.23,57.9 308.23,57.64 309.37,56.51 310.03,56.51 310.18,56.35 310.92,56.35 311.04,56.48 312.57,56.48 313.28,55.77 313.28,54.14 312.4,53.27 308.59,53.27 308.34,53.01 308.34,50.62 307.8,50.08 306.88,50.08 305.58,51.38 v1(305.26,51.38)
H_PM_DOWN_R: length 9.2
  TOP w0.14: U41.BP31 265,127.02 265.5,127.02 265.58,126.94 266.05,126.94 266.15,126.84 266.62,126.84 267.02,127.25 267.02,127.65 268.63,129.25 268.63,129.89 268.75,130.01 270.12,130.01 270.76,130.65 R559.2
H_PROCHOT#: length 343.7
  TOP w0.079: PR67236.2 65.76,50.9 65.92,50.74 67.13,50.74 67.18,50.79 ; 67.63,51.71 v1(67.63,52.06)
  TOP w0.102: 67.63,51.71 67.63,51.25 67.18,50.79
  TOP w0.14: C96031.1 C807.2 269.82,127.55 270.07,127.8 v1(270.38,127.8) 271.44,127.8 R566.1 271.49,127.52 271.26,127.29 R22148.1 ; v1(171.5,64.84) 172.23,64.1 Q32.3 ; PR66938.2 265.89,169.93 265.51,169.93 265.27,170.18 v1(265.07,170.18)
  TOP w0.203: PR66937.1 265.83,169.58 PR66938.2
  IN2 w0.089: v1(205.71,96.03) 205.93,95.81 205.93,92.18 207.13,90.98 207.13,80.66 203.84,77.37 203.84,73.22 205.42,71.64 205.42,68.52 204.56,67.67 201.73,67.67 200.53,68.88 198.65,68.88 197.83,68.06 190.65,68.06 190.52,68.18 190.52,68.55 190.19,68.88 188.82,68.88 188.42,68.48 182.33,68.48 181.93,68.88 180.36,68.88 179.58,68.09 178.95,68.09 178.2,67.34 178.2,66.92 177.05,65.76 175.49,65.76 174.24,64.51 172.3,64.51 171.98,64.84 v1(171.5,64.84) 171.5,64.17 170.74,63.41 169.9,63.41 168.04,61.55 158.83,61.55 157.87,60.6 152.12,60.6 151.71,60.19 150.98,60.19 149.46,61.71 148.33,61.71 147.72,62.32 144.67,62.32 144.03,62.96 142.19,62.96 142.11,62.89 139.71,62.89 139.1,63.5 137.29,63.5 135.71,61.92 129.26,61.92 124.13,56.79 118.72,56.79 118.35,56.42 115.79,56.42 115.42,56.79 108.03,56.79 106.72,55.48 100.55,55.48 99.83,54.77 95.72,54.77 93.18,52.23 84.88,52.23 82.71,50.06 77.93,50.06 77.54,49.67 73.08,49.67 72.65,50.11 70.53,50.11 68.58,52.06 v1(67.63,52.06)
  IN3 w0.079: v1(205.71,96.03) 205.73,96.05 205.73,99.1 206.57,99.93 207.3,99.93 207.54,99.69 265.07,99.69 267.71,102.33 268.47,102.33 269.16,103.02 269.16,104.74 268.93,104.97 268.93,109.9 269.14,110.11 269.14,112.25 267,114.39 265.28,116.11 265.28,123.6 268.29,126.61 269.19,126.61 v1(270.38,127.8) 270.61,127.8 272.17,129.37 272.17,130.94 272.64,131.41 272.64,132.58 273.59,133.53 273.59,139.4 272.69,140.3 272.69,145.13 273.49,145.93 273.49,166.93 271.67,168.75 265.94,168.75 265.07,169.62 v1(265.07,170.18)
H_PROCHOT#_CPU: length 5.8
  TOP w0.14: R22148.2 269.79,126.43 269.69,126.43 269.39,126.13 267.56,126.13 266.8,125.37 266.2,125.37 266.12,125.44 265.61,125.44 U41.BR30
H_PROCHOT#_R: length 8.9
  TOP w0.14: PR67235.2 65.84,58.53 66.14,58.23 66.14,57.99 PQ9088.2 67.37,57.48 68.91,55.94 PR67240.2 68.73,54.95 v1(67.93,54.95) 67.72,54.74 PQ9087.2
  BOTTOM w0.14: v1(67.93,54.95) PU1.10
HDMI_HPD: length 3.6
  TOP w0.14: ESD7.9 ESD7.2 229.63,171.35 229,171.98 CN2044.19
  vias: v1(229.71,171.67)
HDMI_HPD_PCH: length 388.7
  TOP w0.14: v1(197.53,45.89) 197.53,47.08 199.31,48.86 199.31,51.05 200.38,52.11 202.61,52.11 204.87,54.37 v1(204.87,55.21) ; Q7931.3 323.74,52.63 v1(323.28,52.16) 322.97,52.16 322.9,52.23 R67232.2
  IN1 w0.089: v1(130.2,113.91) 130.2,112.1 128.82,110.73 128.82,105.17 130.75,103.24 130.75,103.17 133.5,100.42 134.51,100.42 135.02,99.91 135.78,99.91 136.23,99.46 142.05,99.46 142.24,99.66 145.71,99.66 145.96,99.41 147.47,99.41 147.76,99.11 150.35,99.11 151.05,99.81 151.7,99.81 157.4,94.11 198.74,94.11 v1(199.16,93.69)
  IN4 w0.089: v1(289.99,47.62) 289.11,47.62 287.46,49.27 270.61,49.27 269.84,48.51 265.41,48.51 264.41,47.51 247.72,47.51 246.98,48.24 230.61,48.24 230.25,47.87 203.55,47.87 203.07,48.35 198.95,48.35 197.53,46.93 v1(197.53,45.89)
  IN5 w0.089: v1(204.87,55.21) 205.25,55.21 206.14,56.1 206.14,63.97 203.58,66.54 203.58,70.54 204.59,71.55 204.59,77.94 206.6,79.95 206.6,89.93 206.14,90.39 202.46,90.39 v1(199.16,93.69) 199.16,94.15 203.61,98.61 203.61,108.61 210.16,115.16 210.16,128.24 211.73,129.81 211.73,160.64 213.88,162.79 213.88,165.33 216.84,168.29 229.31,168.29 v1(230.5,167.1)
  BOTTOM w0.14: v1(230.5,167.1) 231.92,168.52 R22126.1 ; v1(323.28,52.16) 323.1,52.34 321.66,52.34 321.56,52.24 321.56,52.24 321.29,51.97 321.29,51.97 321.1,51.78 321.1,49.14 322.54,47.71 322.54,46.31 321.79,45.56 318.21,45.56 317.7,46.07 309.93,46.07 309.72,46.27 304.4,46.27 303.83,46.84 290.77,46.84 v1(289.99,47.62) ; v1(130.2,113.91) C95080.2 R21565.2
HDMI_HPD_PCH_R: length 16.5
  TOP w0.14: v2(309.48,54.96) 309.83,54.6 U13113.AV4 ; R67233.1 322.72,56.24 322.73,56.23 322.73,55.36 322.22,55.36 v1(321.76,55.82) 321.65,55.71 v1(317.77,55.71)
  IN2 w0.089: v2(309.48,54.96) 311.02,56.51 313.94,56.51 314.73,55.71 v1(317.77,55.71)
HDMI_SCLK: length 7.7
  TOP w0.102: CN2044.15 227.22,172.55 227.22,172.06 228.24,171.04 228.24,170.94 228.13,170.83 ESD7.5 ESD7.6 228.13,169.15 228.24,169.04 228.24,168.76 R21010.1 227.6,168.25 v1(227.17,168.67)
  BOTTOM w0.102: Q34.3 227.55,167.89 v1(227.17,167.89) v1(227.17,168.67)
HDMI_SDATA: length 9.1
  TOP w0.081: 227.5,173.13 227.5,172.43
  TOP w0.102: v1(229.56,168.7) 229.11,168.25 R21011.1 228.52,168.73 228.52,168.95 228.63,169.06 ESD7.7 ESD7.4 228.63,170.83 228.52,170.94 228.52,171.16 227.5,172.18 227.5,172.43 227.5,172.43 ; 227.5,173.13 227.5,173.4 227.5,173.4 227.5,173.6 227.5,173.6 227.5,174.27 CN2044.16
  BOTTOM w0.102: v1(229.56,168.7) 229.66,168.8 229.66,169.38 v1(229.64,169.41) 229.49,169.55 Q34.6
HOLD#_7: length 5.7
  TOP w0.14: R21552.2 126.31,103.44 126.54,103.22 128.04,103.22 128.62,103.8 U13116.7 v1(128.62,106.39)
HP-L2: length 32.5
  TOP w0.203: 25.61,32.94 25.9,32.94 25.97,32.86 U13108.27
  TOP w0.254: R67204.1 17.72,13.31 18.48,12.56 C95983.1 18.51,11.99 v1(18.29,11.77) ; v1(24.28,34) 24.28,33.92 24.81,33.39 25.06,33.39 25.52,32.94 25.61,32.94
  IN2 w0.254: v1(18.29,11.77) 18.29,12.34 17.99,12.63 17.99,15.73 18.03,15.76 18.03,17.82 20.99,20.79 21.95,20.79 22.39,21.23 22.39,25.17 24.67,27.45 24.67,28.5 26.06,29.89 26.06,32.38 25.12,33.32 24.58,33.32 24.28,33.62 v1(24.28,34)
HP-L3: length 1.8
  TOP w0.254: R67018.2 18.46,14.28 18.61,14.13 v1(18.86,14.13) 18.86,13.68 C95983.2
HP-L4: length 4.5
  TOP w0.203: R67018.1 18.05,15.34 18.33,15.61 v1(18.54,15.61) 18.83,15.9 U13150.1
  BOTTOM w0.14: v1(17.84,14.6) 17.84,14.91 v1(18.54,15.61)
  BOTTOM w0.203: v1(18.54,15.61) 17.93,16.22 R67260.1
HP-L5: length 16.9
  TOP w0.254: v1(16.38,15.59) 16.4,15.61 C94942.1 15.64,16.34 15.48,16.18 D8569.1 R21447.2 14.47,15.09 v1(14.24,15.32) 13.82,15.32 CN2058.1
  BOTTOM w0.203: U13156.1 18.75,11.51 18.37,11.13 17.76,11.13 17.09,10.46 15.92,10.46 14.68,11.7 14.68,13.45 16.38,15.16 v1(16.38,15.59)
HP-R2: length 30.8
  TOP w0.203: U13108.26 26.03,33.26 25.96,33.33 25.64,33.33 25.55,33.41
  TOP w0.254: v1(20.16,13.66) 20.16,12.94 19.63,12.4 C95986.1 19.58,11.95 18.57,10.95 R67205.1 ; v1(24.96,34) 25.55,33.41
  IN2 w0.254: v1(20.16,13.66) 20.16,13.89 20.42,14.14 20.42,16.96 20.19,17.19 20.19,18.61 21.47,19.89 22.13,19.89 23.15,20.92 23.15,24.85 26.18,27.88 26.18,28.92 26.82,29.56 26.82,32.81 25.55,34.08 25.04,34.08 v1(24.96,34)
HP-R3: length 2.2
  TOP w0.254: C95986.2 19.58,13.73 19.6,13.76 19.6,14.18 R67019.2 20.52,14.18 v1(20.74,13.96)
HP-R4: length 6.5
  TOP w0.203: v1(18.94,14.96) R67019.1 20.24,14.96 20.51,15.23 v1(20.52,15.23) 20.52,15.69 20.33,15.88 U13150.4
  BOTTOM w0.203: R67261.1 21.06,16.16 21.06,15.64 20.39,14.96 v1(18.94,14.96)
HP-R5: length 21.5
  TOP w0.254: CN2058.2 6.34,9.74 12.85,9.74 13.27,10.17 v1(14.23,10.17) D8571.1 15.26,10.17 R22159.2 15.56,11.26 15.8,11.01 15.8,10.53 C94943.1 16.38,10.31 v1(16.38,10.99)
  BOTTOM w0.203: v1(16.38,10.99) 15.35,12.02 15.35,12.74 15.73,13.12 16.48,13.12 16.73,12.87 18.61,12.87 18.98,12.51 U13156.3
HP_AMP_EN: length 226.8
  IN5 w0.089: v1(181.07,63.67) 180.49,63.08 180.11,63.08 178.59,61.57 176.31,61.57 175.99,61.25 175.99,59.54 175.12,58.68 175.12,58.59 171.8,55.27 169.91,55.27 168.73,54.09 156.18,54.09 154.78,55.5 148.26,55.5 147.54,54.78 141.76,54.78 140.99,55.55 140.84,55.55 126.96,55.55 126.37,56.14 118.46,56.14 117.75,55.44 112.27,55.44 111.08,54.25 100.98,54.25 100.34,53.61 93.39,53.61 91.64,51.86 85.62,51.86 83.19,49.43 74,49.43 72.84,50.59 70.82,50.59 67.06,54.35 66.6,54.35 65.95,54.99 65.95,59.27 63.21,62.01 61.66,62.01 61.18,62.49 61.18,65.9 59.59,67.49 56.92,67.49 56.64,67.21 55.69,67.21 49.81,61.33 35.54,61.33 35.07,61.79 32.86,61.79 32.33,61.26 32.33,56.23 28.04,51.93 25.98,51.93 25.12,51.07 24.38,51.07 23.87,50.56 23.05,50.56 22.31,49.83 22.31,47.04 22.47,46.88 22.47,43.44 22.17,43.13 22.17,38.42 22.47,38.12 22.47,35.27 21.54,34.34 16.46,34.34 v1(16.43,34.31)
  BOTTOM w0.14: v1(16.43,34.31) 16.83,33.9 R67338.1 16.8,33.62 15.62,33.62 14.83,32.83 v1(14.27,32.83) 10.69,32.83 10.08,32.22 10.08,31.13 10.69,30.52 14.12,30.52 14.41,30.23 D13089.1 ; R67038.2 181.09,63.69 v1(181.07,63.67)
HP_EN: length 2.4
  BOTTOM w0.14: D13090.1 v1(16.95,23.04)
  BOTTOM w0.254: R67336.1 16.06,24.57 D13090.1
HP_EN_QQ: length 12.5
  TOP w0.254: v1(17.11,19.4) 17.11,19.07 17.3,18.88 U13150.13
  BOTTOM w0.254: D13089.2 14.41,27.53 14.28,27.4 14.28,26.95 14.04,26.71 14.04,22.11 14.38,21.78 R67337.1 15.16,21.34 D13090.2 16.06,20.83 16.25,20.65 R67328.2 16.53,20.16 17.11,19.57 v1(17.11,19.4)
HP_JD#_EC: length 228.1
  TOP w0.14: U49.80 194.89,59.2 v1(195.32,59.63)
  TOP w0.254: v1(18.84,9.87) 18.84,10.11 18.58,10.38 17.43,10.38 17.22,10.17 R67310.2 17.22,9.17 16.18,8.13 R67368.1
  IN2 w0.381: v1(40.33,34.08) 40.13,33.87 40.13,32.73 39.77,32.38 37.84,32.38 37.23,31.77 37.23,27.88 v1(35.57,26.22)
  IN3 w0.381: v1(40.33,34.08) 41.73,34.08 42.82,35.17 42.82,38.45 43.61,39.23 43.61,40.2 41.92,41.89 41.92,47.37 45.77,51.22 48.76,51.22 51.12,53.58 58.49,53.58 61.69,50.38 62.5,50.38 63.96,48.93 66.67,48.93 68.32,47.29 74.57,47.29 75.05,46.8 78.96,46.8 79.22,46.55 87.88,46.55 88.49,47.16 89.61,47.16 93.59,51.15 128.24,51.15 128.72,51.63 168.37,51.63 v1(170.3,53.56)
  IN4 w0.381: v1(195.32,59.63) 194.56,59.63 193.8,60.39 190.52,60.39 189.76,59.63 186.51,59.63 186,59.12 182.65,59.12 182.06,58.54 179.04,58.54 176.55,56.05 175.19,56.05 174.86,55.72 174.49,55.72 174.06,55.29 172.1,55.29 170.37,53.56 v1(170.3,53.56)
  IN5 w0.381: v1(18.84,9.87) 19.4,9.87 19.96,9.31 23.72,9.31 24.47,10.07 24.47,14 24.94,14.47 24.94,16.77 26.19,18.02 26.19,19.34 29.54,22.7 33.37,22.7 33.73,23.05 33.73,23.66 33.45,23.94 33.45,24.48 33.83,24.86 34.21,24.86 v1(35.57,26.22)
HP_JD#_EC_CODEC: length 174
  TOP w0.14: v1(41.5,31.69) 41.02,31.21 R67285.2 40.46,31.03 39.59,30.17 39.59,29.61 39.8,29.4 40.08,29.4 40.3,29.18 40.3,29.11 41.02,28.4 Q7937.2
  IN3 w0.079: v1(180.92,57.6) 180.51,57.19 178.05,57.19 175.28,54.42 172.13,54.42 171.75,54.03 171.75,52.68 168.44,49.37 98.34,49.37 97.66,48.69 93.14,48.69 90.12,45.67 89.24,45.67 88.3,44.73 79.57,44.73 78.94,44.09 76.94,44.09 76.51,44.52 73.72,44.52 73.22,45.02 67.73,45.02 66.46,46.29 65.73,46.29 64.59,45.15 61.89,45.15 61.32,45.72 61.32,47.09 60.41,47.99 60.15,47.99 59.38,48.76 57.98,48.76 56.06,50.68 51.64,50.68 50.66,49.7 48.87,49.7 48.47,50.1 46.19,50.1 42.67,46.57 42.67,42.18 44.5,40.35 44.5,35.17 41.5,32.17 v1(41.5,31.69)
  BOTTOM w0.14: R67264.2 181.01,57.69 v1(180.92,57.6)
HP_JD#_EC_R: length 10.7
  TOP w0.254: R67368.2 15.31,7.35 15.18,7.48 15.18,7.81 14.91,8.09 D8570.1 13.81,8.09 v1(13.79,8.07)
  BOTTOM w0.381: CN2058.6 11.27,8.25 11.53,7.99 13.71,7.99 v1(13.79,8.07) 13.81,8.09 R67262.1 16.01,8.64 16.74,9.36 R67263.1
HPOUT_L2: length 14.4
  TOP w0.254: U13151.12 18.58,25.57 v1(18.77,25.38) ; U13150.16 17.66,17.38 17.18,16.9 17.18,16.1 v1(17.19,16.09) 17.19,15.97 16.88,15.67 16.88,14.99 R67206.2
  IN1 w0.254: v1(18.77,25.38) 18.77,21.91 17.58,20.73 17.58,16.49 v1(17.19,16.09)
HPOUT_R2: length 21.2
  TOP w0.254: U13150.5 21.38,17.17 v1(21.38,16.7) ; R67207.2 17.43,11.65 v1(17.42,11.64) ; v1(18.08,25.57) U13151.11
  IN1 w0.254: v1(18.08,25.57) 18.08,26 18.26,26.18 18.94,26.18 19.53,25.59 19.53,21.76 20.37,20.92 20.37,17.21 20.77,16.81 21.28,16.81 v1(21.38,16.7) 21.23,16.55 21.23,15.52 17.42,11.72 v1(17.42,11.64)
HRESET: length 262.8
  TOP w0.14: U13155.D6 367.56,26.99 v1(367.15,26.59)
  IN1 w0.089: v1(367.15,26.59) 366.76,26.98 365.94,26.98 364.62,28.3 364.62,33.14 362.25,35.52 362.25,38.1 361.58,38.77 361.58,39.39 360.12,40.86 359.49,40.86 358.91,41.44 358.91,44.68 357.12,46.47 356.03,46.47 355.7,46.15 355.14,46.15 354.1,47.2 354.1,47.3 352.85,48.54 349.91,48.54 349.84,48.61 346.75,48.61 345.86,49.51 339.29,49.51 336.63,52.17 335.49,52.17 334.3,53.36 333.65,53.36 333.32,53.69 333.32,59.93 331.36,61.89 331.36,63.18 332.6,64.42 333.11,64.42 335.03,66.33 335.2,66.33 335.81,66.94 336.23,67.37 336.23,68.1 335.66,68.67 333.34,68.67 333.08,68.93 331.5,68.93 330.41,70.03 330.23,70.2 330.06,70.37 328.23,70.37 328.08,70.52 328.08,70.52 327.75,70.85 327.75,72.09 325.27,74.57 322.35,74.57 321.25,73.47 319.48,73.47 318.95,72.94 318.4,72.94 317.85,72.39 315.11,72.39 313.61,73.89 307.78,73.89 307.54,73.65 v2(307.54,69.1)
  IN3 w0.079: v1(184.7,62.25) 184.7,64.53 185.2,65.02 185.2,66.04 185.81,66.65 191.65,66.65 192.86,65.45 192.86,65.45 193.26,65.04 194.55,65.04 197.52,68.01 200.25,68.01 200.65,68.42 200.65,68.7 204.6,72.65 204.6,74.83 204.8,75.02 204.8,75.79 205.48,76.47 206.14,76.47 206.24,76.37 206.65,76.37 212.95,82.67 275.96,82.67 282.02,76.6 282.02,75.54 285.52,72.04 292.18,72.04 292.49,72.36 294.61,72.36 295.24,71.72 295.24,71.04 295.55,70.73 297.56,70.73 298.01,70.27 299.18,70.27 300.23,69.22 302.03,69.22 302.15,69.1 303.68,69.1 304.77,70.2 306.45,70.2 v2(307.54,69.1)
  BOTTOM w0.14: R67164.2 182.09,57.28 182.09,57.83 182.39,58.13 184.26,58.13 184.64,58.51 184.64,62.18 v1(184.7,62.25) ; R67163.1 307.66,69.23 v2(307.54,69.1) ; R67136.1 366.42,26.13 366.87,26.59 v1(367.15,26.59)
HWPG: length 177.5
  TOP w0.14: U49.21 179.49,57.6 v1(179.55,57.66)
  IN2 w0.089: v1(176.37,65.37) 177.42,65.37 179.29,67.24 181.51,67.24 182.32,68.06 190.09,68.06 190.48,67.66 198.63,67.66 198.9,67.94 200.15,67.94 200.43,67.66 200.43,67.28 200.93,66.77 204.22,66.77 205.81,68.36 205.81,71.81 204.24,73.38 204.24,76.29 207.52,79.58 207.52,92.25 v1(208.45,93.18)
  IN3 w0.079: v1(208.45,93.18) 208.98,93.18 209.96,92.2 263.86,92.2 272.92,101.26 274.14,101.26 279.35,96.05 279.35,91.63 283.56,87.41 283.71,87.41 284.47,86.65 284.47,86.51 286.12,84.85 289.66,84.85 v1(289.96,84.55)
  IN5 w0.089: v1(208.45,93.18) 207.59,94.05 v1(207.59,97.37)
  BOTTOM w0.14: v1(176.37,65.37) 176.12,65.62 D17.2 D18.2 D13.2 D11.2 D15.2 175.37,59.4 175.08,59.11 175.08,58.33 175.53,57.88 177.61,57.88 177.72,57.98 178.46,57.98 178.6,57.84 R813.1 179.47,57.57 v1(179.55,57.66) ; v1(289.96,84.55) 290.85,85.44 R67199.2 ; R202.2 206.58,98.38 v1(207.59,97.37)
HWPG_1.8VS5: length 109.2
  TOP w0.203: PR97.2 89.44,83.13 v1(89.95,83.64) 90.25,83.94 PR102.2
  IN1 w0.089: v1(89.95,83.64) 90.19,83.4 90.19,80.56 92.68,78.07 97.81,78.07 101.44,74.44 101.44,67.45 102.48,66.41 102.48,65.27 103.21,64.55 103.21,62.97 106.32,59.86 112.44,59.86 112.98,60.39 115.26,60.39 117.06,62.2 119.27,62.2 120.64,60.82 123.34,60.82 124.41,59.75 127.06,59.75 128.05,58.77 132.38,58.77 133.37,59.76 135.1,59.76 135.17,59.83 151.45,59.83 152.81,61.19 156.33,61.19 158.24,63.1 165.65,63.1 166.06,63.52 170.2,63.52 v1(170.48,63.8)
  BOTTOM w0.14: v1(170.48,63.8) 170.48,63.52 173.27,60.72 173.58,60.72 173.67,60.63 D15.1
HWPG_1VS5: length 189.8
  TOP w0.14: PU9015.1 242.52,159.77 242.72,159.58 PR263.2 243.5,159.75 243.81,160.06 244.55,160.06 245.28,159.33 247.57,159.33 248.48,160.24 v1(248.48,160.6) 248.48,161.71 v1(248.43,161.76)
  IN1 w0.089: v1(171.01,64.35) 171.01,65.04 173.58,67.61 178.47,67.61 179.25,68.39 179.52,68.39 180.06,68.93 181.86,68.93 182.39,68.39 188.63,68.39 189.64,69.41 190.86,69.41 191.7,70.25 194.92,70.25 196.72,72.05 200.8,72.05 201.98,73.24 205.29,73.24 205.76,73.71 205.94,73.71 206.87,74.65 206.87,91.41 206.01,92.27 206.01,94 206.87,94.86 206.87,96.42 206.07,97.22 206.07,105.46 215.61,115 217.54,115 220.34,117.81 220.34,127.71 222.24,129.61 222.24,129.89 224.12,131.78 224.12,136.04 223.27,136.89 219.79,136.89 214.52,142.16 214.52,149.62 216.74,151.83 222.04,151.83 224.03,149.85 228.39,149.85 232.18,153.64 232.18,156.07 235.43,159.32 235.43,161.61 237.43,163.61 246.41,163.61 247.88,162.14 248.05,162.14 v1(248.43,161.76)
  BOTTOM w0.14: v1(171.01,64.35) 171.01,63.72 173.3,61.43 D11.1
HWPG_2.5V: length 41.7
  TOP w0.14: PR309.2 188.88,76.42 PR311.2 188.85,75.72 187.98,74.85 181.22,74.85 179.9,76.17 176.19,76.17 v1(175.69,75.66) 174.75,74.72 v1(174.75,74.45)
  IN5 w0.089: v1(174.75,74.45) 174.75,78.28 174.01,79.01 174.01,80.78 v1(174.33,81.1)
  BOTTOM w0.14: v1(174.75,74.45) 174.77,74.47 174.98,74.47 176.4,73.05 176.4,71.22 175.77,70.6 175.12,70.6 174.89,70.83 173.87,70.83 173.29,70.24 173.29,69.24 172.71,68.67 172.71,63.11 172.99,62.83 D13.1 ; v1(174.33,81.1) 174.1,81.1 173.72,81.49 PR67229.2
HWPG_R: length 9.8
  BOTTOM w0.14: R21166.1 R67199.1 R21171.1 292.37,86.58 292.63,86.33 293.18,86.33 Q7840.3 294.52,85.6 295.45,84.67 v1(296.36,84.67) 297.68,84.67 298.37,83.99 R21164.1
HWPG_VDDR: length 30.4
  TOP w0.203: v1(172.05,80.41) 173.68,82.03 173.68,82.72 174.24,83.28 v1(177.06,83.28)
  BOTTOM w0.14: D18.1 173.17,64.23 172.99,64.41 172.99,68.56 173.57,69.13 173.57,70.1 174.01,70.55 174.77,70.55 175.01,70.32 176.01,70.32 176.68,70.98 176.68,73.19 171.98,77.89 171.98,79.87 172.05,79.94 v1(172.05,80.41)
  BOTTOM w0.203: v1(177.06,83.28) 176.63,83.71 PR2016.2 176.63,83.88 177.1,84.35 177.1,84.39 177.37,84.66 PR2017.2
I2C0_SCL: length 216.4
  TOP w0.14: U13113.AR38 308.58,70.7 v2(308.33,70.45) ; R67277.1 120.7,63.62 120.29,63.21 120.29,62.86 v1(119.27,61.84) 118.79,61.84 v1(118.51,61.56)
  IN4 w0.089: v1(118.51,61.56) 118.54,61.59 119.69,61.59 120.3,60.98 121.1,60.98 121.31,61.18 124.91,61.18 125.24,60.86 126.79,60.86 126.96,60.69 127.92,60.69 128.02,60.59 131.38,60.59 131.67,60.88 145.9,60.88 146.57,60.21 151.68,60.21 152.28,60.81 157.79,60.81 158.87,61.89 164.69,61.89 166.97,64.18 166.97,65.44 167.46,65.92 167.46,66.3 168.86,67.71 171.68,67.71 174.43,70.45 175.18,70.45 175.99,71.27 175.99,71.45 178.16,73.62 184.37,73.62 184.88,74.13 189.43,74.13 191.16,75.86 195.63,75.86 196.82,77.05 200.55,77.05 201.32,77.82 202.42,77.82 209.28,84.67 274.22,84.67 281.03,77.86 285.98,77.86 v1(286.07,77.77) 286.08,77.77 286.5,77.34 288.47,77.34 288.59,77.46 290.47,77.46 291.72,76.21 293.62,76.21 297.22,72.61 299.61,72.61 299.74,72.48 299.74,71.47 299.99,71.21 302.03,71.21 302.28,70.96 302.79,70.96 303.3,71.47 305.33,71.47 305.58,71.72 306.48,71.72 306.62,71.57 307.4,71.57 307.61,71.37 307.61,71.16 v2(308.33,70.45)
  BOTTOM w0.14: v1(286.07,77.77) 286.07,77.17 R67236.2
I2C0_SDA: length 218.7
  TOP w0.14: R67275.1 120.41,66.26 119.77,65.62 119.77,63.07 119.15,62.45 118.31,62.45 117.83,61.97 v1(117.83,61.56) ; v2(309.09,72.56) 308.82,72.83 U13113.AT42
  IN4 w0.089: v2(309.09,72.56) 307.82,72.56 307.63,72.38 306.71,72.38 306.6,72.48 306.19,72.48 305.5,73.17 297.33,73.17 293.82,76.68 291.92,76.68 290.66,77.94 288.31,77.94 288.18,77.81 286.79,77.81 286.13,78.48 v1(286.05,78.48) 285.9,78.33 281.23,78.33 274.42,85.14 209.06,85.14 202.41,78.49 195.69,78.49 193.6,76.39 191.02,76.39 189.23,74.6 181.93,74.6 181.42,74.09 177.25,74.09 171.37,68.2 168.69,68.2 166.99,66.5 166.99,66.12 166.5,65.64 166.5,64.37 164.49,62.36 158.68,62.36 157.76,61.44 152.25,61.44 151.48,60.68 149.24,60.68 148.47,61.44 134.38,61.44 134.13,61.69 121.06,61.69 120.81,61.45 120.49,61.45 119.87,62.07 118.33,62.07 v1(117.83,61.56)
  BOTTOM w0.14: R67237.2 287.64,76.83 286.95,77.52 286.95,77.58 v1(286.05,78.48)
I2C1_SCL: length 84.4
  TOP w0.14: U13113.AR41 308.58,72.28 309.09,71.77 v2(309.09,71.29)
  IN1 w0.089: v1(357.55,39.64) 357.92,40.01 357.92,43.68 356.75,44.86 354.34,44.86 353.34,45.86 351.31,45.86 349.85,47.31 349.85,47.45 349.51,47.8 346.42,47.8 345.52,48.7 338.95,48.7 338.36,49.29 336.37,49.29 335.78,49.88 334.37,51.29 334.37,51.9 333.73,52.54 333.27,52.54 331.76,54.06 331.76,59.43 330.41,60.78 330.41,63.38 332.26,65.23 332.78,65.23 334.42,66.88 334.42,67.27 333.84,67.85 333.03,67.85 333.01,67.85 332.74,68.12 330.36,68.12 330.2,68.28 329.08,68.28 327.22,70.13 327,70.36 326.46,70.36 326.29,70.53 325.69,71.13 325.69,71.88 325,72.57 322.44,72.57 321.45,71.58 321.37,71.58 v1(320.77,70.98) 320.63,70.85 319.11,70.85 318.76,71.19 317.88,71.19 316.89,70.2 313.3,70.2 312.69,70.81 309.57,70.81 v2(309.09,71.29)
  BOTTOM w0.14: R67404.1 357.67,40.42 357.55,40.3 v1(357.55,39.64) ; R67405.2 321.3,70.45 v1(320.77,70.98)
I2C1_SDA: length 87.6
  TOP w0.102: v2(308.12,73.42) 308.28,73.58 U13113.AR44
  IN1 w0.089: v2(308.12,73.42) 308.38,73.17 309.42,73.17 309.82,72.77 309.82,71.98 310.41,71.38 317.33,71.38 318.23,72.28 319.4,72.28 319.63,72.05 v1(321.25,72.05) 322.24,73.04 325.19,73.04 326.16,72.08 326.16,71.33 326.46,71.03 326.66,70.83 327.19,70.83 329.27,68.75 330.39,68.75 330.55,68.59 332.93,68.59 333.2,68.32 335.52,68.32 335.89,67.96 335.89,67.51 335.66,67.28 335.06,66.68 334.89,66.68 332.97,64.76 332.46,64.76 330.88,63.18 330.88,60.97 332.23,59.63 332.23,58.18 332.23,54.3 333.51,53.01 333.92,53.01 334.86,52.08 334.86,51.47 336.12,50.2 336.56,49.76 338.55,49.76 339.15,49.17 345.72,49.17 346.61,48.27 349.7,48.27 349.77,48.2 351.91,48.2 353,47.11 353.41,47.11 355.19,45.33 356.94,45.33 358.39,43.88 358.39,40.48 358.85,40.02 v1(360.01,40.02)
  BOTTOM w0.14: v1(360.01,40.02) 360.09,40.02 360.37,39.75 R67403.1 ; v1(321.25,72.05) 321.7,71.6 R67406.2
I2C_EN_EDP: length 7.3
  TOP w0.14: v1(331.44,73.51) U13079.17
  BOTTOM w0.14: v1(331.44,73.51) 331.13,73.16 331.13,71.67 331.36,71.44 331.36,70.73 332.77,69.32 R20932.2 R20930.2
I2C_EN_TBT: length 4.6
  TOP w0.14: U13025.17 v1(331.18,55.1)
  BOTTOM w0.14: v1(331.18,55.1) 331.38,54.9 331.38,54.68 R20839.1 331.99,53.83 R20834.1 333.51,52.32 v1(333.55,52.32)
I2C_TP_SCL_R: length 29.2
  TOP w0.14: v1(125,64.73) R21068.1 123.97,64.73 123.86,64.62 Q7892.1 123.38,64.45 123.73,64.1 R67259.2 ; v1(135.05,62.93) CN2076.6 ; CN2078.5 137,54.57 v1(137.13,54.7)
  IN1 w0.089: v1(125,64.73) 125.41,64.32 127.93,64.32 129.92,62.32 132.23,62.32 133.43,63.53 134.53,63.53 135.05,63 v1(135.05,62.93)
  BOTTOM w0.14: v1(135.05,62.93) 135.05,62.76 132.6,60.3 132.6,58.4 133.73,57.27 134.56,57.27 v1(137.13,54.7)
