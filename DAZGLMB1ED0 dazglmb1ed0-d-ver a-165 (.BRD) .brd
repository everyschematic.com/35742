# Allegro board DAZGLMB1ED0 dazglmb1ed0-d-ver a-165 (.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_ODT1_CPU: length 61.6
  TOP w0.216: U41.AE4 242.53,106.35 242.85,106.04 v1(243,106.04) ; CN2063.161 236.18,60.88 235.68,60.37 v1(234.67,60.37)
  IN1 w0.14: v1(243,106.04) 242.49,106.04 242.31,105.86 242.31,103.31 238.83,99.83 238.83,99.51 238.97,99.37 239.05,99.37 239.19,99.23 239.19,98.95 239.05,98.81 238.97,98.81 238.83,98.67 238.83,98.39 238.97,98.25 239.05,98.25 239.19,98.11 239.19,97.83 239.05,97.69 238.97,97.69 238.83,97.55 238.83,97.27 238.97,97.13 239.05,97.13 239.19,96.99 239.19,96.71 239.05,96.57 238.97,96.57 238.83,96.43 238.83,96.15 238.97,96.01 239.05,96.01 239.19,95.87 239.19,95.6 239.05,95.46 238.97,95.46 238.83,95.32 238.83,95.04 238.97,94.9 239.05,94.9 239.19,94.76 239.19,94.48 239.05,94.34 238.97,94.34 238.83,94.2 238.83,93.92 238.97,93.78 239.05,93.78 239.19,93.64 239.19,93.36 239.05,93.22 238.97,93.22 238.83,93.08 238.83,92.8 238.97,92.66 239.05,92.66 239.19,92.52 239.19,92.24 239.05,92.1 238.97,92.1 238.83,91.96 238.83,91.68 238.97,91.54 239.05,91.54 239.19,91.4 239.19,91.13 239.05,90.99 238.97,90.99 238.83,90.85 238.83,90.57 238.97,90.43 239.05,90.43 239.19,90.29 239.19,90.01 239.05,89.87 238.97,89.87 238.83,89.73 238.83,89.45 238.97,89.31 239.05,89.31 239.19,89.17 239.19,88.89 239.05,88.75 238.97,88.75 238.83,88.61 238.83,88.33 238.97,88.19 239.05,88.19 239.19,88.05 239.19,87.77 239.05,87.63 238.97,87.63 238.83,87.49 238.83,87.21 238.97,87.07 239.05,87.07 239.19,86.93 239.19,86.6 238.26,85.67 238.06,85.67 237.87,85.86 237.68,85.86 237.48,85.67 237.48,85.47 237.67,85.28 237.67,85.08 237.47,84.88 237.27,84.88 237.08,85.07 236.89,85.07 236.69,84.88 236.69,84.68 236.88,84.49 236.88,84.29 236.68,84.09 236.48,84.09 236.29,84.28 236.1,84.28 235.9,84.08 235.9,83.89 236.09,83.7 236.09,83.5 235.89,83.3 235.69,83.3 235.5,83.49 235.31,83.49 235.11,83.29 235.11,83.1 235.3,82.91 235.3,82.71 235.1,82.51 234.9,82.51 234.71,82.7 234.52,82.7 234.32,82.5 234.32,82.31 234.51,82.12 234.51,81.92 234.13,81.54 234.13,60.91 v1(234.67,60.37)
M_A_PARITY: length 58.6
  TOP w0.216: v1(245.55,102.1) 244.57,102.1 243.83,102.84 243.83,105.21 244.31,105.68 U41.AG3 ; v1(239.69,58.74) 240.2,58.74 242.15,60.69 242.56,60.69 242.69,60.82 CN2063.143
  IN1 w0.14: v1(239.69,58.74) 240.63,59.68 240.63,69.18 240.86,69.41 240.86,79.64 244.72,83.5 244.72,93.75 244.58,93.89 244.46,93.89 244.32,94.03 244.32,94.31 244.46,94.45 244.58,94.45 244.72,94.59 244.72,94.86 244.58,95 244.46,95 244.32,95.14 244.32,95.42 244.46,95.56 244.58,95.56 244.72,95.7 244.72,95.98 244.58,96.12 244.46,96.12 244.32,96.26 244.32,96.54 244.46,96.68 244.58,96.68 244.72,96.82 244.72,97.1 244.58,97.24 244.46,97.24 244.32,97.38 244.32,97.66 244.46,97.8 244.58,97.8 244.72,97.94 244.72,98.22 244.58,98.36 244.46,98.36 244.32,98.5 244.32,98.78 244.46,98.92 244.58,98.92 244.72,99.06 244.72,99.34 244.58,99.47 244.46,99.47 244.32,99.61 244.32,99.89 244.46,100.03 244.58,100.03 244.72,100.17 244.72,101.08 245.55,101.91 v1(245.55,102.1)
M_A_RAS#: length 56.4
  TOP w0.216: v1(238.5,56.37) 238.58,56.28 238.58,55.23 238.44,55.08 CN2063.152 ; v1(245.53,106.02) 245.19,106.35 U41.AH4
  IN1 w0.14: v1(238.5,56.37) 238.5,56.37 238.5,57.75 238.09,58.16 238.09,79.87 242.21,83.99 242.21,100.16 244.23,102.18 244.23,104.38 244.88,105.03 244.88,105.37 v1(245.53,106.02)
M_A_WE#: length 59.5
  TOP w0.216: CN2063.151 238.69,60.44 237.29,59.05 v1(237.04,59.05) ; v1(243.87,106.03) 244.19,106.35 U41.AG4
  IN1 w0.14: v1(237.04,59.05) 237.2,59.21 237.2,62.8 236.56,63.43 236.56,64.32 237.2,64.96 237.2,68.1 236.74,68.55 236.74,70.39 237.2,70.85 237.2,72.11 236.56,72.74 236.56,73.92 236.7,74.06 237.06,74.06 237.2,74.2 237.2,74.48 237.06,74.62 236.7,74.62 236.56,74.76 236.56,75.04 236.7,75.18 237.06,75.18 237.2,75.32 237.2,75.6 237.06,75.74 236.7,75.74 236.56,75.88 236.56,77.3 236.75,77.48 237.07,77.48 237.2,77.61 237.2,77.91 237.07,78.04 236.72,78.04 236.56,78.2 236.56,78.46 236.7,78.6 237.06,78.6 237.2,78.74 237.2,79.02 237.06,79.16 236.7,79.16 236.56,79.3 236.56,79.62 236.69,79.75 237.1,79.75 237.2,79.85 237.2,80.26 241.31,84.36 241.31,100.07 243.64,102.41 243.64,104.98 243.44,105.19 243.44,105.6 v1(243.87,106.03)
M_B_A0: length 49.2
  TOP w0.216: v1(241.32,68.93) 241.72,68.52 241.72,68.32 242.44,67.61 CN2062.144 ; U41.AJ9 246.54,109.95 v1(246.67,109.95)
  IN2 w0.079: v1(246.67,109.95) 246.4,109.67 246.4,109.67 246.27,109.55 246.27,108.2 245.99,107.92 245.3,107.92 244.93,107.55 244.93,102.86 244.8,102.73 244.8,102.51
  IN2 w0.14: v1(241.32,68.93) 241.45,68.8 241.91,68.8 242.04,68.93 242.04,71.82 241.04,72.82 241.04,75.42 240.42,76.04 240.42,84.27 245.18,89.03 245.18,101.18 244.8,101.57 244.8,102.51
M_B_A1: length 47.3
  TOP w0.216: CN2062.133 245.18,73.33 245.16,73.3 245.16,72.94 244.44,72.22 244.44,71.95 244.02,71.52 243.6,71.52 242.86,72.27 242.86,72.96 v1(241.57,74.25) ; U41.AK6 246.68,107.66 v1(246.35,107.32)
  IN2 w0.079: 245.08,101.84 245.08,107.47 245.37,107.75 246.21,107.75 246.35,107.61 v1(246.35,107.32)
  IN2 w0.14: v1(241.57,74.25) 241.57,76.4 241.42,76.55 241.07,76.55 240.87,76.74 240.87,83.07 241.19,83.4 241.19,83.59 240.87,83.91 240.87,84.09 241.18,84.41 241.38,84.41 241.69,84.09 241.89,84.09 242.09,84.29 242.09,84.49 241.78,84.8 241.78,85 245.64,88.86 245.64,101.29 245.08,101.84
M_B_A2: length 49.4
  TOP w0.216: v1(246.36,106.68) 246.51,106.68 246.82,106.99 U41.AK5 ; CN2062.132 245.44,67.86 245.05,68.24 245.05,68.47 244.62,68.9 244.62,69.69 241.58,72.73 v1(241.58,72.86)
  IN2 w0.079: 245.95,102.98 245.95,106.27 v1(246.36,106.68)
  IN2 w0.14: 245.95,102.98 246.1,102.84 246.1,87.67 245.78,87.36 245.58,87.36 245.27,87.67 245.07,87.67 244.88,87.47 244.88,87.27 245.19,86.96 245.19,86.76 244.99,86.57 244.79,86.57 244.48,86.88 244.28,86.88 244.09,86.68 244.09,86.48 244.4,86.17 244.4,85.97 244.2,85.78 244,85.78 243.69,86.09 243.49,86.09 243.3,85.89 243.3,85.69 243.61,85.38 243.61,85.18 243.41,84.99 243.21,84.99 242.9,85.3 242.7,85.3 242.51,85.1 242.51,84.9 242.82,84.59 242.82,84.39 241.33,82.9 241.33,77.27 242.03,76.57 242.03,73.32 v1(241.58,72.86)
M_B_A3: length 49.2
  TOP w0.216: v1(245.1,72.15) 245.16,72.15 245.69,72.68 CN2062.131 ; U41.AL5 247.56,106.97 247.87,106.66 v1(248.03,106.66)
  IN2 w0.079: 248.66,103.5 248.47,103.69 248.47,106.61 248.42,106.66 v1(248.03,106.66)
  IN2 w0.14: v1(245.1,72.15) 245.41,72.46 245.41,74.35 245.55,74.49 246.02,74.49 246.16,74.63 246.16,74.91 246.02,75.05 245.55,75.05 245.41,75.19 245.41,75.47 245.55,75.61 246.39,75.61 246.53,75.75 246.53,76.03 246.39,76.17 245.55,76.17 245.41,76.31 245.41,76.59 245.55,76.73 246.39,76.73 246.53,76.87 246.53,77.15 246.39,77.29 245.55,77.29 245.41,77.43 245.41,77.71 245.55,77.85 246.39,77.85 246.53,77.98 246.53,78.26 246.39,78.4 245.55,78.4 245.41,78.54 245.41,78.82 245.55,78.96 246.39,78.96 246.53,79.1 246.53,79.38 246.39,79.52 245.68,79.52 245.54,79.66 245.54,80.23 249.37,84.07 249.37,101.21 249.07,101.52 249.07,103.09 248.66,103.5
M_B_A4: length 49.6
  TOP w0.216: U41.AL6 247.69,107.66 v1(248.03,107.31) ; CN2062.128 246.44,67.6 245.74,68.29 245.74,69.1 245.33,69.51 v1(245.16,69.51)
  IN2 w0.079: 249.68,102.28 249.48,102.47 249.48,107.33 249.07,107.75 248.46,107.75 v1(248.03,107.31)
  IN2 w0.14: v1(245.16,69.51) 244.72,69.07 244.72,68.58 245.13,68.16 245.64,68.16 246.36,68.89 246.36,73.58 247.42,74.64 247.42,80.85 250.29,83.72 250.29,101.67 249.68,102.28
M_B_A5: length 45.7
  TOP w0.216: v1(245.16,70.83) 245.38,70.83 246.26,69.96 246.26,68.51 246.93,67.83 CN2062.126 ; v1(248.88,107.34) 248.57,107.66 U41.AM6
  IN2 w0.079: v1(248.88,107.34) 248.95,107.41 249.18,107.41 249.32,107.27 249.32,101.97
  IN2 w0.14: v1(245.16,70.83) 245.54,70.45 245.79,70.45 245.92,70.58 245.92,73.77 246.97,74.82 246.97,81.04 249.83,83.89 249.83,101.46 249.32,101.97
M_B_A6: length 47.1
  TOP w0.216: v1(247.42,71.99) 246.69,72.72 CN2062.127 ; v1(249.42,108.65) 249.09,108.32 U41.AN7
  IN2 w0.079: 250.12,103.34 250.12,103.54 250.09,103.58 249.96,103.71 249.96,107.67 249.42,108.2 v1(249.42,108.65)
  IN2 w0.14: v1(247.42,71.99) 247.42,70.32 247.67,70.07 248.05,70.07 248.32,70.34 248.32,72.89 250.05,74.63 250.05,81.58 251.66,83.19 251.66,101.71 250.12,103.24 250.12,103.34
M_B_A7: length 50.8
  TOP w0.216: U41.AN10 249.25,109.97 v1(249.39,109.97) ; CN2062.122 247.93,67.62 v1(247.37,68.19)
  IN2 w0.079: v1(249.39,109.97) 249.14,109.72 249.14,109.72 248.97,109.55 248.97,109.04 248.87,108.94 248.87,108.31 249.64,107.54 249.64,102.75 249.84,102.54
  IN2 w0.14: v1(247.37,68.19) 247.77,68.19 248.05,67.91 248.05,67.53 247.8,67.28 246.53,67.28 246.4,67.41 246.4,68.3 246.81,68.71 246.81,73.4 247.86,74.45 247.86,80.67 250.74,83.55 250.74,101.64 249.84,102.54
M_B_A8: length 47.3
  TOP w0.216: v1(249.38,109.32) 249.12,109.06 249.04,109.06 U41.AN8 ; CN2062.125 247.18,73.69 v1(247.43,73.44)
  IN2 w0.079: v1(249.38,109.32) 249.38,109.24 249.02,108.88 249.02,108.37 249.8,107.6 249.8,103.12 250.03,102.88
  IN2 w0.14: 250.03,102.88 251.2,101.71 251.2,83.38 249.61,81.79 249.61,81.11 249.47,80.97 248.83,80.97 248.69,80.83 248.69,80.55 248.83,80.41 249.47,80.41 249.61,80.27 249.61,79.99 249.47,79.85 248.83,79.85 248.69,79.71 248.69,79.43 248.83,79.29 249.47,79.29 249.61,79.15 249.61,78.87 249.47,78.73 248.83,78.73 248.69,78.59 248.69,78.31 248.83,78.17 249.47,78.17 249.61,78.03 249.61,76.07 249.19,75.66 248.44,75.66 248.31,75.52 248.31,75.15 248.43,75.02 249.19,75.02 249.32,74.9 249.32,74.52 248.24,73.44 v1(247.43,73.44)
M_B_A9: length 47.6
  TOP w0.216: CN2062.121 248.18,73.48 248.05,73.35 248.05,72.97 v1(249.18,71.84) ; v1(250.36,110.59) 250.69,110.92 U41.AR11
  IN2 w0.079: 250.96,107.49 249.97,108.47 249.97,110.2 v1(250.36,110.59)
  IN2 w0.14: 250.96,107.49 250.96,103.24 252.56,101.64 252.56,82.4 251.61,81.44 251.19,81.44 250.94,81.2 250.94,75.03 251.35,74.62 251.35,74.01 251.13,73.78 250.55,73.78 250.21,73.45 250.21,71.47 250.08,71.34 249.68,71.34 v1(249.18,71.84)
M_B_A10: length 47.9
  TOP w0.216: U41.AH7 245.37,108.32 v1(245.69,108.64) ; v1(241.62,70.3) 240.71,69.38 240.71,68.46 239.94,67.68 CN2062.146
  IN2 w0.079: v1(245.69,108.64) 245.41,108.36 245.23,108.36 244.61,107.74 244.61,103.31 244.52,103.22
  IN2 w0.14: v1(241.62,70.3) 240.3,70.3 240.15,70.45 240.15,74.83 239.15,75.82 239.15,76.82 239.54,77.2 239.54,85.3 244.27,90.03 244.27,102.96 244.52,103.22
M_B_A11: length 51.1
  TOP w0.216: v1(249.38,110.62) 249.08,110.92 U41.AN11 ; v1(247.37,69.51) 247.41,69.51 248.44,68.49 CN2062.120
  IN2 w0.079: v1(249.38,110.62) 249.42,110.62 249.81,110.22 249.81,108.06 250.11,107.76 250.11,103.77 250.2,103.69 250.46,103.42 250.46,103.25
  IN2 w0.14: 250.46,103.25 252.12,101.6 252.12,83 250.5,81.38 250.5,74.44 248.76,72.71 248.76,70.89 248.9,70.75 249.39,70.75 249.53,70.61 249.53,70.33 249.39,70.19 248.9,70.19 248.8,70.08 248.8,69.04 248.56,68.8 248.08,68.8 v1(247.37,69.51)
M_B_A12: length 47.6
  TOP w0.216: v1(251.21,110.62) 250.86,110.27 U41.AR10 ; CN2062.119 248.69,73.12 v1(250.77,71.04)
  IN2 w0.079: 252.28,103.12 252.17,103.22 252.17,107.11 251.27,108.02 251.27,108.62 250.84,109.05 250.84,110.25 v1(251.21,110.62)
  IN2 w0.14: v1(250.77,71.04) 252.82,73.09 252.82,78.2 253.07,78.45 253.07,80.98 254.02,81.93 254.02,101.38 252.28,103.12
M_B_A13: length 49.2
  TOP w0.216: v1(243.02,109.93) 243.34,109.62 U41.AF9 ; v1(237.15,70.22) 236.62,69.69 236.62,67.99 236.94,67.67 CN2062.158
  IN2 w0.079: 242.58,102.51 242.58,107.46 243.29,108.17 243.29,109.02 243.54,109.28 243.54,109.81 243.42,109.93 v1(243.02,109.93)
  IN2 w0.14: 242.58,102.51 242.44,102.36 242.44,91.07 236.67,85.3 236.67,75.8 237.99,74.48 237.99,70.17 237.76,69.94 237.43,69.94 v1(237.15,70.22)
M_B_ACT#: length 48.1
  TOP w0.216: CN2062.114 249.93,69.16 v1(250.72,69.94) ; v1(251.3,109.93) 251.61,109.62 U41.AT9
  IN2 w0.079: v1(251.3,109.93) 251.72,109.51 251.72,109.13 252.59,108.27 252.59,103.62 252.88,103.33
  IN2 w0.14: 252.88,103.33 255.24,100.97 255.24,81.43 254.29,80.48 254.29,72.83 251.4,69.94 v1(250.72,69.94)
M_B_ALERT#: length 47.6
  TOP w0.216: v1(249.17,67.89) 249.44,67.62 CN2062.116 ; U41.AR8 250.81,108.97 251.08,109.24 251.23,109.24 v1(251.25,109.22)
  IN2 w0.079: 252.63,103.15 252.38,103.4 252.38,107.21 251.71,107.88 251.71,108.19 251.43,108.48 251.43,109.04 v1(251.25,109.22)
  IN2 w0.14: 252.63,103.15 254.79,100.98 254.79,81.61 253.84,80.66 253.84,73.01 251.34,70.51 250.53,70.51 250.31,70.29 250.31,69.02 v1(249.17,67.89)
M_B_BA#0: length 49.4
  TOP w0.216: U41.AH8 245.62,109.3 v1(245.7,109.3) ; v1(238.75,70.5) 238.94,70.32 CN2062.150
  IN2 w0.079: v1(245.7,109.3) 245.7,109.27 244.45,108.02 244.45,103.53 244.29,103.37
  IN2 w0.14: 244.29,103.37 243.8,102.87 243.8,90.19 239.09,85.48 239.09,77.38 238.71,77 238.71,75.64 239.67,74.68 239.67,69.56 239.54,69.43 239.03,69.43 238.75,69.71 v1(238.75,70.5)
M_B_BA#1: length 49.6
  TOP w0.216: CN2062.145 240.18,73.05 v1(241.6,71.63) ; v1(245.74,109.97) 245.62,109.97 245.29,109.64 U41.AH9
  IN2 w0.079: 244.52,102.61 244.52,102.86 244.77,103.11 244.77,107.62 245.23,108.08 245.88,108.08 246.11,108.32 246.11,109.59 v1(245.74,109.97)
  IN2 w0.14: v1(241.6,71.63) 240.6,72.64 240.6,75.24 239.98,75.85 239.98,84.46 240.31,84.79 240.31,84.98 240.18,85.11 240.18,85.31 240.38,85.51 240.57,85.51 240.7,85.38 240.9,85.38 241.1,85.58 241.1,85.77 240.97,85.9 240.97,86.1 241.17,86.3 241.36,86.3 241.49,86.17 241.69,86.17 241.89,86.37 241.89,86.57 241.76,86.69 241.76,86.89 241.96,87.09 242.15,87.09 242.28,86.96 242.48,86.96 242.68,87.16 242.68,87.36 242.55,87.48 242.55,87.68 242.75,87.88 242.94,87.88 243.07,87.75 243.27,87.75 243.47,87.95 243.47,88.15 243.34,88.28 243.34,88.47 243.54,88.67 243.74,88.67 243.86,88.54 244.06,88.54 244.72,89.2 244.72,101.06 244.52,101.26 244.52,102.61
M_B_BG#0: length 43.8
  TOP w0.216: v1(250.74,71.95) 249.69,73.01 CN2062.115 ; v1(250.38,109.29) 250.47,109.29 250.78,109.6 U41.AR9
  IN2 w0.079: 252.17,102.89 251.98,103.08 251.98,107.05 251.11,107.92 251.11,108.56 v1(250.38,109.29)
  IN2 w0.14: v1(250.74,71.95) 251.05,71.95 252.38,73.27 252.38,78.39 252.62,78.64 252.62,81.18 253.56,82.12 253.56,101.5 252.17,102.89
M_B_BG#1: length 44.7
  TOP w0.216: CN2062.113 250.18,73.7 250.51,73.37 v1(250.72,73.37) ; U41.AR7 250.71,108.32 v1(250.38,108.64)
  IN2 w0.079: 252.08,102.55 251.81,102.83 251.81,106.91 250.38,108.33 v1(250.38,108.64)
  IN2 w0.14: v1(250.72,73.37) 250.72,73.29 251.01,72.99 251.47,72.99 251.93,73.45 251.93,74.93 251.79,75.07 251.52,75.07 251.38,75.21 251.38,75.49 251.52,75.63 251.79,75.63 251.93,75.77 251.93,78.06 251.79,78.2 251.52,78.2 251.38,78.34 251.38,78.62 251.52,78.76 252.04,78.76 252.18,78.9 252.18,79.18 252.04,79.32 251.52,79.32 251.38,79.46 251.38,79.74 251.52,79.88 252.04,79.88 252.18,80.02 252.18,80.3 252.04,80.44 251.52,80.44 251.38,80.58 251.38,80.86 251.52,81 251.79,81 253.11,82.31 253.11,101.53 252.08,102.55
M_B_CAS#: length 50.1
  TOP w0.216: v1(237.15,68.72) 237.44,68.44 CN2062.156 ; U41.AF8 243.28,108.97 v1(242.98,109.27)
  IN2 w0.079: 242.23,102.62 242.42,102.81 242.42,107.52 242.71,107.81 242.71,108.99 v1(242.98,109.27)
  IN2 w0.14: v1(237.15,68.72) 237.15,68.32 237,68.16 236.11,68.16 235.73,68.55 235.73,70.22 236.01,70.5 236.62,70.5 237.54,71.42 237.54,74.28 236.2,75.63 236.2,85.49 241.97,91.27 241.97,102.36 242.23,102.62
M_B_CB0: length 2.6
  TOP w0.14: CN2062.92 255.44,67.62 v1(255.75,67.94)
  BOTTOM w0.14: R21422.2 256.18,67.5 v1(255.75,67.94)
M_B_CB1: length 2.5
  TOP w0.14: CN2062.91 255.69,73.44 v1(255.75,73.37)
  BOTTOM w0.14: R21423.2 255.72,73.4 v1(255.75,73.37)
M_B_CB2: length 2.5
  TOP w0.14: CN2062.101 253.18,76.02 v1(253.23,76.06)
  BOTTOM w0.14: v1(253.23,76.06) 252.38,75.21 R21424.2
M_B_CB3: length 4.4
  TOP w0.14: v1(251.38,76.84) 252.18,76.03 CN2062.105
  BOTTOM w0.14: R21425.2 251.84,75.77 251.84,76.38 v1(251.38,76.84)
M_B_CB4: length 5.7
  TOP w0.14: CN2062.88 256.44,68.67 v1(255.73,69.37)
  BOTTOM w0.14: R21426.2 255.14,68.77 v1(255.73,69.37)
M_B_CB5: length 6.2
  TOP w0.14: CN2062.87 256.69,72.84 v1(255.77,71.92)
  BOTTOM w0.14: v1(255.77,71.92) 256.28,72.43 256.28,73.7 256.84,74.26 R21429.2
M_B_CB6: length 2.7
  TOP w0.14: v1(253.33,68.06) 253.44,67.96 CN2062.100
  BOTTOM w0.14: v1(253.33,68.06) 253.61,67.78 R21428.2
M_B_CB7: length 5.9
  TOP w0.14: v1(253.33,69.38) 252.44,68.49 CN2062.104
  BOTTOM w0.14: R21430.2 252.52,68.57 v1(253.33,69.38)
M_B_CKE0: length 50.3
  TOP w0.216: CN2062.109 251.18,73.74 251.84,73.09 251.84,69.12 v1(251.79,69.08) ; v1(252.15,109.26) 251.86,108.97 U41.AT8
  IN2 w0.079: 253.55,108.1 253.16,108.49 252.97,108.49 252.2,109.26 v1(252.15,109.26)
  IN2 w0.14: 253.55,108.1 253.55,107.69 253.46,107.59 253.46,103.91 253.18,103.64 253.18,103.42 255.68,100.92 255.68,81.24 254.74,80.3 254.74,72.18 251.84,69.28 251.84,69.12 v1(251.79,69.08)
M_B_CKE1: length 49.3
  TOP w0.216: CN2062.110 250.93,68.1 v1(250.73,68.31) ; U41.AT10 252.01,109.95 v1(252.16,109.95)
  IN2 w0.079: 254.33,106.75 254.33,107.69 253.23,108.78 252.9,108.78 252.65,109.03 252.65,109.49 252.19,109.95 v1(252.16,109.95)
  IN2 w0.14: 254.33,106.75 254.33,102.58 256.13,100.78 256.13,81.06 255.19,80.12 255.19,72 252.28,69.09 252.28,68.28 251.98,67.98 251.05,67.98 v1(250.73,68.31)
M_B_CLKN0: length 46.5
  TOP w0.14: v1(248.49,109.97) 248.79,109.97 248.95,109.81 U41.AN9 ; v1(243.78,73.42) 243.69,73.52 CN2062.139
  IN2 w0.079: v1(248.49,109.97) 248.49,109.87 248.09,109.47 248.09,109.12 247.91,108.94 247.91,108.47 247.9,108.47 247.9,108.45
  IN2 w0.089: v1(243.78,73.42) 243.78,73.21 243.88,73.12 244.38,73.12 244.5,73.23 244.5,74.79 244.41,74.88 243.74,74.88 243.55,75.07 243.55,75.63 243.74,75.81 244.41,75.81 244.5,75.9 244.5,76.22 244.24,76.48 244.24,76.91 244.5,77.17 244.5,77.56 244.41,77.65 243.93,77.65 243.74,77.83 243.74,78.39 243.93,78.58 244.41,78.58 244.5,78.67 244.5,79.09 244.41,79.17 243.93,79.17 243.74,79.36 243.74,79.92 243.93,80.11 244.41,80.11 244.58,80.28 244.58,80.57 248.44,84.43 248.44,102.82 247.45,103.81 247.45,107.67 247.9,108.12 247.9,108.45
M_B_CLKN1: length 48.2
  TOP w0.14: v1(247.52,109.3) 247.56,109.3 247.89,108.97 U41.AM8 ; CN2062.140 243.44,67.64 v1(243.71,67.92)
  IN2 w0.089: v1(243.71,67.92) 243.71,68.39 243.52,68.58 242.98,68.58 242.79,68.77 242.79,70.6 242.97,70.78 243.55,70.78 243.64,70.87 243.64,71.29 243.55,71.38 242.97,71.38 242.79,71.57 242.79,76.22 242.98,76.41 242.98,80.24 247.65,84.91 247.65,101.21 247.05,101.82 247.05,108.42 247.09,108.45 247.09,109.09 247.29,109.3 v1(247.52,109.3)
M_B_CLKP0: length 46.6
  TOP w0.14: CN2062.137 244.18,73.71 244.29,73.6 244.29,73.22 v1(243.81,72.74) ; U41.AM9 248.16,109.62 v1(248.49,109.29)
  IN2 w0.079: v1(248.49,109.29) 248.07,108.87 248.07,108.47 248.07,108.47 248.07,108.45
  IN2 w0.089: v1(243.81,72.74) 244.02,72.95 244.45,72.95 244.66,73.16 244.66,74.86 244.48,75.05 243.81,75.05 243.72,75.14 243.72,75.56 243.81,75.65 244.48,75.65 244.66,75.83 244.66,76.29 244.4,76.55 244.4,76.84 244.66,77.1 244.66,77.63 244.48,77.81 244,77.81 243.91,77.9 243.91,78.32 244,78.41 244.48,78.41 244.66,78.6 244.66,79.15 244.48,79.34 244,79.34 243.91,79.43 243.91,79.85 244,79.94 244.48,79.94 244.75,80.21 244.75,80.5 248.61,84.36 248.61,102.89 247.62,103.88 247.62,107.6 248.07,108.05 248.07,108.45
M_B_CLKP1: length 48.3
  TOP w0.14: v1(243.71,69.19) 243.71,68.6 244.19,68.11 244.19,67.73 243.93,67.48 CN2062.138 ; U41.AM7 247.84,108.32 v1(247.51,108.64)
  IN2 w0.089: v1(243.71,69.19) 243.71,68.85 243.61,68.75 243.05,68.75 242.95,68.84 242.95,70.53 243.04,70.62 243.62,70.62 243.81,70.8 243.81,71.36 243.62,71.55 243.04,71.55 242.95,71.64 242.95,76.15 243.15,76.34 243.15,80.17 247.82,84.84 247.82,101.28 247.22,101.89 247.22,108.35 v1(247.51,108.64)
M_B_CS#0: length 45.7
  TOP w0.216: v1(235.2,77.77) 238.07,77.77 238.78,77.05 238.78,76.22 239.18,75.81 CN2062.149 ; U41.AF11 243.32,110.92 v1(243,110.59)
  IN2 w0.079: 242.11,102.81 242.25,102.95 242.25,107.58 242.55,107.88 242.55,110.15 v1(243,110.59)
  IN2 w0.14: v1(235.2,77.77) 235.42,77.99 235.42,83.03 235.28,83.17 234.72,83.17 234.58,83.31 234.58,83.59 234.72,83.73 235.28,83.73 235.42,83.87 235.42,84.15 235.28,84.29 234.72,84.29 234.58,84.43 234.58,84.71 234.72,84.85 235.28,84.85 235.42,84.99 235.42,85.81 241.18,91.57 241.18,101.88 242.11,102.81
M_B_CS#1: length 48.4
  TOP w0.216: v1(237.13,73.5) 237.18,73.55 CN2062.157 ; v1(242.12,108.01) 242.25,108.01 U41.AE7
  IN2 w0.079: 242.03,103.04 242.08,103.09 242.08,107.97 v1(242.12,108.01)
  IN2 w0.14: 242.03,103.04 240.72,101.73 240.72,91.76 234.13,85.17 234.13,82.73 234.27,82.59 234.84,82.59 234.98,82.45 234.98,82.17 234.84,82.03 234.27,82.03 234.13,81.89 234.13,81.5 234.26,81.37 234.84,81.37 234.98,81.24 234.98,80.92 234.84,80.78 234.26,80.78 234.12,80.64 234.12,80.36 234.26,80.22 234.84,80.22 234.98,80.08 234.98,78.2 234.79,78.01 234.79,75.84 236.01,74.62 236.01,71.7 236.2,71.5 236.53,71.5 236.72,71.69 236.72,73.09 v1(237.13,73.5)
M_B_DQ0: length 51.2
  TOP w0.14: U41.BT11 267.23,110.86 v1(267.75,111.37) ; CN2062.4 277.44,68.35 v1(276.41,69.37)
  IN2 w0.089: v1(267.75,111.37) 268.25,111.37 270.67,108.95 270.67,108.51 271.77,107.4 271.77,105.86 273.03,104.6 273.03,103.55 274.46,102.13 274.46,80.2 274.86,79.8 274.86,73.6 275.56,72.9 275.56,70.22 v1(276.41,69.37)
M_B_DQ1: length 51.1
  TOP w0.14: U41.BR11 265.24,110.93 265.59,111.28 v1(266.39,111.28) ; v1(276.37,68.01) 276.44,67.95 CN2062.8
  IN2 w0.089: v1(266.39,111.28) 266.73,110.95 268.26,110.95 270.38,108.83 270.38,108.38 271.48,107.28 271.48,105.74 272.74,104.48 272.74,103.43 274.12,102.05 274.12,80.12 274.55,79.69 274.55,73.48 275.13,72.9 275.13,69.26 v1(276.37,68.01)
M_B_DQ2: length 51
  TOP w0.14: U41.BT8 266.08,108.86 267.43,108.86 v1(267.6,109.02) ; CN2062.21 273.19,73.53 v1(273.05,73.4)
  IN2 w0.089: v1(267.6,109.02) 267.6,109.01 268.27,108.34 268.27,107.94 269.66,106.54 269.66,105.27 271.08,103.86 271.08,102.73 271.76,102.04 271.76,97.04 271.85,96.95 272.41,96.95 272.5,96.86 272.5,96.68 272.41,96.59 271.85,96.59 271.76,96.51 271.76,96.33 271.85,96.24 272.41,96.24 272.5,96.15 272.5,95.97 272.41,95.88 271.85,95.88 271.76,95.79 271.76,95.62 271.85,95.53 272.41,95.53 272.5,95.44 272.5,95.26 272.41,95.17 271.85,95.17 271.76,95.08 271.76,94.91 271.85,94.82 272.41,94.82 272.5,94.73 272.5,94.55 272.41,94.46 271.85,94.46 271.76,94.37 271.76,94.19 271.85,94.11 272.41,94.11 272.5,94.02 272.5,93.84 272.41,93.75 271.85,93.75 271.76,93.66 271.76,93.48 271.85,93.39 272.41,93.39 272.5,93.31 272.5,93.13 272.41,93.04 271.85,93.04 271.76,92.95 271.76,92.77 271.85,92.68 272.41,92.68 272.5,92.59 272.5,92.42 272.41,92.33 271.85,92.33 271.76,92.24 271.76,92.06 271.85,91.97 272.41,91.97 272.5,91.88 272.5,91.7 272.41,91.62 272.23,91.62 272.14,91.53 272.14,91.37 272.23,91.28 272.41,91.28 272.5,91.19 272.5,78.67 272.58,78.59 272.58,73.87 v1(273.05,73.4)
M_B_DQ3: length 51.3
  TOP w0.14: CN2062.17 274.19,73.8 273.55,73.17 273.55,72.53 273.07,72.05 v1(273.07,71.95) ; U41.BR8 265.42,109.47 266.91,109.47 v1(266.97,109.4)
  IN2 w0.089: v1(273.07,71.95) 272.59,71.95 272.28,72.26 272.28,78.48 271.45,79.31 271.45,87.61 271.54,87.7 271.92,87.7 272,87.79 272,87.97 271.92,88.06 271.54,88.06 271.45,88.15 271.45,88.32 271.54,88.41 272.09,88.41 272.18,88.5 272.18,88.68 272.09,88.77 271.54,88.77 271.45,88.86 271.45,89.03 271.54,89.12 272.09,89.12 272.18,89.21 272.18,89.39 272.09,89.48 271.54,89.48 271.45,89.57 271.45,89.75 271.54,89.83 272.09,89.83 272.18,89.92 272.18,90.1 272.09,90.19 271.54,90.19 271.45,90.28 271.45,90.46 271.54,90.55 272.09,90.55 272.18,90.63 272.18,90.81 272.09,90.9 271.54,90.9 271.45,90.99 271.45,101.94 270.78,102.6 270.78,103.74 269.37,105.15 269.37,106.42 267.98,107.81 267.98,108.06 266.97,109.06 v1(266.97,109.4)
M_B_DQ4: length 51.1
  TOP w0.14: v1(264.91,111.25) 264.58,110.93 U41.BP11 ; CN2062.3 277.68,73.01 v1(276.45,71.77)
  IN2 w0.089: v1(276.45,71.77) 275.91,72.31 275.91,72.96 275.15,73.73 275.15,79.92 274.79,80.28 274.79,102.21 273.33,103.67 273.33,104.72 272.07,105.98 272.07,107.52 270.96,108.63 270.96,109.07 268.11,111.92 265.58,111.92 265.41,111.75 265.41,111.75 264.91,111.25 v1(264.91,111.25)
M_B_DQ5: length 51.1
  TOP w0.14: U41.BN11 263.93,110.93 v1(264.26,111.25) ; CN2062.7 276.68,73.48 v1(276.43,73.22)
  IN2 w0.089: v1(276.43,73.22) 276.07,73.22 275.44,73.85 275.44,74.14 275.53,74.23 276.16,74.23 276.25,74.32 276.25,74.49 276.16,74.58 275.53,74.58 275.44,74.67 275.44,80.04 275.09,80.39 275.09,102.32 273.62,103.79 273.62,104.84 272.36,106.1 272.36,107.81 271.27,108.91 271.27,109.18 268.22,112.23 264.43,112.23 264.26,112.05 v1(264.26,111.25)
M_B_DQ6: length 51.1
  TOP w0.14: v1(264.91,109.68) 264.58,109.35 U41.BP8 ; v1(273.01,69.5) 274.44,68.07 CN2062.16
  IN2 w0.089: v1(273.01,69.5) 272.69,69.5 272.56,69.37 272.56,68.29 272.44,68.16 272.13,68.16 271.97,68.32 271.97,78.37 271.15,79.2 271.15,101.83 270.49,102.48 270.49,103.61 269.08,105.03 269.08,106.3 267.36,108.02 267.36,108.14 265.82,109.68 v1(264.91,109.68)
M_B_DQ7: length 50.2
  TOP w0.14: v1(272.99,68.19) 273.44,67.75 CN2062.20 ; v1(264.26,109.67) 263.93,109.35 U41.BN8
  IN2 w0.079: v1(264.26,109.67) 264.65,109.28 265.43,109.28 265.56,109.15
  IN2 w0.089: v1(272.99,68.19) 272.99,67.53 272.87,67.4 271.93,67.4 271.67,67.66 271.67,78.27 270.84,79.09 270.84,101.44 270.2,102.08 270.2,103.49 268.79,104.91 268.79,106.18 267.05,107.92 267.05,108.02 266.24,108.83 265.88,108.83 265.56,109.15
M_B_DQ8: length 49.7
  TOP w0.14: v1(262.14,111.43) 262.35,111.64 U41.BL12 ; CN2062.25 272.19,73 v1(271.14,71.95)
  IN2 w0.089: v1(262.14,111.43) 262.42,111.15 263.02,110.55 263.02,109.98 263.94,109.06 263.94,108.88 264.5,108.32 264.5,107.88 264.7,107.68 265.66,107.68 265.85,107.49 265.85,106.88 266.43,106.3 267.37,106.3 267.76,105.91 267.76,104.49 269.18,103.07 269.18,99.27 269.7,98.75 269.7,78.79 270.29,78.21 270.29,71.9 270.5,71.69 270.5,71.37 270.59,71.28 270.85,71.28 270.94,71.37 270.94,71.75 v1(271.14,71.95)
M_B_DQ9: length 48.7
  TOP w0.14: CN2062.29 271.19,73.46 v1(271.12,73.4) ; U41.BL11 262.63,110.92 v1(262.96,111.25)
  IN2 w0.089: v1(271.12,73.4) 270.76,73.4 270.59,73.56 270.59,73.85 270.68,73.94 270.85,73.94 270.94,74.03 270.94,74.21 270.85,74.3 270.68,74.3 270.59,74.39 270.59,74.57 270.68,74.65 270.85,74.65 270.94,74.74 270.94,74.92 270.85,75.01 270.68,75.01 270.59,75.1 270.59,75.28 270.68,75.37 270.85,75.37 270.94,75.45 270.94,75.63 270.85,75.72 270.68,75.72 270.59,75.81 270.59,76.49 270.68,76.57 270.85,76.57 270.94,76.66 270.94,76.84 270.85,76.93 270.68,76.93 270.59,77.02 270.59,77.2 270.68,77.29 270.85,77.29 270.94,77.37 270.94,77.55 270.85,77.64 270.68,77.64 270.59,77.73 270.59,78.32 270.01,78.9 270.01,99.21 269.92,99.3 269.56,99.3 269.48,99.39 269.48,99.57 269.56,99.66 269.92,99.66 270.01,99.75 270.01,99.92 269.92,100.01 269.56,100.01 269.48,100.1 269.48,100.28 269.56,100.37 269.92,100.37 270.01,100.46 270.01,100.68 269.88,100.8 269.6,100.8 269.48,100.93 269.48,101.15 269.73,101.4 269.73,101.53 269.48,101.78 269.48,103.19 267.93,104.74 267.93,106.01 267.32,106.62 266.44,106.62 266.02,107.04 266.02,107.61 265.14,108.49 264.73,108.49 264.39,108.82 264.39,108.95 263.19,110.15 263.19,110.81 262.96,111.04 v1(262.96,111.25)
M_B_DQ10: length 48.8
  TOP w0.14: v1(262.26,108.9) 262.63,109.27 U41.BL8 ; CN2062.41 268.19,73.79 v1(267.89,73.5)
  IN2 w0.089: v1(262.26,108.9) 262.78,108.38 262.78,107.74 263.96,106.55 263.96,105.53 264.79,104.71 264.79,103.6 265.57,102.82 265.57,102.43 266.47,101.53 266.47,98.01 266.56,97.92 267.33,97.92 267.41,97.84 267.41,97.66 267.33,97.57 266.56,97.57 266.47,97.48 266.47,97.3 266.56,97.21 267.33,97.21 267.41,97.12 267.41,96.95 267.33,96.86 266.56,96.86 266.47,96.77 266.47,96.59 266.56,96.5 267.33,96.5 267.41,96.41 267.41,96.24 267.33,96.15 266.56,96.15 266.47,96.06 266.47,95.88 266.56,95.79 267.33,95.79 267.41,95.7 267.41,95.52 267.33,95.44 266.56,95.44 266.47,95.35 266.47,95.17 266.56,95.08 267.33,95.08 267.41,94.99 267.41,94.81 267.33,94.72 266.56,94.72 266.47,94.64 266.47,94.34 267.27,93.54 267.27,73.33 267.36,73.24 267.64,73.24 v1(267.89,73.5)
M_B_DQ11: length 49.7
  TOP w0.14: U41.BJ8 261.67,108.97 v1(261.31,109.33) ; CN2062.38 268.93,67.6 268.37,68.16 268.37,68.8 v1(267.9,69.27)
  IN2 w0.089: v1(261.31,109.33) 261.75,108.88 261.75,107.87 262.73,106.89 262.73,106.29 264.18,104.84 264.18,103.35 264.86,102.66 264.86,101.59 265.88,100.57 265.88,94.1 266.66,93.33 266.66,67.98 266.82,67.81 267.23,67.81 267.36,67.94 267.36,68.72 v1(267.9,69.27)
M_B_DQ12: length 49.3
  TOP w0.14: U41.BJ11 261.88,110.92 v1(262.19,110.61) ; CN2062.24 272.44,67.65 271.95,68.14 271.95,68.52 v1(271.1,69.37)
  IN2 w0.089: v1(262.19,110.61) 262.3,110.61 262.85,110.06 262.85,109.83 263.61,109.07 263.61,107.86 264.77,106.7 265.06,106.7 266.35,105.41 266.35,104.62 267.99,102.98 268.36,102.98 268.89,102.45 268.89,99.15 269.41,98.63 269.41,78.67 269.98,78.1 269.98,71.79 270.15,71.63 270.15,70.32 v1(271.1,69.37)
M_B_DQ13: length 49.5
  TOP w0.14: CN2062.28 271.44,67.62 v1(271.09,67.96) ; v1(261.31,110.63) 261.67,110.27 U41.BJ10
  IN2 w0.089: v1(261.31,110.63) 261.6,110.34 261.72,110.21 262.44,110.21 262.65,110 262.65,109.76 263.42,109 263.42,107.81 264.7,106.53 264.88,106.53 265.22,106.19 265.22,105.99 266.19,105.02 266.19,104.23 267.76,102.66 268,102.66 268.6,102.06 268.6,99.03 269.03,98.6 269.03,78.64 269.68,77.99 269.68,71.68 269.86,71.51 269.86,69.19 v1(271.09,67.96)
M_B_DQ14: length 48.9
  TOP w0.14: CN2062.37 269.19,73.32 v1(267.91,72.05) ; v1(262.2,108.04) 262.55,108.39 U41.BL7
  IN2 w0.089: v1(262.2,108.04) 262.2,107.98 263.55,106.63 263.55,105.71 264.48,104.77 264.48,103.47 265.28,102.68 265.28,102.48 266.18,101.59 266.18,94.22 266.96,93.44 266.96,69.15 267.04,69.07 267.29,69.07 267.39,69.18 267.39,72.19 267.51,72.31 267.66,72.31 v1(267.91,72.05)
M_B_DQ15: length 49.3
  TOP w0.14: U41.BJ7 261.63,108.32 v1(261.29,108.65) ; v1(267.89,67.96) 267.93,67.92 CN2062.42
  IN2 w0.079: 262.15,104.92 262.15,104.92 261.85,105.21 261.85,107.51 261.29,108.08 v1(261.29,108.65)
  IN2 w0.089: 262.15,104.92 263.02,104.05 263.63,104.05 263.88,103.8 263.88,103.22 264.69,102.4 264.69,101.29 265.59,100.4 265.59,93.98 266.35,93.22 266.35,67.39 266.54,67.2 268.46,67.2 268.55,67.29 268.55,67.78 268.37,67.96 v1(267.89,67.96)
M_B_DQ16: length 48.6
  TOP w0.14: U41.BG11 260.13,110.92 v1(260.38,111.17) ; v1(265.86,73.4) 266.19,73.72 CN2062.49
  IN2 w0.089: v1(265.86,73.4) 265.42,73.84 265.42,88.28 265.33,88.37 264.96,88.37 264.87,88.45 264.87,88.63 264.96,88.72 265.33,88.72 265.42,88.81 265.42,88.99 265.33,89.08 264.96,89.08 264.87,89.17 264.87,89.34 264.96,89.43 265.33,89.43 265.42,89.52 265.42,89.7 265.33,89.79 264.96,89.79 264.87,89.88 264.87,90.06 264.96,90.14 265.33,90.14 265.42,90.23 265.42,90.41 265.33,90.5 264.96,90.5 264.87,90.59 264.87,90.77 264.96,90.86 265.33,90.86 265.42,90.94 265.42,91.12 265.33,91.21 264.96,91.21 264.87,91.3 264.87,91.48 264.96,91.57 265.33,91.57 265.42,91.66 265.42,91.83 265.33,91.92 264.96,91.92 264.87,92.01 264.87,92.19 264.96,92.28 265.33,92.28 265.42,92.37 265.42,92.54 265.33,92.63 264.96,92.63 264.87,92.72 264.87,92.9 264.96,92.99 265.2,92.99 265.29,93.08 265.29,93.26 265.2,93.34 265.03,93.34 264.87,93.51 264.87,100.1 263.15,101.81 263.15,102.79 262.35,103.58 262.35,104.33 261.91,104.78 261.42,104.78 261.04,105.15 261.04,107.56 260.84,107.77 260.84,110.74 260.66,110.92 260.63,110.92 v1(260.38,111.17)
M_B_DQ17: length 48.4
  TOP w0.14: U41.BG10 260.15,110.27 v1(260.39,110.51) ; v1(265.88,71.95) 266.87,72.94 266.87,73.55 267.19,73.86 CN2062.45
  IN2 w0.079: v1(260.39,110.51) 260.67,110.23 260.67,108.13 260.21,107.67 260.21,105.75 260.59,105.37
  IN2 w0.089: v1(265.88,71.95) 265.63,71.69 265.63,70.68 265.47,70.53 265.25,70.53 265.13,70.65 265.13,87.68 264.58,88.23 264.58,99.96 262.85,101.68 262.85,102.66 262.19,103.32 262.19,104.25 261.83,104.61 261.35,104.61 260.59,105.37
M_B_DQ18: length 48.5
  TOP w0.14: v1(259.46,109.2) 259.69,108.97 U41.BG8 ; CN2062.59 263.69,73.89 263.11,73.32 263.11,72.48 v1(262.61,71.97)
  IN2 w0.079: 258.79,103.03 258.58,103.24 258.58,106.87 258.58,106.88 258.58,107.55 259.05,108.02 259.05,108.79 259.18,108.92 259.18,108.92 v1(259.46,109.2)
  IN2 w0.089: v1(262.61,71.97) 262.3,71.97 261.88,72.39 261.88,78.22 262.07,78.41 262.07,90.15 261.55,90.66 261.55,90.95 261.64,91.04 261.99,91.04 262.08,91.13 262.08,91.31 261.99,91.4 261.64,91.4 261.55,91.49 261.55,91.67 261.64,91.75 261.99,91.75 262.08,91.84 262.08,92.02 261.99,92.11 261.64,92.11 261.55,92.2 261.55,92.38 261.64,92.47 261.99,92.47 262.08,92.55 262.08,92.73 261.99,92.82 261.64,92.82 261.55,92.91 261.55,93.09 261.64,93.18 261.99,93.18 262.08,93.27 262.08,93.44 261.99,93.53 261.64,93.53 261.55,93.62 261.55,93.8 261.64,93.89 261.99,93.89 262.08,93.98 262.08,94.15 261.99,94.24 261.64,94.24 261.55,94.33 261.55,94.51 261.64,94.6 261.99,94.6 262.08,94.69 262.08,94.87 261.99,94.95 261.64,94.95 261.55,95.04 261.55,99.41 260.05,100.91 260.05,101.76 258.79,103.03
M_B_DQ19: length 48.8
  TOP w0.14: U41.BF8 258.9,108.97 v1(258.58,109.28) ; v1(262.64,69.19) 263.93,67.9 CN2062.58
  IN2 w0.079: v1(258.58,109.28) 258.86,109 258.86,108.97 258.89,108.94 258.89,108.09 258.52,107.71 258.42,107.62 258.42,107.01 258.42,107.01 258.42,103.16 258.63,102.95
  IN2 w0.089: v1(262.64,69.19) 262.34,68.89 261.93,68.89 261.81,69.02 261.81,69.58 261.89,69.67 262.31,69.67 262.4,69.76 262.4,69.94 262.31,70.03 261.89,70.03 261.81,70.11 261.81,70.29 261.89,70.38 262.31,70.38 262.4,70.47 262.4,70.65 262.31,70.74 261.89,70.74 261.81,70.83 261.81,72.06 261.58,72.28 261.58,78.33 261.77,78.52 261.77,90.04 261.26,90.54 261.26,99.27 259.75,100.78 259.75,101.83 258.63,102.95
M_B_DQ20: length 49.1
  TOP w0.14: v1(265.87,69.22) 266.93,68.15 CN2062.46 ; U41.BF11 259.41,111.31 v1(259.46,111.31)
  IN2 w0.079: 260.47,105.25 260.05,105.67 260.05,107.73 260.48,108.17 260.48,109.85 259.97,110.37 259.97,110.67 259.46,111.18 v1(259.46,111.31)
  IN2 w0.089: 260.47,105.25 261.28,104.44 261.76,104.44 262.02,104.18 262.02,103.13 262.54,102.61 262.54,101.56 264.28,99.82 264.28,88.04 264.83,87.49 264.83,70.25 v1(265.87,69.22)
M_B_DQ21: length 48.4
  TOP w0.14: U41.BF10 259.08,110.27 v1(259.45,110.64) ; CN2062.50 265.93,67.78 v1(265.86,67.86)
  IN2 w0.089: v1(259.45,110.64) 259.47,110.64 260.23,109.88 260.23,108.15 259.89,107.81 259.89,105.59 261.21,104.27 261.68,104.27 261.85,104.1 261.85,102.82 262.24,102.43 262.24,101.43 263.99,99.68 263.99,87.92 264.54,87.37 264.54,68.31 264.99,67.86 v1(265.86,67.86)
M_B_DQ22: length 48.4
  TOP w0.14: U41.BG7 259.69,108.32 v1(259.46,108.54) ; v1(262.59,73.42) 262.69,73.52 CN2062.63
  IN2 w0.089: v1(259.46,108.54) 259.38,108.46 259.38,104.78 259.77,104.39 259.77,102.95 260.36,102.37 260.36,101.02 261.85,99.54 261.85,99.07 262.04,98.88 262.28,98.88 262.38,98.78 262.38,98.63 262.29,98.54 261.93,98.54 261.85,98.45 261.85,98.27 261.93,98.18 262.29,98.18 262.38,98.09 262.38,97.91 262.29,97.83 261.93,97.83 261.85,97.74 261.85,97.56 261.93,97.47 262.29,97.47 262.38,97.38 262.38,97.2 262.29,97.11 261.93,97.11 261.85,97.02 261.85,96.85 261.93,96.76 262.29,96.76 262.38,96.67 262.38,96.49 262.29,96.4 261.93,96.4 261.85,96.31 261.85,96.14 261.93,96.05 262.29,96.05 262.38,95.96 262.38,95.78 262.29,95.69 261.93,95.69 261.85,95.6 261.85,95.42 261.93,95.34 262.29,95.34 262.38,95.25 262.38,82.52 262.38,82.51 262.38,81.22 262.47,81.13 262.84,81.13 262.93,81.04 262.93,80.87 262.84,80.78 262.47,80.78 262.38,80.69 262.38,80.51 262.47,80.42 262.84,80.42 262.93,80.33 262.93,80.16 262.84,80.07 262.47,80.07 262.38,79.98 262.38,79.8 262.47,79.71 262.84,79.71 262.93,79.62 262.93,79.44 262.84,79.36 262.47,79.36 262.38,79.27 262.38,79.09 262.47,79 262.84,79 262.93,78.91 262.93,78.73 262.84,78.64 262.47,78.64 262.38,78.56 262.38,78.38 262.47,78.29 262.84,78.29 262.93,78.2 262.93,78.02 262.84,77.93 262.47,77.93 262.38,77.84 262.38,77.55 262.19,77.37 262.19,76.07 262.28,75.98 262.36,75.98 262.45,75.89 262.45,75.71 262.36,75.62 262.28,75.62 262.19,75.53 262.19,75.36 262.28,75.27 262.34,75.27 262.43,75.18 262.43,75 262.34,74.91 262.28,74.91 262.19,74.82 262.19,74.65 262.28,74.56 262.35,74.56 262.44,74.47 262.44,74.29 262.35,74.2 262.28,74.2 262.19,74.11 262.19,73.58 262.35,73.42 v1(262.59,73.42)
M_B_DQ23: length 48.4
  TOP w0.14: v1(258.5,108.62) 258.81,108.32 U41.BF7 ; CN2062.62 262.93,67.58 v1(262.63,67.89)
  IN2 w0.089: v1(258.5,108.62) 258.5,108.35 257.61,107.46 257.61,103.63 259.44,101.8 259.44,100.67 260.97,99.15 260.97,90.42 261.46,89.93 261.46,78.62 261.28,78.44 261.28,72.17 261.51,71.94 261.51,66.77 261.64,66.64 262.53,66.64 262.63,66.74 v1(262.63,67.89)
M_B_DQ24: length 49.2
  TOP w0.14: v1(256.72,111.31) 256.32,110.92 U41.BB11 ; v1(260.79,69.22) 260.97,69.22 261.93,68.25 CN2062.66
  IN2 w0.089: v1(256.72,111.31) 257,111.03 257,111.03 257.17,110.85 257.17,110.47 257.63,110.01 257.63,108.2 257.11,107.67 257.11,103.23 258.55,101.78 258.55,99.71 259.66,98.6 259.66,85.84 260.13,85.37 260.13,79.22 259.61,78.7 259.61,70.75 259.91,70.45 259.91,69.13 259.99,69.05 260.62,69.05 v1(260.79,69.22)
M_B_DQ25: length 48.9
  TOP w0.14: CN2062.71 260.69,73.47 v1(260.73,73.42) ; v1(257.65,111.22) 257.35,110.92 U41.BC11
  IN2 w0.089: v1(260.73,73.42) 260.55,73.24 260.37,73.24 260.22,73.39 260.22,73.87 260.31,73.96 260.46,73.96 260.55,74.05 260.55,74.22 260.46,74.31 260.31,74.31 260.22,74.4 260.22,74.58 260.31,74.67 260.46,74.67 260.55,74.76 260.55,74.93 260.46,75.02 260.31,75.02 260.22,75.11 260.22,75.29 260.31,75.38 260.46,75.38 260.55,75.47 260.55,75.65 260.46,75.73 260.31,75.73 260.22,75.82 260.22,76.51 260.41,76.71 260.41,77.01 260.22,77.21 260.22,77.66 260.31,77.75 260.46,77.75 260.55,77.83 260.55,78.01 260.46,78.1 260.31,78.1 260.22,78.19 260.22,78.48 260.74,79 260.74,85.96 260.65,86.05 260.33,86.05 260.25,86.14 260.25,86.43 260.33,86.52 260.65,86.52 260.74,86.61 260.74,86.78 260.65,86.87 260.33,86.87 260.25,86.96 260.25,87.14 260.33,87.23 260.65,87.23 260.74,87.32 260.74,87.49 260.65,87.58 260.33,87.58 260.25,87.67 260.25,87.85 260.33,87.94 260.65,87.94 260.74,88.03 260.74,88.21 260.65,88.29 260.33,88.29 260.25,88.38 260.25,88.56 260.33,88.65 260.65,88.65 260.74,88.74 260.74,88.92 260.65,89.01 260.33,89.01 260.25,89.1 260.25,89.27 260.33,89.36 260.65,89.36 260.74,89.45 260.74,89.63 260.65,89.72 260.33,89.72 260.25,89.81 260.25,98.85 259.01,100.08 259.01,101.95 257.44,103.52 257.44,107.53 258.04,108.13 258.04,110.79 258.15,110.9 258.15,111.18 258.02,111.31 257.74,111.31 v1(257.65,111.22)
M_B_DQ26: length 49.3
  TOP w0.14: v1(257.63,72.05) 258.69,73.11 CN2062.79 ; U41.BB8 256.05,108.97 v1(255.81,109.2)
  IN2 w0.089: v1(257.63,72.05) 257.4,72.05 257.21,71.86 257.21,69.64 257.07,69.5 256.94,69.5 256.76,69.68 256.76,72.29 256.85,72.38 257.18,72.38 257.27,72.47 257.27,72.65 257.18,72.74 256.85,72.74 256.76,72.83 256.76,79.8 257.46,80.51 257.46,101 255.53,102.93 255.53,107.69 256.31,108.47 256.31,109.16 256.14,109.32 255.94,109.32 v1(255.81,109.2)
M_B_DQ27: length 49.4
  TOP w0.14: U41.BC8 256.97,108.97 v1(256.72,109.21) ; v1(257.65,67.96) 257.44,67.74 CN2062.84
  IN2 w0.079: v1(256.72,109.21) 256.49,109.21 256.1,109.6 255.61,109.6 255.38,109.37 255.38,108.38 255.33,108.33
  IN2 w0.089: v1(257.65,67.96) 257.65,67.1 257.58,67.02 256.31,67.02 256.16,67.17 256.16,80.03 256.88,80.75 256.88,101.03 255.14,102.77 255.14,108.14 255.33,108.33
M_B_DQ28: length 49.1
  TOP w0.14: U41.BC10 257.34,110.27 v1(257.64,110.57) ; CN2062.67 261.69,72.91 v1(260.75,71.97)
  IN2 w0.089: v1(260.75,71.97) 260.63,71.85 260.63,70.21 260.49,70.07 260.29,70.07 260.2,70.16 260.2,70.74 259.91,71.04 259.91,72.24 260,72.33 260.27,72.33 260.36,72.42 260.36,72.59 260.27,72.68 260,72.68 259.91,72.77 259.91,78.59 260.43,79.11 260.43,85.48 259.95,85.96 259.95,98.73 258.78,99.9 258.78,101.84 257.27,103.35 257.27,107.6 257.8,108.13 257.8,110.4 v1(257.64,110.57)
M_B_DQ29: length 49
  TOP w0.14: CN2062.70 260.93,67.73 v1(260.78,67.89) ; U41.BB10 256.33,110.27 v1(256.71,110.65)
  IN2 w0.089: v1(260.78,67.89) 260.78,67.43 260.62,67.28 259.87,67.28 259.62,67.53 259.62,70.32 259.3,70.64 259.3,78.81 259.78,79.29 259.78,85.31 259.37,85.72 259.37,98.5 258.33,99.54 258.33,101.65 256.89,103.09 256.89,107.69 257.47,108.27 257.47,109.94 256.75,110.65 v1(256.71,110.65)
M_B_DQ30: length 48.9
  TOP w0.14: CN2062.83 257.69,73.58 v1(257.61,73.5) ; v1(256.71,108.56) 256.96,108.32 U41.BC7
  IN2 w0.089: v1(256.71,108.56) 256.71,108.23 256.54,108.06 256.14,108.06 255.69,107.62 255.69,103.02 256.22,102.49 256.6,102.49 257.72,101.38 257.72,98.23 257.75,98.19 257.75,84.81 257.84,84.73 258.08,84.73 258.17,84.64 258.17,84.46 258.08,84.37 257.84,84.37 257.75,84.28 257.75,84.1 257.84,84.01 258.08,84.01 258.17,83.93 258.17,83.75 258.08,83.66 257.84,83.66 257.75,83.57 257.75,83.39 257.84,83.3 258.08,83.3 258.17,83.21 258.17,83.04 258.08,82.95 257.84,82.95 257.75,82.86 257.75,82.68 257.84,82.59 258.08,82.59 258.17,82.5 258.17,82.33 258.08,82.24 257.84,82.24 257.75,82.15 257.75,81.97 257.84,81.88 258.08,81.88 258.17,81.79 258.17,81.61 258.08,81.53 257.84,81.53 257.75,81.44 257.75,81.26 257.84,81.17 258.08,81.17 258.17,81.08 258.17,80.9 258.08,80.81 257.84,80.81 257.75,80.73 257.75,80.55 257.84,80.46 258.08,80.46 258.17,80.37 258.17,79.96 257.98,79.76 257.85,79.76 257.55,80.06 257.43,80.06 257.3,79.93 257.3,79.81 257.6,79.51 257.6,79.39 257.53,79.32 257.2,79.32 257.05,79.17 257.05,78.72 257.14,78.63 257.33,78.63 257.42,78.54 257.42,78.36 257.33,78.27 257.14,78.27 257.05,78.19 257.05,78.01 257.14,77.92 257.33,77.92 257.42,77.83 257.42,77.65 257.33,77.56 257.14,77.56 257.05,77.47 257.05,77.3 257.14,77.21 257.33,77.21 257.42,77.12 257.42,76.94 257.33,76.85 257.14,76.85 257.05,76.76 257.05,76.59 257.14,76.5 257.33,76.5 257.42,76.41 257.42,76.23 257.33,76.14 257.14,76.14 257.05,76.05 257.05,75.87 257.14,75.78 257.33,75.78 257.42,75.7 257.42,75.52 257.33,75.43 257.14,75.43 257.05,75.34 257.05,75.16 257.14,75.07 257.33,75.07 257.42,74.98 257.42,74.81 257.33,74.72 257.14,74.72 257.05,74.63 257.05,74.45 257.14,74.36 257.33,74.36 257.42,74.27 257.42,74.1 257.33,74.01 257.14,74.01 257.05,73.92 257.05,73.37 257.18,73.24 257.35,73.24 v1(257.61,73.5)
M_B_DQ31: length 49.3
  TOP w0.14: U41.BB7 256.25,108.3 256.04,108.3 v1(255.81,108.54) ; v1(257.66,69.35) 258.26,68.75 258.26,68.01 258.44,67.84 CN2062.80
  IN2 w0.089: v1(255.81,108.54) 255.8,108.54 255.36,108.1 255.36,102.83 257.17,101.02 257.17,80.63 256.45,79.91 256.45,68.34 256.54,68.25 256.73,68.25 256.81,68.16 256.81,67.98 256.73,67.89 256.54,67.89 256.45,67.8 256.45,67.51 256.56,67.4 257.14,67.4 257.26,67.53 257.26,68.95 v1(257.66,69.35)
M_B_DQ32: length 51.2
  TOP w0.14: U41.AA11 239.66,110.92 v1(239.34,111.24) ; CN2062.186 229.94,67.5 v1(230.42,67.99)
  IN2 w0.089: v1(239.34,111.24) 239.34,110.95 238.46,110.07 238.46,108.31 237.84,107.69 237.72,107.69 237.52,107.49 237.52,104.26 237.38,104.12 237.38,102.4 235.64,100.67 235.64,94.89 228,87.25 228,70.41 v1(230.42,67.99)
M_B_DQ33: length 50.7
  TOP w0.14: v1(239.37,109.98) 239.66,110.27 U41.AA10 ; v1(229.23,73.37) 229.69,73.83 CN2062.187
  IN2 w0.079: 238.26,102.51 238.5,102.75 238.5,104.14 238.68,104.33 239.07,104.33 239.28,104.54 239.28,107.49 238.94,107.84 238.94,109.75 239.16,109.98 v1(239.37,109.98)
  IN2 w0.089: 238.26,102.51 236.56,100.8 236.56,94.56 236.24,94.24 236.24,94.07 236.56,93.75 236.56,93.64 236.35,93.44 236.22,93.44 235.89,93.77 235.76,93.77 235.64,93.64 235.64,93.52 235.97,93.18 235.97,93.06 235.84,92.93 235.72,92.93 235.39,93.26 235.26,93.26 235.14,93.14 235.14,93.01 235.47,92.68 235.47,92.56 235.34,92.43 235.22,92.43 234.88,92.76 234.76,92.76 234.63,92.64 234.63,92.51 234.96,92.18 234.96,92.05 234.84,91.93 234.71,91.93 234.38,92.26 234.26,92.26 234.13,92.13 234.13,92.01 234.46,91.67 234.46,91.55 234.34,91.42 234.21,91.42 233.88,91.76 233.75,91.76 233.63,91.63 233.63,91.5 233.96,91.17 233.96,91.05 233.83,90.92 233.71,90.92 233.38,91.25 233.25,91.25 233.12,91.13 233.12,91 233.46,90.67 233.46,90.54 229.02,86.11 229.02,77.56 228.92,77.46 228.92,73.5 229.05,73.37 v1(229.23,73.37)
M_B_DQ34: length 51.5
  TOP w0.14: U41.AC11 240.61,110.92 v1(240.26,111.26) ; v1(230.45,69.43) 230.94,68.95 CN2062.182
  IN2 w0.079: 238.01,102.8 238.18,102.97 238.18,104.27 238.32,104.41 238.32,107.17 238.62,107.47 238.62,110.01 239.31,110.7 239.7,110.7 v1(240.26,111.26)
  IN2 w0.089: 238.01,102.8 235.97,100.76 235.97,94.8 228.31,87.14 228.31,71.57 v1(230.45,69.43)
M_B_DQ35: length 51.6
  TOP w0.14: v1(229.18,72.03) 229.23,72.03 229.84,72.64 229.84,72.98 230.69,73.83 CN2062.183 ; v1(240.26,110.61) 240.6,110.27 U41.AC10
  IN2 w0.079: 238.04,102.59 238.34,102.89 238.34,104.21 238.48,104.34 238.48,107.11 238.78,107.41 238.78,109.94 239.31,110.47 240.11,110.47 v1(240.26,110.61)
  IN2 w0.089: v1(229.18,72.03) 228.61,72.59 228.61,86.11 230.93,88.43 230.93,88.63 230.76,88.8 230.76,88.92 230.89,89.05 231.01,89.05 231.18,88.88 231.31,88.88 231.43,89.01 231.43,89.14 231.27,89.3 231.27,89.43 231.39,89.55 231.52,89.55 231.68,89.39 231.81,89.39 231.93,89.51 231.93,89.64 231.64,89.93 231.64,90.06 231.77,90.18 231.89,90.18 232.19,89.89 232.31,89.89 232.44,90.02 232.44,90.14 232.14,90.44 232.14,90.56 232.27,90.69 232.4,90.69 232.69,90.39 232.81,90.39 232.94,90.52 232.94,90.64 232.65,90.94 232.65,91.06 236.26,94.68 236.26,100.82 238.04,102.59
M_B_DQ36: length 51.1
  TOP w0.14: v1(232.61,71.97) 234.18,73.55 CN2062.169 ; U41.AA7 240,108.32 v1(240.31,108.62)
  IN2 w0.089: v1(240.31,108.62) 240.18,108.49 240.18,107.38 239.84,107.04 239.84,103.1 238.17,101.43 238.17,92.87 230.64,85.34 230.64,79.84 230.73,79.75 231.31,79.75 231.4,79.66 231.4,79.48 231.31,79.39 230.73,79.39 230.64,79.31 230.64,79.13 230.73,79.04 231.31,79.04 231.4,78.95 231.4,78.77 231.31,78.68 230.73,78.68 230.64,78.59 230.64,78.42 230.73,78.33 231.31,78.33 231.4,78.24 231.4,78.06 231.31,77.97 230.73,77.97 230.64,77.88 230.64,77.59 230.79,77.44 231.26,77.44 231.4,77.31 231.4,76.53 231.31,76.45 231.14,76.45 231.05,76.36 231.05,76.18 231.14,76.09 231.31,76.09 231.4,76 231.4,75.82 231.31,75.73 231.14,75.73 231.05,75.65 231.05,75.47 231.14,75.38 231.31,75.38 231.4,75.29 231.4,75.11 231.31,75.02 231.14,75.02 231.05,74.93 231.05,74.58 231.82,73.81 231.82,73.12 232.22,72.72 232.22,72.47 232.61,72.09 v1(232.61,71.97)
M_B_DQ37: length 51.3
  TOP w0.14: U41.AA8 239.95,108.97 v1(240.3,109.32) ; CN2062.173 233.18,73.9 v1(232.58,73.3)
  IN2 w0.089: v1(240.3,109.32) 240.74,108.88 240.74,108.12 240.58,107.97 240.58,107.51 240,106.93 240,103.03 238.46,101.48 238.46,92.73 231.69,85.95 231.69,85.21 231.6,85.13 231.02,85.13 230.93,85.04 230.93,84.86 231.02,84.77 231.6,84.77 231.69,84.68 231.69,84.5 231.6,84.41 231.02,84.41 230.93,84.33 230.93,84.15 231.02,84.06 231.6,84.06 231.69,83.97 231.69,83.79 231.6,83.7 231.02,83.7 230.93,83.61 230.93,83.44 231.02,83.35 231.6,83.35 231.69,83.26 231.69,83.08 231.6,82.99 231.02,82.99 230.93,82.9 230.93,82.73 231.02,82.64 231.6,82.64 231.69,82.55 231.69,82.37 231.6,82.28 231.02,82.28 230.93,82.19 230.93,82.01 231.02,81.92 231.6,81.92 231.69,81.84 231.69,81.66 231.6,81.57 231.02,81.57 230.93,81.48 230.93,81.3 231.02,81.21 231.6,81.21 231.69,81.12 231.69,80.95 231.6,80.86 231.27,80.86 231.19,80.77 231.19,80.59 231.27,80.5 231.6,80.5 231.69,80.41 231.69,75.31 232.35,74.64 232.35,73.52 v1(232.58,73.3)
M_B_DQ38: length 50.9
  TOP w0.14: v1(232.58,67.96) 232.94,67.61 CN2062.174 ; v1(241.15,109.3) 240.82,108.97 U41.AC8
  IN2 w0.079: 239.05,101.18 239.05,101.61 240.96,103.53 240.96,107.74 241.39,108.17 241.39,108.29 241.55,108.44 241.55,108.83 241.15,109.22 v1(241.15,109.3)
  IN2 w0.089: 239.05,101.18 239.05,92.43 232.27,85.66 232.27,75.6 232.97,74.9 232.97,74.19 233.99,73.18 233.99,69.66 233.9,69.57 233.61,69.57 233.52,69.48 233.52,69.3 233.61,69.21 233.9,69.21 233.99,69.12 233.99,68.95 233.9,68.86 233.61,68.86 233.52,68.77 233.52,68.59 233.61,68.5 233.9,68.5 233.99,68.41 233.99,68.12 233.83,67.96 v1(232.58,67.96)
M_B_DQ39: length 51.3
  TOP w0.14: CN2062.170 233.94,67.93 v1(232.58,69.28) ; v1(241.15,108.65) 240.82,108.32 U41.AC7
  IN2 w0.079: 238.75,101.14 238.75,101.54 240.81,103.59 240.81,107.81 241.15,108.15 v1(241.15,108.65)
  IN2 w0.089: 238.75,101.14 238.75,92.59 231.98,85.81 231.98,75.45 232.66,74.77 232.66,74.06 233.69,73.02 233.69,72.64 233.6,72.55 233.15,72.55 233.07,72.46 233.07,72.29 233.15,72.2 233.6,72.2 233.69,72.11 233.69,71.93 233.6,71.84 233.15,71.84 233.07,71.75 233.07,71.57 233.15,71.49 233.6,71.49 233.69,71.4 233.69,71.22 233.6,71.13 233.15,71.13 233.07,71.04 233.07,70.86 233.15,70.77 233.6,70.77 233.69,70.69 233.69,70.39 v1(232.58,69.28)
M_B_DQ40: length 52
  TOP w0.14: U41.W8 237.86,108.97 v1(237.53,109.3) ; v1(227.12,70.35) 228.36,69.11 228.36,68.29 228.94,67.72 CN2062.190
  IN2 w0.079: v1(237.53,109.3) 237.96,108.87 237.96,108.52 237.62,108.19 237.5,108.19 237.02,107.7 237.02,105.13 235.85,103.96 235.85,101.77 235.59,101.51
  IN2 w0.089: 235.59,101.51 234.67,100.59 234.67,99.36 234.31,99 234.31,95.77 226.07,87.53 226.07,85.91 226.15,85.82 226.61,85.82 226.7,85.74 226.7,85.56 226.61,85.47 226.15,85.47 226.07,85.38 226.07,85.2 226.15,85.11 226.61,85.11 226.7,85.02 226.7,84.85 226.61,84.76 226.15,84.76 226.07,84.67 226.07,73.62 226.18,73.5 226.18,71.62 226.45,71.35 226.45,70.56 226.66,70.35 v1(227.12,70.35)
M_B_DQ41: length 52
  TOP w0.14: v1(227.12,68.95) 227.58,68.5 227.58,68.27 227.94,67.91 CN2062.194 ; U41.W7 237.87,108.32 v1(237.53,108.65)
  IN2 w0.079: v1(237.53,108.65) 237.53,108.49 236.86,107.83 236.86,105.19 235.69,104.02 235.69,101.89 235.46,101.66
  IN2 w0.089: 235.46,101.66 234.37,100.58 234.37,99.5 234.01,99.13 234.01,95.9 225.76,87.66 225.76,73.43 225.89,73.3 225.89,71.34 226.02,71.21 226.02,68.35 226.33,68.04 227.73,68.04 227.86,68.16 227.86,68.8 227.7,68.95 v1(227.12,68.95)
M_B_DQ42: length 51.5
  TOP w0.14: CN2062.204 225.43,67.43 224.51,68.36 224.51,68.88 v1(223.95,69.43) ; v1(236.63,110.54) 236.9,110.27 U41.V10
  IN2 w0.079: v1(236.63,110.54) 236.22,110.13 236.22,109.51 236.01,109.3 236.01,108.93 234.63,107.55 234.63,106.77 234.59,106.73 234.59,106.62
  IN2 w0.089: v1(223.95,69.43) 223.54,69.43 222.91,70.07 222.91,88.23 231.78,97.1 231.78,100.06 233.99,102.27 233.99,102.95 234.59,103.54 234.59,106.62
M_B_DQ43: length 51.7
  TOP w0.14: U41.V11 236.92,110.92 v1(236.63,111.21) ; CN2062.208 224.43,67.63 v1(223.95,68.11)
  IN2 w0.079: v1(236.63,111.21) 236.35,110.93 236.35,110.93 236.15,110.74 236.15,110.36 236.06,110.27 236.06,109.57 235.82,109.33 235.82,108.95 234.48,107.61 234.48,106.86 234.42,106.81 234.42,106.6
  IN2 w0.089: v1(223.95,68.11) 222.62,69.44 222.62,88.37 231.48,97.23 231.48,100.17 233.74,102.43 233.74,102.93 234.42,103.61 234.42,106.6
