# Allegro board DAZGLMB1ED0 dazglmb1ed0-d-ver a-165 (.BRD) .brd (continued)
## Nets (continued)
FBVDDQ_MEM: C95082.2 C95083.2 C95084.2 C95085.1 C95086.2 C95087.1 C95088.2 C95089.1 C95090.2 C95091.1 C95092.2 C95093.1 C95094.2 C95095.1 C95096.2 C95097.1 C95098.2 C95099.1 C95100.2 C95101.1 C95102.2 C95103.1 C95104.2 C95105.1 C95106.2 C95107.1 C95108.2 C95109.1 C95110.2 C95111.1 C95112.2 C95113.1 C95114.2 C95115.1 C95116.2 C95117.1 C95118.2 C95119.1 C95120.2 C95121.2 C95122.2 C95123.2 C95124.1 C95125.1 C95126.1 C95127.1 C95128.1 C95129.1 C95130.1 C95674.1 C95675.1 C95676.1 C95677.1 C95678.1 C95679.2 C95680.2 C95681.2 C95682.2 C95683.2 C95684.2 C95685.2 C95686.2 C95687.1 C95688.1 C95689.1 C95690.1 C95694.1 C95695.1 C95696.1 C95697.1 C95698.1 C95699.2 C95700.2 C95701.2 C95702.2 C95703.2 C95704.2 C95705.2 C95706.2 C95707.1 C95708.1 C95709.1 C95710.1 C95714.1 C95715.1 C95716.1 C95717.1 C95718.1 C95719.2 C95720.2 C95721.2 C95722.2 C95723.2 C95724.2 C95725.2 C95726.2 C95727.1 C95728.1 C95729.1 C95730.1 C95734.1 C95735.1 C95736.1 C95737.1 C95738.1 C95739.2 C95740.2 C95741.2 C95742.2 C95743.2 C95744.2 C95745.2 C95746.2 C95747.1 C95748.1 C95749.1 C95750.1 C95754.1 C95755.1 C95756.1 C95757.1 C95758.1 C95759.2 C95760.2 C95761.2 C95762.2 C95763.2 C95764.2 C95765.2 C95766.2 C95767.1 C95768.1 C95769.1 C95770.1 C95774.1 C95775.1 C95776.1 C95777.1 C95778.1 C95779.2 C95780.2 C95781.2 C95782.2 C95783.2 C95784.2 C95785.2 C95786.2 C95787.1 C95788.1 C95789.1 C95790.1 C95794.1 C95795.1 C95796.1 C95797.1 C95798.1 C95799.2 C95800.2 C95801.2 C95802.2 C95803.2 C95804.2 C95805.2 C95806.2 C95807.1 C95808.1 C95809.1 C95810.1 C95814.1 C95815.1 C95816.1 C95817.1 C95818.1 C95819.2 C95820.2 C95821.2 C95822.2 C95823.2 C95824.2 C95825.2 C95826.2 C95827.1 C95828.1 C95829.1 C95830.1 C95928.1 C95929.1 C95930.1 C96042.1 C96043.2 C96045.2 C96046.2 C96047.2 C96049.2 C96051.2 C96052.2 C96053.1 C96054.2 C96057.1 C96058.1 C96059.2 C96060.2 C96061.1 C96062.2 C96063.2 C96064.2 C96065.2 C96066.2 C96067.2 C96068.2 C96069.1 C96070.2 C96071.1 C96072.1 C96073.2 C96074.2 C96075.1 C96076.2 C96077.2 C96078.2 C96079.2 C96080.2 C96081.2 C96082.2 C96083.1 C96084.2 C96085.1 C96086.1 C96087.2 C96088.2 C96089.1 C96090.2 C96091.2 C96092.2 C96093.2 C96094.2 C96095.2 C96096.2 C96097.1 C96098.2 C96099.1 C96100.1 C96101.2 C96102.2 C96103.1 C96104.2 C96105.2 C96106.2 C96107.2 C96108.2 C96109.2 C96110.2 C96111.1 C96112.2 C96113.1 C96114.1 C96115.2 C96116.2 C96117.1 C96118.2 C96119.2 C96120.2 C96121.2 C96122.2 C96123.2 C96124.2 C96125.1 C96126.2 C96127.1 C96128.1 C96129.2 C96130.2 C96131.1 C96132.2 C96133.2 C96134.2 C96135.2 C96136.2 C96137.2 C96138.2 C96139.1 C96140.2 C96141.1 C96142.1 C96143.2 C96144.2 C96145.1 C96146.2 C96147.2 C96148.2 C96149.2 C96150.2 C96151.2 C96152.2 C96153.1 C96154.2 C96155.1 C96156.1 C96157.2 C96158.2 PC9110.1 PC9305.1 PC9324.1 PC9325.1 PC9326.1 PC9443.1 PC9444.1 PC9446.1 PC9492.1 PC9493.1 PL9017.2 PL9023.2 PR9136.1 PR9208.1 R21503.2 R21504.2 R21510.2 R21511.2 R21512.2 R21513.2 R21522.2 R21523.2 R21604.1 R21859.1 R21864.1 R21869.1 R21874.1 R22010.1 R22012.1 R22014.1 R22016.1 R22018.1 R22020.1 R22023.1 R22025.1 U13114.AA10(FBVDDQ_01) U13114.AA11(FBVDDQ_02) U13114.AA42(FBVDDQ_03) U13114.AA43(FBVDDQ_04) U13114.AC10(FBVDDQ_05) U13114.AC11(FBVDDQ_06) U13114.AC42(FBVDDQ_07) U13114.AC43(FBVDDQ_08) U13114.AD10(FBVDDQ_09) U13114.AD11(FBVDDQ_10) U13114.AD42(FBVDDQ_11) U13114.AD43(FBVDDQ_12) U13114.AF10(FBVDDQ_13) U13114.AF43(FBVDDQ_14) U13114.AG10(FBVDDQ_15) U13114.AG11(FBVDDQ_16) U13114.AG42(FBVDDQ_17) U13114.AG43(FBVDDQ_18) U13114.AJ10(FBVDDQ_19) U13114.AJ11(FBVDDQ_20) U13114.AJ42(FBVDDQ_21) U13114.AJ43(FBVDDQ_22) U13114.AK10(FBVDDQ_23) U13114.AK11(FBVDDQ_24) U13114.AK42(FBVDDQ_25) U13114.AK43(FBVDDQ_26) U13114.AM42(FBVDDQ_27) U13114.AM43(FBVDDQ_28) U13114.AN43(FBVDDQ_29) U13114.AR42(FBVDDQ_30) U13114.AR43(FBVDDQ_31) U13114.AT43(FBVDDQ_32) U13114.K12(FBVDDQ_33) U13114.K14(FBVDDQ_34) U13114.K15(FBVDDQ_35) U13114.K17(FBVDDQ_36) U13114.K18(FBVDDQ_37) U13114.K20(FBVDDQ_38) U13114.K21(FBVDDQ_39) U13114.K23(FBVDDQ_40) U13114.K24(FBVDDQ_41) U13114.K26(FBVDDQ_42) U13114.K27(FBVDDQ_43) U13114.K29(FBVDDQ_44) U13114.K30(FBVDDQ_45) U13114.K32(FBVDDQ_46) U13114.K33(FBVDDQ_47) U13114.K35(FBVDDQ_48) U13114.K36(FBVDDQ_49) U13114.K38(FBVDDQ_50) U13114.K39(FBVDDQ_51) U13114.K41(FBVDDQ_52) U13114.L14(FBVDDQ_53) U13114.L15(FBVDDQ_54) U13114.L18(FBVDDQ_55) U13114.L20(FBVDDQ_56) U13114.L21(FBVDDQ_57) U13114.L23(FBVDDQ_58) U13114.L24(FBVDDQ_59) U13114.L26(FBVDDQ_60) U13114.L27(FBVDDQ_61) U13114.L30(FBVDDQ_62) U13114.L32(FBVDDQ_63) U13114.L33(FBVDDQ_64) U13114.L35(FBVDDQ_65) U13114.L36(FBVDDQ_66) U13114.L39(FBVDDQ_67) U13114.M10(FBVDDQ_68) U13114.M43(FBVDDQ_69) U13114.P10(FBVDDQ_70) U13114.P11(FBVDDQ_71) U13114.P42(FBVDDQ_72) U13114.P43(FBVDDQ_73) U13114.R10(FBVDDQ_74) U13114.R11(FBVDDQ_75) U13114.R42(FBVDDQ_76) U13114.R43(FBVDDQ_77) U13114.U10(FBVDDQ_78) U13114.U11(FBVDDQ_79) U13114.U43(FBVDDQ_80) U13114.V10(FBVDDQ_81) U13114.V42(FBVDDQ_82) U13114.V43(FBVDDQ_83) U13114.Y10(FBVDDQ_84) U13114.Y11(FBVDDQ_85) U13114.Y42(FBVDDQ_86) U13114.Y43(FBVDDQ_87) U13135.A1(VDD_1) U13135.A2(VDDQ_2) U13135.A4(VDD_4) U13135.A11(VDD_2) U13135.A13(VDDQ_1) U13135.A14(VDD_3) U13135.B5(VDDQ_4) U13135.B10(VDDQ_3) U13135.C1(VDDQ_5) U13135.C2(VDDQ_8) U13135.C13(VDDQ_6) U13135.C14(VDDQ_7) U13135.D10(VDD_5) U13135.E1(VDDQ_9) U13135.E2(VDDQ_13) U13135.E4(VDDQ_14) U13135.E11(VDDQ_10) U13135.E13(VDDQ_11) U13135.E14(VDDQ_12) U13135.F5(VDDQ_16) U13135.F10(VDDQ_15) U13135.G1(VDD_6) U13135.G2(VDDQ_18) U13135.G13(VDDQ_17) U13135.G14(VDD_7) U13135.H3(VDDQ_20) U13135.H5(VDD_9) U13135.H10(VDD_8) U13135.H12(VDDQ_19) U13135.J1(VDD_10) U13135.J2(VDDQ_22) U13135.J13(VDDQ_21) U13135.J14(VDD_11) U13135.L1(VDD_12) U13135.L2(VDDQ_24) U13135.L13(VDDQ_23) U13135.L14(VDD_13) U13135.M3(VDDQ_26) U13135.M5(VDD_15) U13135.M10(VDD_14) U13135.M12(VDDQ_25) U13135.N1(VDD_16) U13135.N2(VDDQ_28) U13135.N13(VDDQ_27) U13135.N14(VDD_17) U13135.P5(VDDQ_30) U13135.P10(VDDQ_29) U13135.R1(VDDQ_31) U13135.R2(VDDQ_35) U13135.R4(VDDQ_36) U13135.R11(VDDQ_32) U13135.R13(VDDQ_33) U13135.R14(VDDQ_34) U13135.T10(VDD_18) U13135.U1(VDDQ_37) U13135.U2(VDDQ_40) U13135.U13(VDDQ_38) U13135.U14(VDDQ_39) U13135.V5(VDDQ_42) U13135.V10(VDDQ_41) U13135.W1(VDD_19) U13135.W2(VDDQ_44) U13135.W4(VDD_22) U13135.W11(VDD_20) U13135.W12(MF) U13135.W13(VDDQ_43) U13135.W14(VDD_21) U13136.A1(VDD_1) U13136.A2(VDDQ_2) U13136.A4(VDD_4) U13136.A11(VDD_2) U13136.A13(VDDQ_1) U13136.A14(VDD_3) U13136.B5(VDDQ_4) U13136.B10(VDDQ_3) U13136.C1(VDDQ_5) U13136.C2(VDDQ_8) U13136.C13(VDDQ_6) U13136.C14(VDDQ_7) U13136.D10(VDD_5) U13136.E1(VDDQ_9) U13136.E2(VDDQ_13) U13136.E4(VDDQ_14) U13136.E11(VDDQ_10) U13136.E13(VDDQ_11) U13136.E14(VDDQ_12) U13136.F5(VDDQ_16) U13136.F10(VDDQ_15) U13136.G1(VDD_6) U13136.G2(VDDQ_18) U13136.G13(VDDQ_17) U13136.G14(VDD_7) U13136.H3(VDDQ_20) U13136.H5(VDD_9) U13136.H10(VDD_8) U13136.H12(VDDQ_19) U13136.J1(VDD_10) U13136.J2(VDDQ_22) U13136.J13(VDDQ_21) U13136.J14(VDD_11) U13136.L1(VDD_12) U13136.L2(VDDQ_24) U13136.L13(VDDQ_23) U13136.L14(VDD_13) U13136.M3(VDDQ_26) U13136.M5(VDD_15) U13136.M10(VDD_14) U13136.M12(VDDQ_25) U13136.N1(VDD_16) U13136.N2(VDDQ_28) U13136.N13(VDDQ_27) U13136.N14(VDD_17) U13136.P5(VDDQ_30) U13136.P10(VDDQ_29) U13136.R1(VDDQ_31) U13136.R2(VDDQ_35) U13136.R4(VDDQ_36) U13136.R11(VDDQ_32) U13136.R13(VDDQ_33) U13136.R14(VDDQ_34) U13136.T10(VDD_18) U13136.U1(VDDQ_37) U13136.U2(VDDQ_40) U13136.U13(VDDQ_38) U13136.U14(VDDQ_39) U13136.V5(VDDQ_42) U13136.V10(VDDQ_41) U13136.W1(VDD_19) U13136.W2(VDDQ_44) U13136.W4(VDD_22) U13136.W11(VDD_20) U13136.W13(VDDQ_43) U13136.W14(VDD_21) U13137.A1(VDD_1) U13137.A2(VDDQ_2) U13137.A4(VDD_4) U13137.A11(VDD_2) U13137.A13(VDDQ_1) U13137.A14(VDD_3) U13137.B5(VDDQ_4) U13137.B10(VDDQ_3) U13137.C1(VDDQ_5) U13137.C2(VDDQ_8) U13137.C13(VDDQ_6) U13137.C14(VDDQ_7) U13137.D10(VDD_5) U13137.E1(VDDQ_9) U13137.E2(VDDQ_13) U13137.E4(VDDQ_14) U13137.E11(VDDQ_10) U13137.E13(VDDQ_11) U13137.E14(VDDQ_12) U13137.F5(VDDQ_16) U13137.F10(VDDQ_15) U13137.G1(VDD_6) U13137.G2(VDDQ_18) U13137.G13(VDDQ_17) U13137.G14(VDD_7) U13137.H3(VDDQ_20) U13137.H5(VDD_9) U13137.H10(VDD_8) U13137.H12(VDDQ_19) U13137.J1(VDD_10) U13137.J2(VDDQ_22) U13137.J13(VDDQ_21) U13137.J14(VDD_11) U13137.L1(VDD_12) U13137.L2(VDDQ_24) U13137.L13(VDDQ_23) U13137.L14(VDD_13) U13137.M3(VDDQ_26) U13137.M5(VDD_15) U13137.M10(VDD_14) U13137.M12(VDDQ_25) U13137.N1(VDD_16) U13137.N2(VDDQ_28) U13137.N13(VDDQ_27) U13137.N14(VDD_17) U13137.P5(VDDQ_30) U13137.P10(VDDQ_29) U13137.R1(VDDQ_31) U13137.R2(VDDQ_35) U13137.R4(VDDQ_36) U13137.R11(VDDQ_32) U13137.R13(VDDQ_33) U13137.R14(VDDQ_34) U13137.T10(VDD_18) U13137.U1(VDDQ_37) U13137.U2(VDDQ_40) U13137.U13(VDDQ_38) U13137.U14(VDDQ_39) U13137.V5(VDDQ_42) U13137.V10(VDDQ_41) U13137.W1(VDD_19) U13137.W2(VDDQ_44) U13137.W4(VDD_22) U13137.W11(VDD_20) U13137.W12(MF) U13137.W13(VDDQ_43) U13137.W14(VDD_21) U13138.A1(VDD_1) U13138.A2(VDDQ_2) U13138.A4(VDD_4) U13138.A11(VDD_2) U13138.A13(VDDQ_1) U13138.A14(VDD_3) U13138.B5(VDDQ_4) U13138.B10(VDDQ_3) U13138.C1(VDDQ_5) U13138.C2(VDDQ_8) U13138.C13(VDDQ_6) U13138.C14(VDDQ_7) U13138.D10(VDD_5) U13138.E1(VDDQ_9) U13138.E2(VDDQ_13) U13138.E4(VDDQ_14) U13138.E11(VDDQ_10) U13138.E13(VDDQ_11) U13138.E14(VDDQ_12) U13138.F5(VDDQ_16) U13138.F10(VDDQ_15) U13138.G1(VDD_6) U13138.G2(VDDQ_18) U13138.G13(VDDQ_17) U13138.G14(VDD_7) U13138.H3(VDDQ_20) U13138.H5(VDD_9) U13138.H10(VDD_8) U13138.H12(VDDQ_19) U13138.J1(VDD_10) U13138.J2(VDDQ_22) U13138.J13(VDDQ_21) U13138.J14(VDD_11) U13138.L1(VDD_12) U13138.L2(VDDQ_24) U13138.L13(VDDQ_23) U13138.L14(VDD_13) U13138.M3(VDDQ_26) U13138.M5(VDD_15) U13138.M10(VDD_14) U13138.M12(VDDQ_25) U13138.N1(VDD_16) U13138.N2(VDDQ_28) U13138.N13(VDDQ_27) U13138.N14(VDD_17) U13138.P5(VDDQ_30) U13138.P10(VDDQ_29) U13138.R1(VDDQ_31) U13138.R2(VDDQ_35) U13138.R4(VDDQ_36) U13138.R11(VDDQ_32) U13138.R13(VDDQ_33) U13138.R14(VDDQ_34) U13138.T10(VDD_18) U13138.U1(VDDQ_37) U13138.U2(VDDQ_40) U13138.U13(VDDQ_38) U13138.U14(VDDQ_39) U13138.V5(VDDQ_42) U13138.V10(VDDQ_41) U13138.W1(VDD_19) U13138.W2(VDDQ_44) U13138.W4(VDD_22) U13138.W11(VDD_20) U13138.W13(VDDQ_43) U13138.W14(VDD_21) U13139.A1(VDD_1) U13139.A2(VDDQ_2) U13139.A4(VDD_4) U13139.A11(VDD_2) U13139.A13(VDDQ_1) U13139.A14(VDD_3) U13139.B5(VDDQ_4) U13139.B10(VDDQ_3) U13139.C1(VDDQ_5) U13139.C2(VDDQ_8) U13139.C13(VDDQ_6) U13139.C14(VDDQ_7) U13139.D10(VDD_5) U13139.E1(VDDQ_9) U13139.E2(VDDQ_13) U13139.E4(VDDQ_14) U13139.E11(VDDQ_10) U13139.E13(VDDQ_11) U13139.E14(VDDQ_12) U13139.F5(VDDQ_16) U13139.F10(VDDQ_15) U13139.G1(VDD_6) U13139.G2(VDDQ_18) U13139.G13(VDDQ_17) U13139.G14(VDD_7) U13139.H3(VDDQ_20) U13139.H5(VDD_9) U13139.H10(VDD_8) U13139.H12(VDDQ_19) U13139.J1(VDD_10) U13139.J2(VDDQ_22) U13139.J13(VDDQ_21) U13139.J14(VDD_11) U13139.L1(VDD_12) U13139.L2(VDDQ_24) U13139.L13(VDDQ_23) U13139.L14(VDD_13) U13139.M3(VDDQ_26) U13139.M5(VDD_15) U13139.M10(VDD_14) U13139.M12(VDDQ_25) U13139.N1(VDD_16) U13139.N2(VDDQ_28) U13139.N13(VDDQ_27) U13139.N14(VDD_17) U13139.P5(VDDQ_30) U13139.P10(VDDQ_29) U13139.R1(VDDQ_31) U13139.R2(VDDQ_35) U13139.R4(VDDQ_36) U13139.R11(VDDQ_32) U13139.R13(VDDQ_33) U13139.R14(VDDQ_34) U13139.T10(VDD_18) U13139.U1(VDDQ_37) U13139.U2(VDDQ_40) U13139.U13(VDDQ_38) U13139.U14(VDDQ_39) U13139.V5(VDDQ_42) U13139.V10(VDDQ_41) U13139.W1(VDD_19) U13139.W2(VDDQ_44) U13139.W4(VDD_22) U13139.W11(VDD_20) U13139.W12(MF) U13139.W13(VDDQ_43) U13139.W14(VDD_21) U13140.A1(VDD_1) U13140.A2(VDDQ_2) U13140.A4(VDD_4) U13140.A11(VDD_2) U13140.A13(VDDQ_1) U13140.A14(VDD_3) U13140.B5(VDDQ_4) U13140.B10(VDDQ_3) U13140.C1(VDDQ_5) U13140.C2(VDDQ_8) U13140.C13(VDDQ_6) U13140.C14(VDDQ_7) U13140.D10(VDD_5) U13140.E1(VDDQ_9) U13140.E2(VDDQ_13) U13140.E4(VDDQ_14) U13140.E11(VDDQ_10) U13140.E13(VDDQ_11) U13140.E14(VDDQ_12) U13140.F5(VDDQ_16) U13140.F10(VDDQ_15) U13140.G1(VDD_6) U13140.G2(VDDQ_18) U13140.G13(VDDQ_17) U13140.G14(VDD_7) U13140.H3(VDDQ_20) U13140.H5(VDD_9) U13140.H10(VDD_8) U13140.H12(VDDQ_19) U13140.J1(VDD_10) U13140.J2(VDDQ_22) U13140.J13(VDDQ_21) U13140.J14(VDD_11) U13140.L1(VDD_12) U13140.L2(VDDQ_24) U13140.L13(VDDQ_23) U13140.L14(VDD_13) U13140.M3(VDDQ_26) U13140.M5(VDD_15) U13140.M10(VDD_14) U13140.M12(VDDQ_25) U13140.N1(VDD_16) U13140.N2(VDDQ_28) U13140.N13(VDDQ_27) U13140.N14(VDD_17) U13140.P5(VDDQ_30) U13140.P10(VDDQ_29) U13140.R1(VDDQ_31) U13140.R2(VDDQ_35) U13140.R4(VDDQ_36) U13140.R11(VDDQ_32) U13140.R13(VDDQ_33) U13140.R14(VDDQ_34) U13140.T10(VDD_18) U13140.U1(VDDQ_37) U13140.U2(VDDQ_40) U13140.U13(VDDQ_38) U13140.U14(VDDQ_39) U13140.V5(VDDQ_42) U13140.V10(VDDQ_41) U13140.W1(VDD_19) U13140.W2(VDDQ_44) U13140.W4(VDD_22) U13140.W11(VDD_20) U13140.W13(VDDQ_43) U13140.W14(VDD_21) U13141.A1(VDD_1) U13141.A2(VDDQ_2) U13141.A4(VDD_4) U13141.A11(VDD_2) U13141.A13(VDDQ_1) U13141.A14(VDD_3) U13141.B5(VDDQ_4) U13141.B10(VDDQ_3) U13141.C1(VDDQ_5) U13141.C2(VDDQ_8) U13141.C13(VDDQ_6) U13141.C14(VDDQ_7) U13141.D10(VDD_5) U13141.E1(VDDQ_9) U13141.E2(VDDQ_13) U13141.E4(VDDQ_14) U13141.E11(VDDQ_10) U13141.E13(VDDQ_11) U13141.E14(VDDQ_12) U13141.F5(VDDQ_16) U13141.F10(VDDQ_15) U13141.G1(VDD_6) U13141.G2(VDDQ_18) U13141.G13(VDDQ_17) U13141.G14(VDD_7) U13141.H3(VDDQ_20) U13141.H5(VDD_9) U13141.H10(VDD_8) U13141.H12(VDDQ_19) U13141.J1(VDD_10) U13141.J2(VDDQ_22) U13141.J13(VDDQ_21) U13141.J14(VDD_11) U13141.L1(VDD_12) U13141.L2(VDDQ_24) U13141.L13(VDDQ_23) U13141.L14(VDD_13) U13141.M3(VDDQ_26) U13141.M5(VDD_15) U13141.M10(VDD_14) U13141.M12(VDDQ_25) U13141.N1(VDD_16) U13141.N2(VDDQ_28) U13141.N13(VDDQ_27) U13141.N14(VDD_17) U13141.P5(VDDQ_30) U13141.P10(VDDQ_29) U13141.R1(VDDQ_31) U13141.R2(VDDQ_35) U13141.R4(VDDQ_36) U13141.R11(VDDQ_32) U13141.R13(VDDQ_33) U13141.R14(VDDQ_34) U13141.T10(VDD_18) U13141.U1(VDDQ_37) U13141.U2(VDDQ_40) U13141.U13(VDDQ_38) U13141.U14(VDDQ_39) U13141.V5(VDDQ_42) U13141.V10(VDDQ_41) U13141.W1(VDD_19) U13141.W2(VDDQ_44) U13141.W4(VDD_22) U13141.W11(VDD_20) U13141.W12(MF) U13141.W13(VDDQ_43) U13141.W14(VDD_21) U13142.A1(VDD_1) U13142.A2(VDDQ_2) U13142.A4(VDD_4) U13142.A11(VDD_2) U13142.A13(VDDQ_1) U13142.A14(VDD_3) U13142.B5(VDDQ_4) U13142.B10(VDDQ_3) U13142.C1(VDDQ_5) U13142.C2(VDDQ_8) U13142.C13(VDDQ_6) U13142.C14(VDDQ_7) U13142.D10(VDD_5) U13142.E1(VDDQ_9) U13142.E2(VDDQ_13) U13142.E4(VDDQ_14) U13142.E11(VDDQ_10) U13142.E13(VDDQ_11) U13142.E14(VDDQ_12) U13142.F5(VDDQ_16) U13142.F10(VDDQ_15) U13142.G1(VDD_6) U13142.G2(VDDQ_18) U13142.G13(VDDQ_17) U13142.G14(VDD_7) U13142.H3(VDDQ_20) U13142.H5(VDD_9) U13142.H10(VDD_8) U13142.H12(VDDQ_19) U13142.J1(VDD_10) U13142.J2(VDDQ_22) U13142.J13(VDDQ_21) U13142.J14(VDD_11) U13142.L1(VDD_12) U13142.L2(VDDQ_24) U13142.L13(VDDQ_23) U13142.L14(VDD_13) U13142.M3(VDDQ_26) U13142.M5(VDD_15) U13142.M10(VDD_14) U13142.M12(VDDQ_25) U13142.N1(VDD_16) U13142.N2(VDDQ_28) U13142.N13(VDDQ_27) U13142.N14(VDD_17) U13142.P5(VDDQ_30) U13142.P10(VDDQ_29) U13142.R1(VDDQ_31) U13142.R2(VDDQ_35) U13142.R4(VDDQ_36) U13142.R11(VDDQ_32) U13142.R13(VDDQ_33) U13142.R14(VDDQ_34) U13142.T10(VDD_18) U13142.U1(VDDQ_37) U13142.U2(VDDQ_40) U13142.U13(VDDQ_38) U13142.U14(VDDQ_39) U13142.V5(VDDQ_42) U13142.V10(VDDQ_41) U13142.W1(VDD_19) U13142.W2(VDDQ_44) U13142.W4(VDD_22) U13142.W11(VDD_20) U13142.W13(VDDQ_43) U13142.W14(VDD_21)
FBVDDQ_SENSE: PR9138.2 U13114.E52(FBVDDQ_SENSE)
FLIP_EDP: R20936.2 R20938.2 U13079.21(FLIP/SCL)
FLIP_TBT_CLK: R20833.1 R20838.1 U13025.21(FLIP/SCL)
FN+F9_BLACKLIGHT: Q7939.1(S) R67299.1 R67300.1 R67394.2
FN+F9_BLACKLIGHT_R: CN2049.5 Q7939.3(D) R67299.2 R67302.1
FRM_LCK#: Q7821.3(COLLECTOR) R21590.2 U13114.BG2(GPIO5)
FRM_LCK#_PANEL: CN2042.19 Q7821.1(EMITTER)
G5719LX2.5V: PL15.1 PU19.3(LX)
GC6FBEN: Q7856.2(G) Q7865.2(G) R21573.2 U13114.BB5(GPIO1) U13118.1(B)
GC6FBEN_Q: Q7855.3(D) R67216.2 R67218.1
GC6FBEN_Q_EC: Q7945.3(D) R67395.1
GC6FBEN_Q_NL5: R67216.1 U13113.AG43(GPP_E5/DEVSLP1)
GC6FBEN_Q_ZRYD_WS1: R21311.2 R21312.1 R67217.1 R67218.2 U13113.AV29(GPP_B20/GSPI1_CLK)
GFX_SCL: Q7858.1(S) R21599.2 U13114.BJ8(I2CS_SCL)
GFX_SDA: Q7860.4(S) R21600.2 U13114.BH8(I2CS_SDA)
GPD2: R21124.2 U13113.BD11(GPD2/LAN_WAKE#)
GPIO17_IFPD_HPD_EDP: Q7854.3(D) R21561.2 U13114.BH1(GPIO17)
GPIO18_IFPE_HPD_DP: Q7852.3(D) R21560.2 U13114.BE3(GPIO18)
GPIO18_IFPE_HPD_Q: Q7852.2(G) R21563.1 R21566.1
GPIO24_IFPF_HPD_TBT: Q7880.3(D) R21881.2 U13114.BD5(GPIO24)
GPIO27_IFPC_HPD_HDMI: Q7853.3(D) R21562.2 U13114.BA4(GPIO27)
GPIO27_IFPE_HPD_Q: Q7853.2(G) R21565.1 R21567.1
GPIO28_OC_WARN#: D8588.1(CATHODE) PQ147.3(D)
GPIO28_OC_WARN#_Q: D8588.2(ANODE) R21596.2 U13114.BB4(GPIO28)
GPP_B2: R21101.1 U13113.BD23(GPP_B2/VRALERT#)
GPU_CLK: C94749.1 U13114.BE17(IFPC_L3)
GPU_CLK#: C94750.1 U13114.BF17(IFPC_L3_N)
GPU_CLK#_C: C94750.2 R22125.1 R22135.2
GPU_CLK_C: C94749.2 R22124.1 R22134.2
GPU_D0: C94751.1 U13114.BG18(IFPC_L2)
GPU_D0#: C94743.1 U13114.BF18(IFPC_L2_N)
GPU_D0#_C: C94743.2 R22123.1 R22133.2
GPU_D0_C: C94751.2 R22122.1 R22132.2
GPU_D1: C94744.1 U13114.BH20(IFPC_L1)
GPU_D1#: C94754.1 U13114.BG20(IFPC_L1_N)
GPU_D1#_C: C94754.2 R22121.1 R22131.2
GPU_D1_C: C94744.2 R22120.1 R22130.2
GPU_D2: C94747.1 U13114.BE20(IFPC_L0)
GPU_D2#: C94748.1 U13114.BF20(IFPC_L0_N)
GPU_D2#_C: C94748.2 R22119.1 R22129.2
GPU_D2_C: C94747.2 R22118.1 R22128.2
GPU_DDCCLK: Q34.4(S) R21026.1 R21532.2 U13114.BK9(IFPC_AUX_SCL)
GPU_DDCDATA: Q34.1(S) R21032.1 R21533.1 U13114.BL9(IFPC_AUX_SDA_N)
GPU_PEX_RST_HOLD#: R21595.2 TP13113.1 U13114.BG3(GPIO23)
GPU_TBT_AUXN: C94556.1 C94567.2 R21880.2 U13114.BM9(IFPF_AUX_SDA_N)
GPU_TBT_AUXP: C94555.1 C94566.2 R21879.2 U13114.BM8(IFPF_AUX_SCL)
GPU_TBT_D0: C93687.1 U13114.BL14(IFPF_L0)
GPU_TBT_D0#: C94548.1 U13114.BK14(IFPF_L0_N)
GPU_TBT_D1: C94553.1 U13114.BK12(IFPF_L1)
GPU_TBT_D1#: C94554.1 U13114.BL12(IFPF_L1_N)
GPU_TBT_D2: C94551.1 U13114.BM12(IFPF_L2)
GPU_TBT_D2#: C94552.1 U13114.BM11(IFPF_L2_N)
GPU_TBT_D3: C94549.1 U13114.BL11(IFPF_L3)
GPU_TBT_D3#: C94550.1 U13114.BK11(IFPF_L3_N)
GPU_THROTTING#: D13095.1(CATHODE) PR67219.2 R67308.2 R67380.2
GPUEVENT#: D8589.2(ANODE) R21588.2 U13114.BD1(GPIO2)
GPUEVENT#_PCH: D8589.1(CATHODE) U13113.AR29(GPP_B21/GSPI1_MISO)
GPUT_CLK: Q7858.6(D) R22061.2
GPUT_DATA: Q7860.3(D) R22062.2
GSPI0_MOSI: R21327.2 U13113.BD28(GPP_B18/GSPI0_MOSI)
GSPI1_MOSI: R21328.2 U13113.AT29(GPP_B22/GSPI1_MOSI)
GT_PWM4: PR66835.2 PR66949.1
GT_PWM5: PR66836.2 PR66952.1
H_CPU_SVIDALRT#: R545.1 U41.BH31(VIDALERT#)
H_CPU_SVIDDAT: R543.1 R544.2 U41.BH29(VIDSOUT)
H_PM_DOWN: R559.1 U13113.AH2(PM_DOWN)
H_PM_DOWN_R: R559.2 U41.BP31(PM_DOWN)
H_PROCHOT#: C807.2 C96031.1 PR66937.1 PR66938.2 PR67236.2 Q32.3(D) R566.1 R22148.1
H_PROCHOT#_CPU: R22148.2 U41.BR30(PROCHOT#)
H_PROCHOT#_R: PQ9087.2(G) PQ9088.2(G) PR67235.2 PR67240.2 PU1.10(P\R\O\C\H\O\T\)
HDMI_HPD: C94765.1 CN2044.19(HP_DET) ESD7.2(LINE-2) ESD7.9(NC#3) R22126.2
HDMI_HPD_PCH: C95080.2 Q7931.3(D) R21565.2 R22126.1 R67232.2
HDMI_HPD_PCH_R: Q7931.1(S) R67233.1 U13113.AV4(GPP_I2/DDPD_HPD2)
HDMI_SCLK: CN2044.15(DDC_CLK) ESD7.5(LINE-4) ESD7.6(NC#1) Q34.3(D) R21010.1
HDMI_SDATA: CN2044.16(DDC_DATA) ESD7.4(LINE-3) ESD7.7(NC#2) Q34.6(D) R21011.1
HOLD#_7: R21552.2 U13116.7(H\O\L\D\(IO3)) U13117.7(H\O\L\D\)
HP-L2: C95983.1 R67204.1 U13108.27(HP-OUT-L)
HP-L3: C95983.2 R67018.2
HP-L4: R67018.1 R67260.1 U13150.1(INL-)
HP-L5: C94942.1 CN2058.1(L) D8569.1 R21447.2 U13156.1(GND#1)
HP-R2: C95986.1 R67205.1 U13108.26(HP-OUT-R)
HP-R3: C95986.2 R67019.2
HP-R4: R67019.1 R67261.1 U13150.4(INR-)
HP-R5: C94943.1 CN2058.2(R) D8571.1 R22159.2 U13156.3(RFIN)
HP_AMP_EN: D13089.1(CATHODE) R67038.2 R67338.1
HP_EN: D13090.1(CATHODE) R67336.1
HP_EN_QQ: D13089.2(ANODE) D13090.2(ANODE) R67328.2 R67337.1 U13150.13(EN)
HP_JD#_EC: R67310.2 R67368.1 U49.80(DAC4/DCD0#/GPJ4(3))
HP_JD#_EC_CODEC: Q7937.2(BASE) R67264.2 R67285.2
HP_JD#_EC_R: CN2058.6 D8570.1 R67262.1 R67263.1 R67368.2
HPOUT_L2: R67206.2 U13150.16(OUTL) U13151.12(CH0)
HPOUT_R2: R67207.2 U13150.5(OUTR) U13151.11(CH1)
HRESET: R67136.1 R67163.1 R67164.2 U13155.D6(HRESET)
HWPG: D11.2(ANODE) D13.2(ANODE) D15.2(ANODE) D17.2(ANODE) D18.2(ANODE) R202.2 R813.1 R67199.2 U49.21(RI2#/GPD1)
HWPG_1.8VS5: D15.1(CATHODE) PR97.2 PR102.2
HWPG_1VS5: D11.1(CATHODE) PR263.2 PU9015.1(PGOOD)
HWPG_2.5V: D13.1(CATHODE) PR309.2 PR311.2 PR67229.2
HWPG_R: Q7840.3(D) R21164.1 R21166.1 R21171.1 R67199.1
HWPG_VDDR: D18.1(CATHODE) PR2016.2 PR2017.2
I2C0_SCL: R67236.2 R67277.1 U13113.AR38(GPP_C17/I2C0_SCL)
I2C0_SDA: R67237.2 R67275.1 U13113.AT42(GPP_C16/I2C0_SDA)
I2C1_SCL: R67404.1 R67405.2 U13113.AR41(GPP_C19/I2C1_SCL)
I2C1_SDA: R67403.1 R67406.2 U13113.AR44(GPP_C18/I2C1_SDA)
I2C_EN_EDP: R20930.2 R20932.2 U13079.17(I2C_EN)
I2C_EN_TBT: R20834.1 R20839.1 U13025.17(I2C_EN)
I2C_TP_SCL_R: CN2076.6 CN2078.5 Q7892.1(S) R21068.1 R67259.2
I2C_TP_SDA_R: CN2076.5 CN2078.6 Q7892.4(S) R21067.1 R67258.2
I2CB_SCL_G: R21571.2 U13114.BG8(I2CB_SCL)
I2CB_SDA_G: R21572.2 U13114.BF8(I2CB_SDA)
I2CC_SCL_GFX: Q7858.4(S) R21569.2 U13114.BG9(I2CC_SCL)
I2CC_SCL_IPC: PR701.2 PU12.6(SCL) Q7858.3(D)
I2CC_SDA_GFX: Q7860.1(S) R21570.2 U13114.BH9(I2CC_SDA)
I2CC_SDA_IPC: PR702.2 PR706.2 PU12.7(SDA) Q7860.6(D)
ICMNT: C574.2 PC37.2 PR32.1 PR67220.2 U49.67(ADC1/GPI1(3))
IFPC_RSET: R21531.2 U13114.BD20(IFPCD_RSET)
IFPEF_RSET: R21528.2 U13114.BD17(IFPEF_RSET)
ILIM_HI: R21702.1 U13128.16(ILIM_HI)
ILIM_LO: R21703.2 U13128.15(ILIM_LO)
IMVP8_TMP_FLT: PR66893.1 PR66900.1 PR66905.1 PR66915.1 PR66920.1 PR66925.1 PR66946.1
IMVP_PWRGD: PR66851.1 PR66853.1 Q20.2(G) R21150.2 U13098.2(INA)
INA3221_THERM_ALERT: PD102.1(CATHODE) PR417.1 PR67226.1 PU12.9(CRIT)
INA3221_WARN: PD101.1(CATHODE) PR416.1 PU12.8(WARNING)
INT_DP_AUXN: C94740.2 Q7903.6(D) R21530.2 U13114.BL8(IFPE_AUX_SDA_N)
INT_DP_AUXP: C94742.2 Q7904.6(D) R21529.2 U13114.BK8(IFPE_AUX_SCL)
INT_EDP_AUXN: C94697.1 R21535.2 U13114.BF11(IFPD_AUX_SDA_N)
INT_EDP_AUXP: C94698.1 R21534.2 U13114.BE11(IFPD_AUX_SCL)
INT_EDP_TXN0: C94659.1 U13114.BM17(IFPD_L0_N)
INT_EDP_TXN0_R: C94659.2 U13079.10(DP0N)
INT_EDP_TXN1: C94671.1 U13114.BK17(IFPD_L1_N)
INT_EDP_TXN1_R: C94671.2 U13079.13(DP1N)
INT_EDP_TXN2: C94669.1 U13114.BL15(IFPD_L2_N)
INT_EDP_TXN2_R: C94669.2 U13079.16(DP2N)
INT_EDP_TXN3: C94657.1 U13114.BM14(IFPD_L3_N)
INT_EDP_TXN3_R: C94657.2 U13079.19(DP3N)
INT_EDP_TXP0: C94655.1 U13114.BM18(IFPD_L0)
INT_EDP_TXP0_R: C94655.2 U13079.9(DP0P)
INT_EDP_TXP1: C94670.1 U13114.BL17(IFPD_L1)
INT_EDP_TXP1_R: C94670.2 U13079.12(DP1P)
INT_EDP_TXP2: C94668.1 U13114.BK15(IFPD_L2)
INT_EDP_TXP2_R: C94668.2 U13079.15(DP2P)
INT_EDP_TXP3: C94656.1 U13114.BM15(IFPD_L3)
INT_EDP_TXP3_R: C94656.2 U13079.18(DP3P)
INT_ULT_EDP_HPD: R20918.2 R20923.1 R67248.1 U13079.32(HPDIN/DCI_CLK)
IRQ_SERIRQ: R21088.1 U49.5(SERIRQ/GPM6(3)) U13113.BA17(GPP_A6/SERIRQ/ESPI_CS1#)
JTAG_SEL: TP13111.1 U13114.BK23(NVJTAG_SEL)
JTAG_TCK: R21586.2 U13114.BK24(JTAG_TCK)
JTAG_TCK_PCH: R21121.1 U13113.AN3(JTAG_TCK)
JTAG_TDI: R21584.2 U13114.BM23(JTAG_TDI)
JTAG_TDI_PCH: R21110.2 R21119.1 U13113.AP2(JTAG_TDI)
JTAG_TDO: TP13110.1 U13114.BM24(JTAG_TDO)
JTAG_TDO_PCH: R21111.2 R21120.1 U13113.AP1(JTAG_TDO)
JTAG_TMS: R21583.2 U13114.BL23(JTAG_TMS)
JTAG_TMS_PCH: R21109.2 R21118.1 U13113.AR2(JTAG_TMS)
JTAG_TRST#: R21585.2 U13114.BL24(JTAG_TRST_N)
KB_LED_A0: R21058.2 R21059.2 U13093.31(A0)
KB_LED_A1: R21060.2 R21061.2 U13093.32(A1)
KB_PWR_EN: C96273.2 R67306.1 U13158.3(ON1)
L_SPK+: C94958.2 CN2060.1 U13108.42(SPK-OUT-L+)
L_SPK-: C94959.2 CN2060.2 U13108.43(SPK-OUT-L-)
LAN_DEBUGMODE: R67304.2 U13143.5(DEBUGMODE[0])
LAN_MCT0: R21492.1 U13112.24(MCT1)
LAN_MCT1: R21495.1 U13112.21(MCT2)
LAN_MCT2: R21491.1 U13112.18(MCT3)
LAN_MCT3: R21490.1 U13112.15(MCT4)
LAN_MX0+: CN2061.1 U13112.13(MX4-)
LAN_MX0-: CN2061.2 U13112.14(MX4+)
LAN_MX1+: CN2061.3 U13112.16(MX3-)
LAN_MX1-: CN2061.6 U13112.17(MX3+)
LAN_MX2+: CN2061.4 U13112.19(MX2-)
LAN_MX2-: CN2061.5 U13112.20(MX2+)
LAN_MX3+: CN2061.7 U13112.22(MX1-)
LAN_MX3-: CN2061.8 U13112.23(MX1+)
LANVCC: C94979.2 C94982.2 C94983.2 C94985.1 C94986.2 Q7848.2(G) Q7849.2(G) R21484.1 R21486.1 R21494.1 R67190.1 R67304.1 U13143.1(VDD33)
LCD_BL_PWM: Q7820.2(G) R21575.1 U13114.BD7(GPIO7)
LCD_BLEN: Q7823.2(G) R21579.2 U13114.BB1(GPIO13)
LCD_VDD: R20960.1 R21578.2 U13114.BH3(GPIO11)
LCDVCC: C94707.2 C94708.2 C94709.1 C94710.1 C95907.2 Q7821.2(BASE) R20946.1 R20947.1 R20948.2 R20956.1 R20957.2 U13080.1(OUT)
LCDVCC_R: C94680.2 C94681.2 CN2042.1 CN2042.2 CN2042.3 R20946.2
LED_A_B: CN2075.10 U13093.5(O\U\T\2\)
LED_A_G: CN2075.11 U13093.4(O\U\T\1\)
LED_A_R: CN2075.12 U13093.3(O\U\T\0\)
LED_B1_SYS: R67173.2 U13152.5(O\U\T\2\)
LED_B1_SYS_R: D13048.1 LED2.3 R67173.1
LED_B2_BAT: R67169.2 U13152.9(O\U\T\5\)
LED_B2_BAT_R: D13051.1 LED1.3 R67169.1
LED_B4_P_BTN: CN2071.5 D13055.1 U13152.17(O\U\T\1\1\)
LED_B5_GPU_FAN: R67031.2 U13152.22(O\U\T\1\5\)
LED_B5_GPU_FAN_R: CN2077.4 D13058.1 R67031.1
LED_B_B: CN2075.7 U13093.9(O\U\T\5\)
LED_B_G: CN2075.8 U13093.8(O\U\T\4\)
LED_B_R: CN2075.9 U13093.6(O\U\T\3\)
LED_C_B: CN2075.4 U13093.14(O\U\T\8\)
LED_C_G: CN2075.5 U13093.11(O\U\T\7\)
LED_C_R: CN2075.6 U13093.10(O\U\T\6\)
LED_D_B: CN2075.1 U13093.17(O\U\T\1\1\)
LED_D_G: CN2075.2 U13093.16(O\U\T\1\0\)
LED_D_R: CN2075.3 U13093.15(O\U\T\9\)
LED_G1_SYS: R67168.2 U13152.4(O\U\T\1\)
LED_G1_SYS_R: D13047.1 LED2.2 R67168.1
LED_G2_BAT: R67171.2 U13152.8(O\U\T\4\)
LED_G2_BAT_R: D13050.1 LED1.2 R67171.1
LED_G3_M_BTN: D13053.1 SW3.4 U13152.11(O\U\T\7\)
LED_G4_P_BTN: CN2071.4 D13056.1 U13152.16(O\U\T\1\0\)
LED_G5_GPU_FAN: R67030.2 U13152.21(O\U\T\1\4\)
LED_G5_GPU_FAN_R: CN2077.3 D13059.1 R67030.1
LED_LINK: R67190.2 R67191.1 U13143.39(LED[1])
LED_R1_SYS: R67167.2 U13152.3(O\U\T\0\)
LED_R1_SYS_R: D13046.1 LED2.1 R67167.1
LED_R2_BAT: R67170.2 U13152.6(O\U\T\3\)
LED_R2_BAT_R: D13049.1 LED1.1 R67170.1
LED_R4_P_BTN: CN2071.3 D13054.1 U13152.15(O\U\T\9\)
LED_R5_GPU_FAN: R67029.2 U13152.20(O\U\T\1\3\)
LED_R5_GPU_FAN_R: CN2077.2 D13057.1 R67029.1
LID#: D8557.1(CATHODE) D8558.1 MR1.1(OUTPUT) R20903.1 R20962.2 R20966.2
LID#_EC_L: C94644.2 D13087.1 R20903.2 U49.118(SMDAT2/PECIRQT#/GPF7(3))
LINLVP: CN2039.4 R67349.2 U13157.22(LISENSE-/LVSENSE+)
LIP: C94632.2 L4237.2 R67349.1 U13157.21(LISENSE+)
LPC_LAD0: R21714.1 U49.10(LAD0/GPM0(3)) U13113.AT22(GPP_A1/LAD0/ESPI_IO0)
LPC_LAD0_C: CN2068.64(NFC_RESET#/UART_RTS) R21714.2
LPC_LAD1: R21715.1 U49.9(LAD1/GPM1(3)) U13113.AV22(GPP_A2/LAD1/ESPI_IO1)
LPC_LAD1_C: CN2068.66(PERST1#) R21715.2 R21996.1 R21997.1
LPC_LAD2: R21716.1 U49.8(LAD2/GPM2(3)) U13113.AT19(GPP_A3/LAD2/ESPI_IO2)
LPC_LAD2_C: CN2068.68(CLKREQ1#) Q7890.1(S) R21716.2 R22003.1
LPC_LAD3: R21717.1 U49.7(LAD3/GPM3(3)) U13113.BD16(GPP_A4/LAD3/ESPI_IO3)
LPC_LAD3_C: CN2068.70(PEWAKE1#) Q7891.1(S) R21717.2 R22005.1
LPC_LFRAME#: R21719.2 U49.6(LFRAME#/GPM5(3)) U13113.BE16(GPP_A5/LFRAME#/ESPI_CS0#)
LVN: C94631.2 CN2039.3 L4236.2 U13157.23(LVSENSE-)
LX: L4242.2 U13143.40(LX)
M_A_A0: CN2063.144(A0) U41.AH3(DDR0_MA[0]/DDR0_CAB[9]/DDR0_MA[)
M_A_A1: CN2063.133(A1) U41.AP4(DDR0_MA[1]/DDR0_CAB[8]/DDR0_MA[)
M_A_A2: CN2063.132(A2) U41.AN4(DDR0_MA[2]/DDR0_CAB[5]/DDR0_MA[)
M_A_A3: CN2063.131(A3) U41.AP5(DDR0_MA[3])
M_A_A4: CN2063.128(A4) U41.AP2(DDR0_MA[4])
M_A_A5: CN2063.126(A5) U41.AP1(DDR0_MA[5]/DDR0_CAA[0]/DDR0_MA[)
M_A_A6: CN2063.127(A6) U41.AP3(DDR0_MA[6]/DDR0_CAA[2]/DDR0_MA[)
M_A_A7: CN2063.122(A7) U41.AN1(DDR0_MA[7]/DDR0_CAA[4]/DDR0_MA[)
M_A_A8: CN2063.125(A8) U41.AN3(DDR0_MA[8]/DDR0_CAA[3]/DDR0_MA[)
M_A_A9: CN2063.121(A9) U41.AT4(DDR0_MA[9]/DDR0_CAA[1]/DDR0_MA[)
M_A_A10: CN2063.146(A10/AP) U41.AH2(DDR0_MA[10]/DDR0_CAB[7]/DDR0_MA)
M_A_A11: CN2063.120(A11) U41.AN2(DDR0_MA[11]/DDR0_CAA[7]/DDR0_MA)
M_A_A12: CN2063.119(A12) U41.AU4(DDR0_MA[12]/DDR0_CAA[6]/DDR0_MA)
M_A_A13: CN2063.158(A13) U41.AE3(DDR0_MA[13]/DDR0_CAB[0]/DDR0_MA)
M_A_ACT#: CN2063.114(ACT#) U41.AU3(DDR0_MA[15]/DDR0_CAA[8]/DDR0_AC)
M_A_ALERT#: CN2063.116(ALERT#) U41.AU5(DDR0_ALERT#)
M_A_BA#0: CN2063.150(BA0) U41.AH5(DDR0_BA[0]/DDR0_CAB[4]/DDR0_BA[)
M_A_BA#1: CN2063.145(BA1) U41.AH1(DDR0_BA[1]/DDR0_CAB[6]/DDR0_BA[)
M_A_BG#0: CN2063.115(BG0) U41.AU1(DDR0_BA[2]/DDR0_CAA[5]/DDR0_BG[)
M_A_BG#1: CN2063.113(BG1) U41.AU2(DDR0_MA[14]/DDR0_CAA[9]/DDR0_BG)
M_A_CAS#: CN2063.156(A15/CAS#) U41.AD1(DDR0_CAS#/DDR0_CAB[1]/DDR0_MA[1)
M_A_CB0: CN2063.92(CB0/NC) R21396.2
M_A_CB1: CN2063.91(CB1/NC) R21397.2
M_A_CB2: CN2063.101(CB2/NC) R21398.2
M_A_CB3: CN2063.105(CB3/NC) R21399.2
M_A_CB4: CN2063.88(CB4/NC) R21401.2
M_A_CB5: CN2063.87(CB5/NC) R21402.2
M_A_CB6: CN2063.100(CB6/NC) R21403.2
M_A_CB7: CN2063.104(CB7/NC) R21404.2
M_A_CKE0: CN2063.109(CKE0) U41.AT1(DDR0_CKE[0])
M_A_CKE1: CN2063.110(CKE1) U41.AT2(DDR0_CKE[1])
M_A_CLKN0: CN2063.139(CK0#) U41.AG2(DDR0_CKN[0])
M_A_CLKN1: CN2063.140(CK1#) U41.AK1(DDR0_CKN[1])
M_A_CLKP0: CN2063.137(CK0) U41.AG1(DDR0_CKP[0])
M_A_CLKP1: CN2063.138(CK1) U41.AK2(DDR0_CKP[1])
M_A_CS#0: CN2063.149(CS0#) U41.AD5(DDR0_CS#[0])
M_A_CS#1: CN2063.157(CS1#) U41.AE2(DDR0_CS#[1])
M_A_DQ0: CN2063.4(DQ4) U41.BR6(DDR0_DQ[0])
M_A_DQ1: CN2063.8(DQ0) U41.BT6(DDR0_DQ[1])
M_A_DQ2: CN2063.17(DQ7) U41.BP3(DDR0_DQ[2])
M_A_DQ3: CN2063.21(DQ3) U41.BR3(DDR0_DQ[3])
M_A_DQ4: CN2063.3(DQ5) U41.BN5(DDR0_DQ[4])
M_A_DQ5: CN2063.7(DQ1) U41.BP6(DDR0_DQ[5])
M_A_DQ6: CN2063.16(DQ6) U41.BP2(DDR0_DQ[6])
M_A_DQ7: CN2063.20(DQ2) U41.BN3(DDR0_DQ[7])
M_A_DQ8: CN2063.28(DQ8) U41.BL4(DDR0_DQ[8])
M_A_DQ9: CN2063.25(DQ13) U41.BL5(DDR0_DQ[9])
M_A_DQ10: CN2063.37(DQ15) U41.BL2(DDR0_DQ[10])
M_A_DQ11: CN2063.42(DQ11) U41.BM1(DDR0_DQ[11])
M_A_DQ12: CN2063.24(DQ12) U41.BK4(DDR0_DQ[12])
M_A_DQ13: CN2063.29(DQ9) U41.BK5(DDR0_DQ[13])
M_A_DQ14: CN2063.41(DQ10) U41.BK1(DDR0_DQ[14])
M_A_DQ15: CN2063.38(DQ14) U41.BK2(DDR0_DQ[15])
M_A_DQ16: CN2063.45(DQ21) U41.BG4(DDR0_DQ[16]/DDR0_DQ[32])
M_A_DQ17: CN2063.49(DQ17) U41.BG5(DDR0_DQ[17]/DDR0_DQ[33])
M_A_DQ18: CN2063.59(DQ23) U41.BF4(DDR0_DQ[18]/DDR0_DQ[34])
M_A_DQ19: CN2063.63(DQ19) U41.BF5(DDR0_DQ[19]/DDR0_DQ[35])
M_A_DQ20: CN2063.46(DQ20) U41.BG2(DDR0_DQ[20]/DDR0_DQ[36])
M_A_DQ21: CN2063.50(DQ16) U41.BG1(DDR0_DQ[21]/DDR0_DQ[37])
M_A_DQ22: CN2063.58(DQ22) U41.BF1(DDR0_DQ[22]/DDR0_DQ[38])
M_A_DQ23: CN2063.62(DQ18) U41.BF2(DDR0_DQ[23]/DDR0_DQ[39])
M_A_DQ24: CN2063.70(DQ24) U41.BD2(DDR0_DQ[24]/DDR0_DQ[40])
M_A_DQ25: CN2063.66(DQ28) U41.BD1(DDR0_DQ[25]/DDR0_DQ[41])
M_A_DQ26: CN2063.80(DQ31) U41.BC4(DDR0_DQ[26]/DDR0_DQ[42])
M_A_DQ27: CN2063.84(DQ27) U41.BC5(DDR0_DQ[27]/DDR0_DQ[43])
M_A_DQ28: CN2063.71(DQ25) U41.BD5(DDR0_DQ[28]/DDR0_DQ[44])
M_A_DQ29: CN2063.67(DQ29) U41.BD4(DDR0_DQ[29]/DDR0_DQ[45])
M_A_DQ30: CN2063.79(DQ30) U41.BC1(DDR0_DQ[30]/DDR0_DQ[46])
M_A_DQ31: CN2063.83(DQ26) U41.BC2(DDR0_DQ[31]/DDR0_DQ[47])
M_A_DQ32: CN2063.170(DQ36) U41.AB1(DDR0_DQ[32]/DDR1_DQ[0])
M_A_DQ33: CN2063.174(DQ32) U41.AB2(DDR0_DQ[33]/DDR1_DQ[1])
M_A_DQ34: CN2063.182(DQ39) U41.AA4(DDR0_DQ[34]/DDR1_DQ[2])
M_A_DQ35: CN2063.186(DQ35) U41.AA5(DDR0_DQ[35]/DDR1_DQ[3])
M_A_DQ36: CN2063.173(DQ33) U41.AB5(DDR0_DQ[36]/DDR1_DQ[4])
M_A_DQ37: CN2063.169(DQ37) U41.AB4(DDR0_DQ[37]/DDR1_DQ[5])
M_A_DQ38: CN2063.183(DQ38) U41.AA2(DDR0_DQ[38]/DDR1_DQ[6])
M_A_DQ39: CN2063.187(DQ34) U41.AA1(DDR0_DQ[39]/DDR1_DQ[7])
M_A_DQ40: CN2063.194(DQ41) U41.V5(DDR0_DQ[40]/DDR1_DQ[8])
M_A_DQ41: CN2063.191(DQ44) U41.V2(DDR0_DQ[41]/DDR1_DQ[9])
M_A_DQ42: CN2063.204(DQ47) U41.U1(DDR0_DQ[42]/DDR1_DQ[10])
M_A_DQ43: CN2063.203(DQ46) U41.U2(DDR0_DQ[43]/DDR1_DQ[11])
M_A_DQ44: CN2063.195(DQ40) U41.V1(DDR0_DQ[44]/DDR1_DQ[12])
M_A_DQ45: CN2063.190(DQ45) U41.V4(DDR0_DQ[45]/DDR1_DQ[13])
M_A_DQ46: CN2063.207(DQ42) U41.U5(DDR0_DQ[46]/DDR1_DQ[14])
M_A_DQ47: CN2063.208(DQ43) U41.U4(DDR0_DQ[47]/DDR1_DQ[15])
M_A_DQ48: CN2063.212(DQ53) U41.R2(DDR0_DQ[48]/DDR1_DQ[32])
M_A_DQ49: CN2063.211(DQ52) U41.P5(DDR0_DQ[49]/DDR1_DQ[33])
M_A_DQ50: CN2063.228(DQ50) U41.R4(DDR0_DQ[50]/DDR1_DQ[34])
M_A_DQ51: CN2063.229(DQ51) U41.P4(DDR0_DQ[51]/DDR1_DQ[35])
M_A_DQ52: CN2063.215(DQ49) U41.R5(DDR0_DQ[52]/DDR1_DQ[36])
M_A_DQ53: CN2063.216(DQ48) U41.P2(DDR0_DQ[53]/DDR1_DQ[37])
M_A_DQ54: CN2063.224(DQ54) U41.R1(DDR0_DQ[54]/DDR1_DQ[38])
M_A_DQ55: CN2063.225(DQ55) U41.P1(DDR0_DQ[55]/DDR1_DQ[39])
M_A_DQ56: CN2063.236(DQ57) U41.M4(DDR0_DQ[56]/DDR1_DQ[40])
M_A_DQ57: CN2063.237(DQ56) U41.M1(DDR0_DQ[57]/DDR1_DQ[41])
M_A_DQ58: CN2063.246(DQ63) U41.L4(DDR0_DQ[58]/DDR1_DQ[42])
M_A_DQ59: CN2063.245(DQ62) U41.L2(DDR0_DQ[59]/DDR1_DQ[43])
M_A_DQ60: CN2063.232(DQ60) U41.M5(DDR0_DQ[60]/DDR1_DQ[44])
M_A_DQ61: CN2063.233(DQ61) U41.M2(DDR0_DQ[61]/DDR1_DQ[45])
M_A_DQ62: CN2063.250(DQ59) U41.L5(DDR0_DQ[62]/DDR1_DQ[46])
M_A_DQ63: CN2063.249(DQ58) U41.L1(DDR0_DQ[63]/DDR1_DQ[47])
M_A_DQSN0: CN2063.11(DQS#0) U41.BR5(DDR0_DQSN[0])
M_A_DQSN1: CN2063.32(DQS#1) U41.BL3(DDR0_DQSN[1])
M_A_DQSN2: CN2063.53(DQS#2) U41.BG3(DDR0_DQSN[2]/DDR0_DQSN[4])
M_A_DQSN3: CN2063.74(DQS#3) U41.BD3(DDR0_DQSN[3]/DDR0_DQSN[5])
M_A_DQSN4: CN2063.177(DQS#4) U41.AA3(DDR0_DQSN[4]/DDR1_DQSN[0])
M_A_DQSN5: CN2063.198(DQS#5) U41.U3(DDR0_DQSN[5]/DDR1_DQSN[1])
M_A_DQSN6: CN2063.219(DQS#6) U41.P3(DDR0_DQSN[6]/DDR1_DQSN[4])
M_A_DQSN7: CN2063.240(DQS#7) U41.L3(DDR0_DQSN[7]/DDR1_DQSN[5])
M_A_DQSN8: CN2063.95(DQS#8) R21400.2
M_A_DQSP0: CN2063.13(DQS0) U41.BP5(DDR0_DQSP[0])
M_A_DQSP1: CN2063.34(DQS1) U41.BK3(DDR0_DQSP[1])
M_A_DQSP2: CN2063.55(DQS2) U41.BF3(DDR0_DQSP[2]/DDR0_DQSP[4])
M_A_DQSP3: CN2063.76(DQS3) U41.BC3(DDR0_DQSP[3]/DDR0_DQSP[5])
M_A_DQSP4: CN2063.179(DQS4) U41.AB3(DDR0_DQSP[4]/DDR1_DQSP[0])
M_A_DQSP5: CN2063.200(DQS5) U41.V3(DDR0_DQSP[5]/DDR1_DQSP[1])
M_A_DQSP6: CN2063.221(DQS6) U41.R3(DDR0_DQSP[6]/DDR1_DQSP[4])
M_A_DQSP7: CN2063.242(DQS7) U41.M3(DDR0_DQSP[7]/DDR1_DQSP[5])
M_A_DQSP8: CN2063.97(DQS8) R21395.2
M_A_EVENT#: CN2063.134(EVENT#) R21387.2
M_A_ODT0_CPU: CN2063.155(O\D\T\0\) U41.AD3(DDR0_ODT[0])
M_A_ODT1_CPU: CN2063.161(ODT1) U41.AE4(DDR0_ODT[1])
M_A_PARITY: CN2063.143(PARITY) U41.AG3(DDR0_PAR)
M_A_RAS#: CN2063.152(A16/RAS#) U41.AH4(DDR0_RAS#/DDR0_CAB[3]/DDR0_MA[1)
M_A_WE#: CN2063.151(A14/WE#) U41.AG4(DDR0_WE#/DDR0_CAB[2]/DDR0_MA[14)
M_B_A0: CN2062.144(A0) U41.AJ9(DDR1_MA[0]/DDR1_CAB[9]/DDR1_MA[)
M_B_A1: CN2062.133(A1) U41.AK6(DDR1_MA[1]/DDR1_CAB[8]/DDR1_MA[)
M_B_A2: CN2062.132(A2) U41.AK5(DDR1_MA[2]/DDR1_CAB[5]/DDR1_MA[)
M_B_A3: CN2062.131(A3) U41.AL5(DDR1_MA[3])
M_B_A4: CN2062.128(A4) U41.AL6(DDR1_MA[4])
M_B_A5: CN2062.126(A5) U41.AM6(DDR1_MA[5]/DDR1_CAA[0]/DDR1_MA[)
M_B_A6: CN2062.127(A6) U41.AN7(DDR1_MA[6]/DDR1_CAA[2]/DDR1_MA[)
M_B_A7: CN2062.122(A7) U41.AN10(DDR1_MA[7]/DDR1_CAA[4]/DDR1_MA[)
M_B_A8: CN2062.125(A8) U41.AN8(DDR1_MA[8]/DDR1_CAA[3]/DDR1_MA[)
M_B_A9: CN2062.121(A9) U41.AR11(DDR1_MA[9]/DDR1_CAA[1]/DDR1_MA[)
M_B_A10: CN2062.146(A10/AP) U41.AH7(DDR1_MA[10]/DDR1_CAB[7]/DDR1_MA)
M_B_A11: CN2062.120(A11) U41.AN11(DDR1_MA[11]/DDR1_CAA[7]/DDR1_MA)
M_B_A12: CN2062.119(A12) U41.AR10(DDR1_MA[12]/DDR1_CAA[6]/DDR1_MA)
M_B_A13: CN2062.158(A13) U41.AF9(DDR1_MA[13]/DDR1_CAB[0]/DDR1_MA)
M_B_ACT#: CN2062.114(ACT#) U41.AT9(DDR1_MA[15]/DDR1_CAA[8]/DDR1_AC)
M_B_ALERT#: CN2062.116(ALERT#) U41.AR8(DDR1_ALERT#)
M_B_BA#0: CN2062.150(BA0) U41.AH8(DDR1_BA[0]/DDR1_CAB[4]/DDR1_BA[)
M_B_BA#1: CN2062.145(BA1) U41.AH9(DDR1_BA[1]/DDR1_CAB[6]/DDR1_BA[)
M_B_BG#0: CN2062.115(BG0) U41.AR9(DDR1_BA[2]/DDR1_CAA[5]/DDR1_BG[)
M_B_BG#1: CN2062.113(BG1) U41.AR7(DDR1_MA[14]/DDR1_CAA[9]/DDR1_BG)
M_B_CAS#: CN2062.156(A15/CAS#) U41.AF8(DDR1_CAS#/DDR1_CAB[1]/DDR1_MA[1)
M_B_CB0: CN2062.92(CB0/NC) R21422.2
M_B_CB1: CN2062.91(CB1/NC) R21423.2
M_B_CB2: CN2062.101(CB2/NC) R21424.2
M_B_CB3: CN2062.105(CB3/NC) R21425.2
M_B_CB4: CN2062.88(CB4/NC) R21426.2
M_B_CB5: CN2062.87(CB5/NC) R21429.2
M_B_CB6: CN2062.100(CB6/NC) R21428.2
M_B_CB7: CN2062.104(CB7/NC) R21430.2
M_B_CKE0: CN2062.109(CKE0) U41.AT8(DDR1_CKE[0])
M_B_CKE1: CN2062.110(CKE1) U41.AT10(DDR1_CKE[1])
M_B_CLKN0: CN2062.139(CK0#) U41.AN9(DDR1_CKN[0])
M_B_CLKN1: CN2062.140(CK1#) U41.AM8(DDR1_CKN[1])
M_B_CLKP0: CN2062.137(CK0) U41.AM9(DDR1_CKP[0])
M_B_CLKP1: CN2062.138(CK1) U41.AM7(DDR1_CKP[1])
M_B_CS#0: CN2062.149(CS0#) U41.AF11(DDR1_CS#[0])
M_B_CS#1: CN2062.157(CS1#) U41.AE7(DDR1_CS#[1])
M_B_DQ0: CN2062.4(DQ4) U41.BT11(DDR1_DQ[0]/DDR0_DQ[16])
M_B_DQ1: CN2062.8(DQ0) U41.BR11(DDR1_DQ[1]/DDR0_DQ[17])
M_B_DQ2: CN2062.21(DQ3) U41.BT8(DDR1_DQ[2]/DDR0_DQ[18])
M_B_DQ3: CN2062.17(DQ7) U41.BR8(DDR1_DQ[3]/DDR0_DQ[19])
M_B_DQ4: CN2062.3(DQ5) U41.BP11(DDR1_DQ[4]/DDR0_DQ[20])
M_B_DQ5: CN2062.7(DQ1) U41.BN11(DDR1_DQ[5]/DDR0_DQ[21])
M_B_DQ6: CN2062.16(DQ6) U41.BP8(DDR1_DQ[6]/DDR0_DQ[22])
M_B_DQ7: CN2062.20(DQ2) U41.BN8(DDR1_DQ[7]/DDR0_DQ[23])
M_B_DQ8: CN2062.25(DQ13) U41.BL12(DDR1_DQ[8]/DDR0_DQ[24])
M_B_DQ9: CN2062.29(DQ9) U41.BL11(DDR1_DQ[9]/DDR0_DQ[25])
M_B_DQ10: CN2062.41(DQ10) U41.BL8(DDR1_DQ[10]/DDR0_DQ[26])
M_B_DQ11: CN2062.38(DQ14) U41.BJ8(DDR1_DQ[11]/DDR0_DQ[27])
M_B_DQ12: CN2062.24(DQ12) U41.BJ11(DDR1_DQ[12]/DDR0_DQ[28])
M_B_DQ13: CN2062.28(DQ8) U41.BJ10(DDR1_DQ[13]/DDR0_DQ[29])
M_B_DQ14: CN2062.37(DQ15) U41.BL7(DDR1_DQ[14]/DDR0_DQ[30])
M_B_DQ15: CN2062.42(DQ11) U41.BJ7(DDR1_DQ[15]/DDR0_DQ[31])
M_B_DQ16: CN2062.49(DQ17) U41.BG11(DDR1_DQ[16]/DDR0_DQ[48])
M_B_DQ17: CN2062.45(DQ21) U41.BG10(DDR1_DQ[17]/DDR0_DQ[49])
M_B_DQ18: CN2062.59(DQ23) U41.BG8(DDR1_DQ[18]/DDR0_DQ[50])
M_B_DQ19: CN2062.58(DQ22) U41.BF8(DDR1_DQ[19]/DDR0_DQ[51])
M_B_DQ20: CN2062.46(DQ20) U41.BF11(DDR1_DQ[20]/DDR0_DQ[52])
M_B_DQ21: CN2062.50(DQ16) U41.BF10(DDR1_DQ[21]/DDR0_DQ[53])
M_B_DQ22: CN2062.63(DQ19) U41.BG7(DDR1_DQ[22]/DDR0_DQ[54])
M_B_DQ23: CN2062.62(DQ18) U41.BF7(DDR1_DQ[23]/DDR0_DQ[55])
M_B_DQ24: CN2062.66(DQ28) U41.BB11(DDR1_DQ[24]/DDR0_DQ[56])
M_B_DQ25: CN2062.71(DQ25) U41.BC11(DDR1_DQ[25]/DDR0_DQ[57])
M_B_DQ26: CN2062.79(DQ30) U41.BB8(DDR1_DQ[26]/DDR0_DQ[58])
M_B_DQ27: CN2062.84(DQ27) U41.BC8(DDR1_DQ[27]/DDR0_DQ[59])
M_B_DQ28: CN2062.67(DQ29) U41.BC10(DDR1_DQ[28]/DDR0_DQ[60])
M_B_DQ29: CN2062.70(DQ24) U41.BB10(DDR1_DQ[29]/DDR0_DQ[61])
M_B_DQ30: CN2062.83(DQ26) U41.BC7(DDR1_DQ[30]/DDR0_DQ[62])
M_B_DQ31: CN2062.80(DQ31) U41.BB7(DDR1_DQ[31]/DDR0_DQ[63])
M_B_DQ32: CN2062.186(DQ35) U41.AA11(DDR1_DQ[32]/DDR1_DQ[16])
M_B_DQ33: CN2062.187(DQ34) U41.AA10(DDR1_DQ[33]/DDR1_DQ[17])
M_B_DQ34: CN2062.182(DQ39) U41.AC11(DDR1_DQ[34]/DDR1_DQ[18])
M_B_DQ35: CN2062.183(DQ38) U41.AC10(DDR1_DQ[35]/DDR1_DQ[19])
M_B_DQ36: CN2062.169(DQ37) U41.AA7(DDR1_DQ[36]/DDR1_DQ[20])
M_B_DQ37: CN2062.173(DQ33) U41.AA8(DDR1_DQ[37]/DDR1_DQ[21])
M_B_DQ38: CN2062.174(DQ32) U41.AC8(DDR1_DQ[38]/DDR1_DQ[22])
M_B_DQ39: CN2062.170(DQ36) U41.AC7(DDR1_DQ[39]/DDR1_DQ[23])
M_B_DQ40: CN2062.190(DQ45) U41.W8(DDR1_DQ[40]/DDR1_DQ[24])
M_B_DQ41: CN2062.194(DQ41) U41.W7(DDR1_DQ[41]/DDR1_DQ[25])
M_B_DQ42: CN2062.204(DQ47) U41.V10(DDR1_DQ[42]/DDR1_DQ[26])
M_B_DQ43: CN2062.208(DQ43) U41.V11(DDR1_DQ[43]/DDR1_DQ[27])
M_B_DQ44: CN2062.195(DQ40) U41.W11(DDR1_DQ[44]/DDR1_DQ[28])
M_B_DQ45: CN2062.191(DQ44) U41.W10(DDR1_DQ[45]/DDR1_DQ[29])
M_B_DQ46: CN2062.207(DQ42) U41.V7(DDR1_DQ[46]/DDR1_DQ[30])
M_B_DQ47: CN2062.203(DQ46) U41.V8(DDR1_DQ[47]/DDR1_DQ[31])
M_B_DQ48: CN2062.225(DQ55) U41.R11(DDR1_DQ[48])
M_B_DQ49: CN2062.228(DQ50) U41.P11(DDR1_DQ[49])
M_B_DQ50: CN2062.216(DQ48) U41.P7(DDR1_DQ[50])
M_B_DQ51: CN2062.215(DQ49) U41.R8(DDR1_DQ[51])
M_B_DQ52: CN2062.229(DQ51) U41.R10(DDR1_DQ[52])
M_B_DQ53: CN2062.224(DQ54) U41.P10(DDR1_DQ[53])
M_B_DQ54: CN2062.211(DQ52) U41.R7(DDR1_DQ[54])
M_B_DQ55: CN2062.212(DQ53) U41.P8(DDR1_DQ[55])
M_B_DQ56: CN2062.246(DQ63) U41.L11(DDR1_DQ[56])
M_B_DQ57: CN2062.250(DQ59) U41.M11(DDR1_DQ[57])
M_B_DQ58: CN2062.233(DQ61) U41.L7(DDR1_DQ[58])
M_B_DQ59: CN2062.237(DQ56) U41.M8(DDR1_DQ[59])
M_B_DQ60: CN2062.245(DQ62) U41.L10(DDR1_DQ[60])
M_B_DQ61: CN2062.249(DQ58) U41.M10(DDR1_DQ[61])
M_B_DQ62: CN2062.236(DQ57) U41.M7(DDR1_DQ[62])
M_B_DQ63: CN2062.232(DQ60) U41.L8(DDR1_DQ[63])
M_B_DQSN0: CN2062.11(DQS#0) U41.BP9(DDR1_DQSN[0]/DDR0_DQSN[2])
M_B_DQSN1: CN2062.32(DQS#1) U41.BL9(DDR1_DQSN[1]/DDR0_DQSN[3])
M_B_DQSN2: CN2062.53(DQS#2) U41.BG9(DDR1_DQSN[2]/DDR0_DQSN[6])
M_B_DQSN3: CN2062.74(DQS#3) U41.BC9(DDR1_DQSN[3]/DDR0_DQSN[7])
M_B_DQSN4: CN2062.177(DQS#4) U41.AC9(DDR1_DQSN[4]/DDR1_DQSN[2])
M_B_DQSN5: CN2062.198(DQS#5) U41.W9(DDR1_DQSN[5]/DDR1_DQSN[3])
M_B_DQSN6: CN2062.219(DQS#6) U41.R9(DDR1_DQSN[6])
M_B_DQSN7: CN2062.240(DQS#7) U41.M9(DDR1_DQSN[7])
M_B_DQSN8: CN2062.95(DQS#8) R21431.2
M_B_DQSP0: CN2062.13(DQS0) U41.BR9(DDR1_DQSP[0]/DDR0_DQSP[2])
M_B_DQSP1: CN2062.34(DQS1) U41.BJ9(DDR1_DQSP[1]/DDR0_DQSP[3])
M_B_DQSP2: CN2062.55(DQS2) U41.BF9(DDR1_DQSP[2]/DDR0_DQSP[6])
M_B_DQSP3: CN2062.76(DQS3) U41.BB9(DDR1_DQSP[3]/DDR0_DQSP[7])
M_B_DQSP4: CN2062.179(DQS4) U41.AA9(DDR1_DQSP[4]/DDR1_DQSP[2])
M_B_DQSP5: CN2062.200(DQS5) U41.V9(DDR1_DQSP[5]/DDR1_DQSP[3])
M_B_DQSP6: CN2062.221(DQS6) U41.P9(DDR1_DQSP[6])
M_B_DQSP7: CN2062.242(DQS7) U41.L9(DDR1_DQSP[7])
M_B_DQSP8: CN2062.97(DQS8) R21427.2
M_B_EVENT#: CN2062.134(EVENT#) R21414.2
M_B_ODT0_CPU: CN2062.155(O\D\T\0\) U41.AF7(DDR1_ODT[0])
M_B_ODT1_CPU: CN2062.161(ODT1) U41.AE8(DDR1_ODT[1])
M_B_PARITY: CN2062.143(PARITY) U41.AJ7(DDR1_PAR)
M_B_RAS#: CN2062.152(A16/RAS#) U41.AH10(DDR1_RAS#/DDR1_CAB[3]/DDR1_MA[1)
M_B_WE#: CN2062.151(A14/WE#) U41.AH11(DDR1_WE#/DDR1_CAB[2]/DDR1_MA[14)
MAIND: PC51.1 PQ6.3(D) PQ9.2(G) PQ40.2(G) PQ9056.4(G) PR59.2
MAINON: PQ16.2(BASE) PR120.1 PR132.1 PR176.1 PR2020.2 PR67175.1 PR67223.1 R812.1 R20849.2 U49.30(PWM4/GPA4)
MAINON_ON_G: PQ6.2(G) PQ12.2(G) PQ14.2(G) PQ16.3(COLLECTOR) PQ19.2(G) PQ41.2(G) PQ9050.2(G) PR116.2 PR118.1
MARCO_1: R67395.2 T9029.1 U49.35(RTS1#/GPE5)
MARCO_2: R67364.1 R67365.2 T9030.1 U49.125(SSCE1#/GPG0)
MARCO_3: R67394.1 T9031.1 U49.76(TACH2/GPJ0(3))
MARCO_4: R67385.2 T9032.1 U49.16(PWUREQ#/BBO/SMCLK2ALT/GPC7(3))
MARCO_5: R67367.2 T9033.1 U49.126(GA20/GPB5(3))
MARCO_P: R67294.1 T9028.1
MB_THRMTRIP#: D13070.1(CATHODE) R21039.2 U13092.4(T\H\E\R\M\)
MBCLK: PC11.1 PD4.1 PR12.2 PR17.1 R388.1 R22061.1 U49.110(SMCLK0/GPB3)
MBCLK_CONN: PJ1.4 PJ9028.5 PR12.1
MBDATA: PC10.1 PD3.1 PR13.2 PR19.1 R20894.1 R22062.1 U49.111(SMDAT0/GPB4)
MBDATA_CONN: PJ1.3 PJ9028.4 PR13.1
MDI_0+: U13112.12(TD4-) U13143.11(TRXP0)
MDI_0-: U13112.11(TD4+) U13143.12(TRXN0)
MDI_1+: U13112.9(TD3-) U13143.14(TRXP1)
MDI_1-: U13112.8(TD3+) U13143.15(TRXN1)
MDI_2+: U13112.6(TD2-) U13143.17(TRXP2)
MDI_2-: U13112.5(TD2+) U13143.18(TRXN2)
MDI_3+: U13112.3(TD1-) U13143.20(TRXP3)
MDI_3-: U13112.2(TD1+) U13143.21(TRXN3)
ME_WR#: R21098.1 R21272.1 R21279.2 U49.109(TXD/SOUT0/GPB1)
MEM_VDD_CTRL: PR9141.2 R21576.2 U13114.BH4(GPIO8)
MEM_VPP: C95692.2 C95693.2 C95712.2 C95713.2 C95732.2 C95733.2 C95752.2 C95753.2 C95772.2 C95773.2 C95792.2 C95793.2 C95812.2 C95813.2 C95832.2 C95833.2 C96210.1 C96211.1 C96212.1 C96213.1 C96214.1 C96215.1 C96216.1 C96217.1 R67309.1 U13135.A3(VPP_1) U13135.W3(VPP_2) U13136.A3(VPP_1) U13136.W3(VPP_2) U13137.A3(VPP_1) U13137.W3(VPP_2) U13138.A3(VPP_1) U13138.W3(VPP_2) U13139.A3(VPP_1) U13139.W3(VPP_2) U13140.A3(VPP_1) U13140.W3(VPP_2) U13141.A3(VPP_1) U13141.W3(VPP_2) U13142.A3(VPP_1) U13142.W3(VPP_2)
MEM_VREF_CTL: Q7876.2(G) Q7877.2(G) Q7878.2(G) Q7879.2(G) R21577.2 U13114.BD3(GPIO10)
MIC2-L: C96039.1 U13108.30(MIC2-L/RING2)
MIC2-L_1: C94953.1 CN2059.1(L) D8577.1 R21459.2 R67187.2
MIC2-L_C: C96039.2 R67187.1
MIC2-R: C96038.1 U13108.31(MIC2-R/SLEEVE)
MIC2-R_1: C94952.1 CN2059.2(R) D8576.1 R21458.2 R67186.2
MIC2-R_C: C96038.2 R67186.1
MIC2-VREFO-L: R21459.1 U13108.28(MIC2-VREFO-L)
MIC2-VREFO-R: R21458.1 U13108.29(MIC2-VREFO-R)
MIC_JD#: CN2059.6 D8575.1 R22093.2
MIC_VCC_1.8V: C94703.2 C94704.2 CN2042.34 R20949.2
MODE: R21748.1 R21749.2 R67356.2 U13146.31(MODE)
MODE_1: R21906.2 R21909.1 R67357.2 U13147.31(MODE)
MODE_2: R21962.2 R21965.1 R67354.2 U13149.31(MODE)
MODE_3: R21943.2 R21945.1 R67355.2 U13148.31(MODE)
MP2949A__VFBA: PR66864.2 PR66867.1 PU37.7(VFBA)
MP2949A_ADDR_P: PR66866.2 PR66870.2 PU37.25(ADDR_P)
MP2949A_ALT#: PR66861.2 PU37.29(ALT#)
MP2949A_CS1: PR66841.1 PR66855.1 PU37.5(CS1)
MP2949A_CS2: PR66843.1 PR66857.2 PU37.4(CS2)
MP2949A_CS3: PR66844.1 PR66858.1 PU37.3(CS3)
MP2949A_CS4: PR66845.1 PR66852.2 PU37.2(CS4)
MP2949A_CS5: PR66846.1 PR66860.1 PU37.1(CS5)
MP2949A_CS6: PR66847.1 PR66862.2 PU37.48(CS6)
MP2949A_CSUMA: PR66877.2 PU37.18(CSSUMA)
MP2949A_CSUMB: PR66879.2 PU37.19(CSSUMB)
MP2949A_CSUMC: PR66881.2 PU37.20(CSSUMC)
MP2949A_EN: PC5585.1 PR66848.2 PU37.37(EN)
MP2949A_IMONA: PC5589.2 PR66885.2 PU37.21(IMONA)
MP2949A_IMONB: PC5592.2 PR66891.2 PU37.22(IMONB)
MP2949A_IMONC: PC5590.2 PR66887.1 PU37.23(IMONC)
MP2949A_IREF: PR66875.2 PU37.24(IREF)
MP2949A_PE: PC5591.1 PR66884.1 PR66889.2 PU37.36(PE)
MP2949A_PSYS: PC5587.2 PR66869.2 PR66871.2 PU37.46(PSYS)
MP2949A_PW1: PR66825.1 PU37.43(PWM1)
MP2949A_PW2: PR66826.1 PU37.42(PWM2)
MP2949A_PW3: PR66827.1 PU37.41(PWM3)
MP2949A_PW4: PR66835.1 PU37.40(PWM4)
MP2949A_PW5: PR66836.1 PU37.39(PWM5)
MP2949A_PW6: PR66839.1 PU37.38(PWM6)
MP2949A_SCL_P: PR66856.2 PR66931.2 PU37.33(SCL_P)
MP2949A_SCLK: PR66865.2 PU37.27(SCLK)
MP2949A_SDA_P: PR66850.2 PR66932.2 PU37.32(SDA_P)
MP2949A_SDIO: PR66863.2 PU37.28(SDIO)
MP2949A_SLP_SO#: PR66832.2 PR66849.2 PU37.35(SLP_S0#)
MP2949A_STB: PR66854.1 PU37.34(STB)
MP2949A_TEMP: PC5593.1 PR66893.2 PR66895.1 PU37.45(TEMP)
MP2949A_VDIFF_A: PR66864.1 PU37.6(VDIFFA)
MP2949A_VDIFF_B: PR66876.1 PU37.10(VDIFFB)
MP2949A_VDIFF_C: PR66898.1 PU37.14(VDIFFC)
MP2949A_VFB: PR66897.1 PR66898.2 PU37.15(VFBC)
MP2949A_VFBB: PR66876.2 PR66880.1 PU37.11(VFBB)
MP2949A_VIN_SEN: PR66840.2 PR66842.2 PU37.47(VIN_SEN)
MP2949A_VORTN: PR66894.1 PU37.17(VORTNC)
MP2949A_VORTNA: PR66874.1 PU37.9(VORTNA)
MP2949A_VORTNB: PR66886.1 PU37.13(VORTNB)
MP2949A_VOSEN: PR66892.1 PU37.16(VOSENC)
MP2949A_VOSENA: PR66872.1 PU37.8(VOSENA)
MP2949A_VOSENB: PR66883.1 PU37.12(VOSENB)
MP2949A_VRHOT#: PR66937.2 PU37.31(VRHOT#)
MP2949A_VRRDY: PR66853.2 PU37.30(VRRDY)
MP86903_GT_CS1: PR66951.2 PU46.18(CS)
MP86903_GT_CS2: PR66954.2 PU45.18(CS)
MP86903_GT_PWM1: PR66949.2 PU46.15(PWM)
MP86903_GT_PWM2: PR66952.2 PU45.15(PWM)
MP86903_GT_SYNC1: PR66950.2 PU46.16(SYNC)
MP86903_GT_SYNC2: PR66953.2 PU45.16(SYNC)
MP86903_GT_TEMP1: PR66915.2 PU46.17(VTEMP/FLT)
MP86903_GT_TEMP2: PR66920.2 PU45.17(VTEMP/FLT)
MP86903_VCCSA_CS: PR66957.2 PU43.10(CS)
MP86903_VCCSA_PWM: PR66955.2 PU43.7(PWM)
MP86903_VCCSA_SYNC: PR66956.2 PU43.8(SYNC)
MP86903_VCCSA_TEMP: PR66925.2 PU43.9(VTEMP/FLT)
MP86903_VCORE_CS1: PR66941.2 PU38.18(CS)
MP86903_VCORE_CS2: PR66944.2 PU39.18(CS)
MP86903_VCORE_CS3: PR66948.2 PU44.18(CS)
MP86903_VCORE_PWM1: PR66939.2 PU38.15(PWM)
MP86903_VCORE_PWM2: PR66942.2 PU39.15(PWM)
MP86903_VCORE_PWM3: PR66945.2 PU44.15(PWM)
MP86903_VCORE_SYNC1: PR66940.2 PU38.16(SYNC)
MP86903_VCORE_SYNC2: PR66943.2 PU39.16(SYNC)
MP86903_VCORE_SYNC3: PR66947.2 PU44.16(SYNC)
MP86903_VCORE_TEMP1: PR66900.2 PU38.17(VTEMP/FLT)
MP86903_VCORE_TEMP2: PR66905.2 PU39.17(VTEMP/FLT)
MP86903_VCORE_TEMP3: PR66946.2 PU44.17(VTEMP/FLT)
MX0: C94782.1(C1) CN2048.26 RP1.1(R2) U49.58(KSI0/STB#)
MX1: C94782.3(C3) CN2048.25 RP1.2(R4) U49.59(KSI1/AFD#)
MX2: C94782.5(C5) CN2048.24 RP1.3(R6) U49.60(KSI2/INIT#)
MX3: C94782.7(C7) CN2048.23 RP1.4(R8) U49.61(KSI3/SLIN#)
MX4: C94775.1(C1) CN2048.22 RP1.6(R9) U49.62(KSI4)
MX5: C94775.3(C3) CN2048.21 RP1.7(R7) U49.63(KSI5)
MX6: C94775.5(C5) CN2048.20 RP1.8(R5) U49.64(KSI6)
MX7: C94775.7(C7) CN2048.19 RP1.9(R3) U49.65(KSI7)
MY0: C94777.7(C7) CN2048.1 U49.36(KSO0/PD0)
MY1: C94777.5(C5) CN2048.2 U49.37(KSO1/PD1)
MY2: C94777.3(C3) CN2048.3 U49.38(KSO2/PD2)
MY3: C94777.1(C1) CN2048.4 U49.39(KSO3/PD3)
MY4: C94780.7(C7) CN2048.5 U49.40(KSO4/PD4)
MY5: C94780.5(C5) CN2048.6 U49.41(KSO5/PD5)
MY6: C94780.3(C3) CN2048.7 U49.42(KSO6/PD6)
MY7: C94780.1(C1) CN2048.8 U49.43(KSO7/PD7)
MY8: C94781.7(C7) CN2048.9 U49.44(KSO8/ACK#)
MY9: C94781.5(C5) CN2048.10 U49.45(KSO9/BUSY)
MY10: C94781.3(C3) CN2048.11 U49.46(KSO10/PE)
MY11: C94781.1(C1) CN2048.12 U49.51(KSO11/ERR#)
MY12: C94783.7(C7) CN2048.13 U49.52(KSO12/SLCT)
MY13: C94783.5(C5) CN2048.14 U49.53(KSO13)
MY14: C94783.3(C3) CN2048.15 U49.54(KSO14)
MY15: C94783.1(C1) CN2048.16 U49.55(KSO15)
MY16: CN2048.17 U49.56(KSO16/SMOSI/GPC3(3))
MY17: CN2048.18 U49.57(KSO17/SMISO/GPC5(3))
NBSWON#: C897.2 C94778.1 C95946.1 R823.1 R20887.1 R21049.1 R22150.1 U49.107(PWRSW/GPE4)
NGFF1_RST#: CN2069.50 R21737.1
NGFF2_RST#: CN2070.50 R21800.1
NGFF3_DET1: Q7874.3(D) R21176.1 R21188.2 R67278.1 U13113.AG36(GPP_E0/SATAXPCIE0/SATAGP0)
NGFF3_DET2: Q7875.3(D) R21177.1 R21187.2 R67280.1 U13113.AD35(GPP_F0/SATAXPCIE3/SATAGP3)
NGFF3_PEDET1: CN2069.69 Q7874.2(G) R21738.2 R21739.2 R67278.2 R67356.1 R67357.1
NGFF3_PEDET2: CN2070.69 Q7875.2(G) R21801.2 R21802.2 R67280.2 R67354.1 R67355.1
