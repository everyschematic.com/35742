# Allegro board DAZGLMB1ED0 dazglmb1ed0-d-ver a-165 (.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+5V_FAN1: length 3
  TOP w0.508: R230.1 328.49,78.66 328.26,78.43 v1(327.83,78.43) 327.75,78.51 CN2045.1
+5V_FAN2: length 2.2
  TOP w0.508: v1(57.48,76.9) CN2046.1
  BOTTOM w0.508: R22139.1 57.55,76.98 v1(57.48,76.9)
+5V_GPU_LED:
  vias: v1(85.11,80.31)
+5V_HDD:
  vias: v1(42.03,39.39) v1(42.18,40.05) v1(42.69,39.41) v1(42.84,40.05) v1(70.35,34.08) v1(70.35,33.37) v1(71.04,34.08) v1(71.01,33.39)
+5V_HDMIC: length 6.8
  TOP w0.508: D8559.3 v1(229.93,164.65) 230.41,164.65 231.21,165.45 231.21,168.8 Q7833.1
  vias: v1(230.42,171.16) v1(231.11,171.19)
+5V_KB_LED:
  vias: v1(254.27,51.63) v1(254.66,50.82) v1(254.96,51.63)
+5V_KB_M: length 13.3
  BOTTOM w0.381: R67302.2 125.75,52.52 123.36,54.91 123.36,56.1 124.27,57.01 129.68,57.01 129.84,57.17 129.84,57.45
  vias: v1(128.93,59.45) v1(129.59,59.45)
+5V_PVDD: length 4.7
  TOP w0.203: C94934.2 28.98,25.92 v1(28.98,26.38) 29.14,26.54 U13108.41 ; v1(32.46,27.22) 32.38,27.3 31.62,27.3 31.14,27.78 U13108.46
  vias: v1(30.93,25.24) v1(33.09,27.4) v1(45.79,44.75) v1(46.15,44.19)
+5V_S5: length 261.3
  TOP w0.508: v1(159.17,60.66) 159.17,60.04 158.97,59.84 PU9005.1 ; v1(148.36,57.12) 148.36,57.49 PR9061.1 ; v1(118.28,53.79) 118.28,57.73 116.35,59.66 116.35,60.95 116.89,61.48 v1(117.09,61.48) ; PR9132.1 113.57,67.27 v1(113.81,67.02)
  IN1 w0.508: v1(142.9,62.58) 141.96,61.64 137.15,61.64 136.6,62.2 136.6,67 135.82,67.77 v1(135.39,67.77) ; v1(151.58,68.98) 150.13,68.98 v1(148.79,70.32)
  IN2 w0.508: v1(161.69,68.93) 161.82,69.05 163.27,69.05 v1(163.3,69.03) 164.03,68.29 164.99,68.29 165.84,69.14 171.85,69.14 172.49,69.78 172.49,71.97 174.14,73.63 174.14,77.18 175.66,78.71 175.66,80.94 180.13,85.41 v1(180.39,85.41) ; v1(129.58,85.71) 131.21,87.34 131.21,93.03 131.97,93.79 131.97,96.21 v1(131.31,96.87) 131.21,96.97 131.21,98.77 132.35,99.91 v1(134.26,99.91)
  IN3 w0.508: v1(290.52,83.46) 293.53,83.46 294.81,84.74 297.69,84.74 299.56,82.87 304.83,82.87 305.38,82.32 332.15,82.32 333.29,83.46 334.13,83.46 335.12,84.45 335.12,85.18 336.75,86.81 338.35,86.81 339.87,88.33 341.06,88.33 344.34,91.61 349.83,91.61 v1(350.54,92.32)
  IN5 w0.508: v1(100.86,78.45) 100.86,77.94 101.24,77.56 105.48,77.56 106.95,76.09 106.95,73.63 108.35,72.23 111.02,72.23 111.4,72.61 115.97,72.61 v1(117.39,74.03) 119.88,74.03 121,72.91 121.65,72.91 122.18,73.45 123.54,73.45 124.91,74.82 124.91,84.4 v1(125.32,84.8)
  BOTTOM w0.508: 159.13,62.32 159.18,62.27 159.18,60.67 v1(159.17,60.66) 159.17,60.16 PC9082.1 ; 159.13,62.32 162.22,62.32 162.71,62.81 162.71,66.34 162.76,66.39 162.76,68.49 v1(163.3,69.03) ; 159.13,62.32 158.59,62.32 158.11,62.81 157.22,62.81 155.37,60.95 152.65,60.95 151.73,61.87 150.08,61.87 148.52,63.43 147.17,63.43 146.79,63.05 146.79,63.05 146.71,62.97 146.71,62.56 146.34,62.19 PR9014.1 ; v1(125.32,84.8) 125.37,84.85 127.83,84.85 128.69,85.71 v1(129.58,85.71) ; PR9014.1 146.48,61.78 146.48,59.68 148.36,57.8 v1(148.36,57.12) ; PR9014.1 145.95,62.07 144.46,62.07 PR9013.1 143.97,61.81 143.4,61.81 142.9,62.32 v1(142.9,62.58) 142.39,62.58 142.02,62.21 PR9015.1 ; v1(117.09,61.48) 117.09,61.97 116.61,62.45 116.33,62.45 113.81,64.97 v1(113.81,67.02) 113.81,70.45 v1(117.39,74.03) ; PR9237.1 148.06,70.32 v1(148.79,70.32) 149.17,70.7 149.17,71.37 148.74,71.8 PR9053.1 ; v1(100.86,78.45) 100.86,78.2 101.87,77.18 PR9209.1 ; v1(151.58,68.98) 152.52,68.04 160.8,68.04 v1(161.69,68.93) ; R21165.1 290.82,83.15 v1(290.52,83.46)
  vias: v1(21.03,65.55) v1(21,64.89) v1(21.1,64.2) v1(23.85,91.2) v1(23.85,90.32) v1(24.2,88.78) v1(24.75,89.85) v1(24.77,89.18) v1(120.09,55.54) v1(120.77,55.54) v1(351.2,92.32) v1(351.86,92.32) v1(360.9,37.91) v1(361.49,38.22) v1(361.54,37.46) v1(361.79,36.85) v1(363.8,38.42) v3(112.92,53.33) v3(113.28,53.99) v3(113.69,53.31) v3(114.04,53.97) v3(114.45,53.31) v3(114.8,53.97)
+5V_TOBII: length 17.3
  TOP w0.203: v1(28.34,80.92) 28.6,81.17 C96024.2
  TOP w0.508: Q7924.1 v1(28.04,90.82) 28.04,89.22 27.33,88.52 C96022.1 27.81,88.05 v1(28.19,88.43) ; v1(30.3,83.5) CN2079.2
  BOTTOM w0.508: v1(28.19,88.43) 28.19,86.4 30.3,84.29 v1(30.3,83.5) 28.92,82.13 C96023.2 28.21,81.65 28.34,81.53 v1(28.34,80.92)
+5V_TP_PLASTIC: length 10
  TOP w0.508: v1(134.69,54.73) 134.67,54.7 134.31,54.7 134,54.39 CN2078.2
  IN2 w0.381: v1(140.46,54.78) 139.91,55.34 134.97,55.34 134.69,55.06 v1(134.69,54.73)
  BOTTOM w0.508: R67311.2 141.02,55.34 v1(140.46,54.78)
+5V_TP_RGB: length 4
  TOP w0.305: v1(137.38,59.27) 137.38,59.81 137.55,59.98 CN2076.11 ; v1(138.04,59.27) 138.04,60.11 138.05,60.11 CN2076.12
  vias: v1(137.26,60.16)
+5V_UIF: length 81.5
  TOP w0.254: LED1.4 376.62,33.33 376.5,33.44 376.5,34.58 376.3,34.77 374.84,34.77 374.4,35.21 374.4,36.91 372.05,39.26 371.52,39.26 371.34,39.44 369.95,39.44 v1(369.64,39.74) 369.62,39.77 v1(368.78,39.77)
  TOP w0.305: v1(378.26,13.91) 376.93,15.24 376.93,17.47 378.02,18.56 378.84,18.56 379.14,18.25 379.91,18.25 380.21,18.55 380.21,19.32 379.52,20.01 378.99,20.01 377.22,21.77 LED2.4
  IN2 w0.254: v1(378.26,13.91) 377.6,13.25 372.97,13.25 v1(371.88,12.16)
  IN4 w0.305: v1(368.78,39.77) 368.78,38.7 366.83,36.75 366.82,36.75 366.8,36.73 366.39,36.73 366.32,36.8 365.76,36.8 365.54,36.57 365.54,32.73 366.2,32.07 366.2,23.47 366.02,23.29 366.02,22.87 366.02,22.87 366.02,21.43 366.95,20.5 366.95,20.12 367.64,19.43 369.28,19.43 369.66,19.04 373.8,19.04 374.28,19.53 374.95,19.53 375.31,19.16 375.31,18.58 375.8,18.1 376.28,18.1 376.98,17.39 376.98,15.84 377.49,15.33 377.49,14.69 v1(378.26,13.91)
  BOTTOM w0.254: C96258.2 379.27,12.59 379.3,12.62 379.3,12.97 378.89,13.38 378.8,13.38 v1(378.26,13.91) 378.26,12.88 377.79,12.4 C96259.1 ; v1(371.88,12.16) 371.88,12.56 372.07,12.76 R67391.2
  BOTTOM w0.305: v1(368.78,39.77) 368.5,39.5 366.75,39.5 366.63,39.62 365.89,39.62 R67392.2
+5VA: length 1.9
  TOP w0.203: U13108.40 28.74,27.74 28.67,27.68 28.67,27.47 28.52,27.32
  BOTTOM w0.508: R22091.1 22.3,31.46 v1(21.97,31.13)
  vias: v1(21.46,30.73) v1(22.39,30.63) v1(27.58,26.25) v1(27.93,25.65)
+5VPCU: length 487.7
  TOP w0.254: PU9015.7 238.03,161.27 237.84,161.46 ; R67269.1 v1(34.22,73.12) ; C94776.2 180.69,49.95 180.99,49.65 181.22,49.65 181.82,49.05 182.81,49.05 v1(182.93,48.94) 182.93,48.99 183.38,48.53 185.26,48.53 185.35,48.62 CN2071.1
  TOP w0.381: PR9223.2 104.68,75.16 v1(105.18,75.66) ; R67268.2 33.23,73.97 v1(33.62,73.58) 33.82,73.58 R67269.1 ; 237.61,161.69 237.76,161.84 237.76,162.91 238.15,163.29 238.53,163.29 PC223.1 ; 237.61,161.69 237.84,161.46 ; 237.61,161.69 v1(237.59,161.69) ; v1(40.57,74.12) PR175.2
  IN1 w0.381: v1(105.18,75.66) 104.64,75.12 104.64,73.14 105.18,72.61 105.18,64.13 v1(105.28,64.02)
  IN1 w0.508: v1(33.62,73.58) 33.9,73.85 37.92,73.85 38.3,73.47 39.92,73.47 v1(40.57,74.12)
  IN2 w0.381: v1(237.59,161.69) 243.91,161.69 244.47,161.13 253.64,161.13 254.53,162.02 258.85,162.02 258.97,161.89 262.91,161.89 264.05,160.75 267.36,160.75 268.65,159.45 268.65,159.1 v1(270.38,157.37) ; v1(274.16,111.55) 273.96,111.55 273.63,111.88 273.63,112.41 272.26,113.78 270.05,113.78 266.04,117.79 266.04,121.2 267.41,122.56 267.41,123.31 268.04,123.94 270.23,123.94 270.78,123.38 272.65,123.38 274.21,124.95 274.21,131.36 v1(274.16,131.41)
  IN3 w0.254: v1(182.93,48.94) 180.82,48.94 180.08,49.67 178.2,49.67 177.39,50.49 v1(177.39,51.55)
  IN3 w0.381: v1(23.32,34.54) 22.79,34.54 22.12,35.21 22.12,50.89 25.29,54.07 25.29,58.67 21.97,61.99 21.97,67.23 25.65,70.91 30.96,70.91 v1(33.62,73.58) ; v1(193.9,66.51) 194.94,67.56 195.07,67.56 197.9,70.39 199.58,70.39 202.19,73 202.19,73.84 203.03,74.69 203.03,76.71 204.97,78.65 206.48,78.65 212.07,84.24 277.14,84.24 284.55,76.82 v1(284.55,76.17)
  IN3 w0.508: v1(40.57,74.12) 40.57,74.42 40.89,74.74 40.89,75.4 41.54,76.05 42.76,76.05 42.77,76.04 44.6,76.04 45.36,75.28 50.95,75.28 52.73,73.5 55.65,73.5 57.42,75.28 61.36,75.28 62.52,76.43 75.08,76.43 75.34,76.17 79.9,76.17 80.92,75.15 83.28,75.15 84.32,76.19 86.58,76.19 87.24,75.53 88.92,75.53 89.28,75.89 94.02,75.89 94.3,75.61 95.07,75.61 95.78,74.9 103.53,74.9 104.29,75.66 v1(105.18,75.66)
  IN5 w0.381: v1(362.86,36.67) 362.86,35.5 364.05,34.31 364.05,33.41 365.02,32.44 365.02,31.33 365.81,30.55 365.81,29.24 366.12,28.93 366.12,24.01 365.79,23.68 364.78,23.68 363.95,22.85 363.95,21.1 365.78,19.27 369.93,19.27 370.54,18.66 373.47,18.66 374.41,19.6 374.97,19.6 375.37,19.2 375.37,18.24 376.55,17.06 376.55,15.61 376.04,15.1 375.28,15.1 373.22,13.05 373.22,9.16 372.66,8.6 v1(371.98,8.6) ; v1(274.19,142.64) 273.53,141.98 273.53,140.22 274.16,139.59 v1(274.16,131.41)
  BOTTOM w0.254: v1(177.39,51.55) 176.68,52.26 172.97,52.26 169.44,55.8 169.44,57.9 v1(169.87,58.34) ; R67401.2 122.44,63.06 v1(122.47,63.06)
  BOTTOM w0.381: v1(23.32,34.54) 23.26,34.48 R22090.1 ; v1(270.38,157.37) 270.43,157.32 272.75,157.32 274.19,155.88 v1(274.19,142.64) ; R21707.1 R21708.1 365.31,49.63 v1(365.91,49.63) ; v1(285.57,56.28) 285.57,59.25 287.11,60.79 287.11,63.2 284.32,65.99 284.32,71.49 284.55,71.72 v1(284.55,76.17) 285.07,76.69 285.07,80.49 286.84,82.26 286.84,85.51 279.93,92.42 279.93,97.63 276.75,100.8 276.75,103.55 276.17,104.13 276.17,105.35 273.83,107.69 273.83,111.22 v1(274.16,111.55)
  vias: v1(97.33,62.98) v1(105.96,64) v1(360.34,53.79) v1(360.37,53.13) v1(365.96,38.35) v1(366.06,37.63) v1(366.64,38.5) v1(366.59,37.23) v1(366.87,37.86) v3(98.14,61.87) v3(98.11,61.05) v3(98.11,60.29) v3(98.11,59.53) v3(98.11,58.77) v3(98.88,61.1) v3(98.88,60.34) v3(98.88,59.55) v3(98.88,58.79) v3(98.98,61.94) v3(99.46,58.28) v3(99.59,61.36) v3(99.59,60.6) v3(99.59,59.83) v3(99.59,59.05)
+5VPD: length 3.1
  BOTTOM w0.254: R67137.2 367,30.37 v1(365.65,31.72)
+12V_PANEL: length 31.2
  TOP w0.508: PR67172.1 361.36,85.9 v1(362.2,85.06) ; v1(334.94,82.8) 334.58,82.43 334.58,82.42 C94701.1
  IN1 w0.508: v1(362.2,85.06) 361.92,84.78 340.18,84.78 339.8,84.4 339.8,84.37 335.88,84.37 334.94,83.43 v1(334.94,82.8)
  vias: v1(358.16,78.83) v1(358.8,78.45) v1(372.03,86.88) v3(371.3,87.05) v3(371.9,87.62)
+A3VPCU: length 1.3
  TOP w0.203: v1(192.81,56.73) 192.87,56.8 U49.74
  vias: v1(192.2,56.46)
+VCC3P3_LC: length 16.5
  TOP w0.254: U21.R6 v4(348.42,56.09)
  IN1 w0.254: v1(340.56,56.57) 340.68,56.45 345.05,56.45 346.48,57.88 347.25,57.88 347.9,57.23 348.65,57.23 348.89,56.99 348.89,56.56 v4(348.42,56.09)
  BOTTOM w0.127: v1(339.91,56.57) v1(340.56,56.57)
  BOTTOM w0.203: v1(340.56,56.57) 340.68,56.45 C94601.2
  BOTTOM w0.254: R20846.1 R20845.1 R20847.1 R454.1 341.55,56.73 C94601.2
+VCC3P3_S0: length 48.6
  TOP w0.254: v4(348.42,52.19) U21.R13 ; C95892.2 342.59,49.14 342.82,49.37 342.82,50.72 v1(343.77,51.67)
  IN2 w0.254: v4(348.42,52.19) 347.94,52.67 346.35,52.67 345.97,52.29 344.39,52.29 v1(343.77,51.67) 343.77,52.17 343.56,52.39 343.56,54.19 344.06,54.7 344.57,54.7 344.95,55.08 344.95,57.5 345.56,58.11 345.56,59.43 345.33,59.66 345.33,60.65 344.16,61.81 342.79,61.81 v1(342.54,62.07)
  IN4 w0.254: v1(342.54,62.07) 342.79,61.81 346.22,61.81 348.1,63.69 348.1,64.94 349.57,66.41 353.26,66.41 353.72,65.96 353.72,65.62 353.87,65.47 353.87,63.75 353.21,63.08 352.57,63.08 v1(352.45,62.96)
  BOTTOM w0.254: R67056.2 354.6,62.53 353.89,63.24 353.38,63.24 353.23,63.08 352.57,63.08 v1(352.45,62.96) 352.45,62.3 352.57,62.17 R67055.2 ; R67053.2 344.95,61.66 344.84,61.77 R67151.1 R67152.1 342.83,61.77 v1(342.54,62.07)
  vias: v1(339.72,49.8)
+VCC3P3_SX: length 44.7
  TOP w0.254: R20860.1 R20859.1 346.35,62.22 v1(346.1,62.48) ; v1(336.21,65.96) 335.94,66.23 335.15,66.23 335.05,66.13 R67049.2 ; v1(351.28,62.58) 351.38,62.48 351.38,61.68 R67153.1 ; R20693.2 344.83,62.58 v1(344.7,62.45) ; Q7886.2 338.67,59.69 338.67,58.8 338.91,58.56 v1(338.91,58.31) 339.31,58.31 339.49,58.13 339.87,58.13 340,58.26 R22031.1 ; U21.F8 v4(352.97,54.79)
  IN1 w0.254: v1(338.91,58.31) 337.98,59.24 337.98,64.37 336.39,65.96 v1(336.21,65.96)
  IN4 w0.254: v1(338.91,58.31) 338.6,58.62 338.6,61.69 339.87,62.96 344.19,62.96 v1(344.7,62.45)
  BOTTOM w0.254: R22035.2 357.24,62.16 356.93,61.85 356.93,60.02 354.61,57.71 354.61,56.74 354.25,56.38 C94600.2 354.2,55.97 353.63,55.4 353.63,55.15 353.27,54.79 v4(352.97,54.79) ; v1(351.28,62.58) 351.28,62.3 351.18,62.2 R20861.1 R67158.2 R20862.2 R67051.2 ; R67193.2 355.62,62.27 354.91,62.98 v1(354.91,63.9)
  vias: v1(345.38,62.48) v1(358.21,63.57) v1(358.52,64.15) v1(358.87,63.57)
+VCC_CORE:
  vias: v1(232.02,112.54) v1(232.3,113.5) v1(233.01,123.64) v1(233.04,122.39) v1(233.04,121.12) v1(233.01,119.8) v1(233.17,118.56) v1(233.17,117.26) v1(233.17,115.99) v1(233.77,128.1) v1(233.77,127.46) v1(234.56,130.06) v1(234.55,129.41) v1(234.55,128.76) v1(234.55,128.1) v1(234.55,127.46) v1(236.13,130.71) v1(236.13,130.06) v1(236.13,129.41) v1(236.13,127.46) v1(237.23,123.33) v1(237.23,122.67) v1(237.23,122.01) v1(237.23,116.55) v1(237.26,121.07) v1(237.26,120.41) v1(237.26,119.75) v1(237.26,119.09) v1(237.26,115.61) v1(237.26,114.95) v1(237.26,114.29) v1(237.26,113.63) v1(237.71,131.36) v1(237.71,130.71) v1(237.71,130.06) v1(237.7,129.41) v1(237.7,127.46) v1(237.7,126.81) v1(239.28,130.06) v1(239.28,129.41) v1(239.28,128.76) v1(239.28,128.1) v1(239.28,127.46) v1(239.28,126.81) v1(240.86,130.06) v1(240.86,129.41) v1(240.85,128.76) v1(241.18,112.54) v1(242.43,131.36) v1(242.43,130.71) v1(242.43,130.06) v1(242.43,129.41) v1(242.43,128.76) v1(242.43,128.1) v1(242.43,127.46) v1(242.43,126.81) v1(242.37,122.95) v1(242.37,122.29) v1(242.37,121.63) v1(242.4,120.69) v1(242.4,120.03) v1(242.4,119.37) v1(242.4,118.71) v1(242.37,115.49) v1(242.37,114.83) v1(242.37,114.17) v1(242.5,132.1) v1(242.53,113.46) v1(243.22,130.71) v1(243.22,130.06) v1(243.22,129.41) v1(243.21,128.76) v1(243.21,126.81) v1(245.61,116.3) v1(245.64,115.36) v1(245.64,114.7) v1(245.64,114.04) v1(245.64,113.38) v1(245.74,123.08) v1(245.74,122.42) v1(245.74,121.76) v1(245.77,120.82) v1(245.77,120.16) v1(245.77,119.5) v1(245.77,118.84) v1(258.13,145.99) v3(234.56,143.22) v3(234.56,142.46) v3(234.56,141.7) v3(234.56,140.94) v3(235.33,143.22) v3(235.33,142.46) v3(235.33,141.7) v3(235.33,140.94) v3(236.09,143.22) v3(236.09,142.46) v3(236.09,141.7) v3(236.09,140.94) v3(236.62,139.03) v3(236.62,138.27) v3(236.62,137.51) v3(236.62,136.74) v3(236.85,143.22) v3(236.85,142.46) v3(236.85,141.7) v3(236.85,140.94) v3(237.38,139.03) v3(237.38,138.27) v3(237.38,137.51) v3(237.38,136.74) v3(238.15,139.03) v3(238.15,138.27) v3(238.15,137.51) v3(238.15,136.74) v3(238.91,139.03) v3(238.91,138.27) v3(238.91,137.51) v3(238.91,136.74) v3(245.77,138.19) v3(246.02,143.27) v3(246.15,138.9) v3(246.78,143.27) v3(246.91,138.9) v3(247.54,143.27) v3(248.31,143.27) v3(248.94,142.84) v3(249.32,143.58) v3(249.7,142.84) v3(250.08,143.58) v3(250.46,142.84) v3(250.85,143.58) v3(251.23,142.84)
+VCC_GT:
  vias: v1(246.37,130.06) v1(246.36,129.41) v1(246.36,128.76) v1(246.37,128.1) v1(247.15,130.71) v1(247.15,130.06) v1(247.15,129.41) v1(247.15,128.76) v1(247.15,128.1) v1(247.94,127.46) v1(247.94,126.81) v1(247.95,123.84) v1(247.95,123.18) v1(247.95,121.68) v1(247.95,121.02) v1(247.95,120.36) v1(247.95,118.63) v1(247.95,117.97) v1(247.95,117.31) v1(248.01,116.6) v1(248.01,115.94) v1(248.01,115.28) v1(248.01,114.62) v1(248,113.45) v1(248.65,113.43) v1(248.73,130.06) v1(248.73,129.41) v1(248.73,128.76) v1(248.73,128.1) v1(248.73,127.46) v1(248.73,126.81) v1(250.3,131.36) v1(250.3,130.71) v1(250.3,130.06) v1(250.3,129.41) v1(250.3,127.46) v1(250.3,126.81) v1(251.02,113.5) v1(251.84,113.5) v1(251.88,131.36) v1(251.88,130.71) v1(251.88,130.06) v1(251.88,129.41) v1(251.88,128.76) v1(251.88,128.1) v1(251.88,127.46) v1(251.88,126.81) v1(252.66,127.46) v1(252.66,126.81) v1(253,113.58) v1(253.45,130.06) v1(253.45,129.41) v1(253.45,128.76) v1(253.45,128.1) v1(253.45,127.46) v1(253.45,126.81) v1(253.93,118.71) v1(253.93,118) v1(253.93,117.34) v1(253.91,116.63) v1(253.91,115.97) v1(253.91,115.28) v1(253.91,114.57) v1(254.01,123.56) v1(254.01,122.78) v1(254.01,121.71) v1(254.01,121.05) v1(254.67,123.56) v1(254.67,122.78) v1(254.67,121.71) v1(254.67,121.05) v1(254.69,118.71) v1(254.69,118) v1(254.69,117.34) v1(254.72,116.66) v1(254.72,116) v1(254.72,115.31) v1(254.72,114.6) v1(254.77,124.33) v1(255.03,131.36) v1(255.03,130.71) v1(255.03,130.06) v1(255.03,129.41) v1(255.03,127.46) v1(255.03,126.81) v1(255.81,126.81) v1(256.6,130.71) v1(256.6,130.06) v1(256.6,129.41) v1(256.6,128.76) v1(256.6,128.1) v1(256.6,127.46) v1(256.6,126.81) v1(257.39,130.06) v1(257.39,129.41) v1(257.39,127.46) v1(257.39,126.81) v1(258.17,126.81) v1(258.34,144.57) v1(258.97,130.71) v1(258.97,130.06) v1(258.96,129.41) v1(258.96,128.76) v1(258.96,128.1) v1(258.96,127.46) v1(258.96,126.81) v1(259.35,113.5) v1(259.75,126.81) v1(260.14,123.87) v1(260.14,122.5) v1(260.12,116.42) v1(260.14,115.74) v1(260.15,123.18) v1(260.15,118.89) v1(260.15,118.23) v1(260.15,117.57) v1(261.33,130.06) v1(261.33,129.41) v3(254.15,137.56) v3(254.15,136.8) v3(254.91,137.56) v3(254.91,136.8) v3(255.67,137.56) v3(255.67,136.8) v3(259.1,143.09) v3(259.1,142.33) v3(259.1,141.57) v3(259.23,138.52) v3(259.86,143.09) v3(259.86,142.33) v3(259.86,141.57) v3(259.99,138.52) v3(260.75,138.52) v3(261.51,138.52) v3(264.43,143.22) v3(264.43,142.46) v3(264.43,141.7) v3(265.2,143.22) v3(265.2,142.46) v3(265.2,141.7) v3(265.96,143.22) v3(265.96,142.46) v3(265.96,141.7) v3(265.96,140.94) v3(266.72,143.22) v3(266.72,142.46) v3(266.72,141.7) v3(266.72,140.94) v3(271.67,143.22) v3(271.67,142.46) v3(271.67,141.7)
+VCC_SA:
  vias: v1(226.36,142.16) v1(230.62,128.76) v1(230.62,128.1) v1(232.19,131.36) v1(232.19,130.71) v1(232.19,130.06) v1(232.19,129.41) v1(232.19,127.45) v1(232.19,126.81) v3(225.57,139.56) v3(226.33,139.92) v3(226.89,137.38) v3(226.89,136.62) v3(226.94,135.86) v3(226.97,135.07) v3(227.1,140.68) v3(227.1,139.92) v3(227.1,139.16) v3(227.12,138.4) v3(227.65,137.38) v3(227.65,136.62) v3(227.71,135.86) v3(228.8,137.51) v3(228.8,136.74)
+VCCAMPHY_1P0:
  vias: v1(298.7,64.18) v2(298.44,64.79) v2(299.05,64.74) v2(299.77,64.74) v2(299.79,63.95)
+VCCAMPHYPLL_1P0: length 0.6
  TOP w0.254: U13113.B43 291.99,73.37 291.83,73.53 U13113.A43
  vias: v1(287.8,76.64)
+VCCAPLLEBB: length 0.5
  TOP w0.254: U13113.V28 300.18,65.93 v2(300.54,66.28)
  vias: v1(300.63,67)
+VCCATS: length 0.8
  TOP w0.254: U13113.AD13 303.69,57.93 v2(303.69,57.88)
  vias: v1(301.95,56.02)
+VCCCLK1: length 2.7
  TOP w0.254: U13113.N17 297.27,60.4 v2(297.27,60.06)
  BOTTOM w0.254: R21336.2 296.07,59.53 296.75,59.53 v2(297.27,60.06)
+VCCCLK2: length 3.5
  TOP w0.254: U13113.R17 298.7,60.33 v2(298.92,60.11) ; v2(299.8,60.86) U13113.V17
  BOTTOM w0.508: R21340.2 299.8,61.04 v2(299.8,60.86) 299.05,60.11 v2(298.92,60.11)
+VCCCLK3: length 5.6
  TOP w0.254: v2(298.16,61.21) 298.7,61.75 U13113.R19
  BOTTOM w0.381: v2(298.16,61.21) 298.16,61.47 297.87,61.75 v1(296.66,61.75) 295.89,61.75 295.6,62.04 295.6,62.73 295.95,63.08 R21338.2
+VCCCLK4: length 2
  TOP w0.254: U13113.U20 299.41,61.84 298.9,61.33 v2(298.9,61.1)
  BOTTOM w0.508: R21339.2 299.03,61.88 299.03,61.23 v2(298.9,61.1)
+VCCCLK5: length 1.4
  TOP w0.254: v1(296.38,52.44) 296.38,52.83 U13113.K2 296.08,53.54 U13113.K3
  vias: v1(296.41,51.76)
+VCCDSW3P3: length 14.3
  TOP w0.254: U13113.BA24 311.37,64.23 v2(311.06,63.93) ; v2(301.29,59.34) 300.87,59.76 U13113.W15
  IN4 w0.254: v2(301.29,59.34) 301.29,60.44 302.96,62.12 304.14,62.12 305.95,63.93 v2(311.06,63.93)
  BOTTOM w0.254: v2(311.06,63.93) 310.89,64.1 C94830.2
  vias: v1(301.52,58.77)
+VCCDSW_1.0V: length 1
  TOP w0.254: U13113.BA29 311.16,66.52 310.79,66.89 v2(310.79,67.15)
  vias: v1(307.92,66.84)
+VCCHDAPLL_1P0: length 1.7
  TOP w0.254: U13113.AN19 307.64,62.09 v2(307.99,62.44)
  BOTTOM w0.508: v2(307.99,62.44) 307.78,62.65 R21354.2
+VCCIO: length 635.7
  TOP w0.191: U41.AG12 244.17,111.57 v1(243.92,111.31)
  TOP w0.508: C94495.1 218.6,139.4 219.1,138.9 219.1,137.1 218.92,136.92 218.92,135.53 219.16,135.28 219.67,135.28 222.02,132.93 R116.1 ; R21106.2 312.69,45.94 311.43,44.68 304.94,44.68 304.19,45.43 v1(304.19,45.66) ; R566.2 272.82,127.75 v1(272.92,127.65) ; PR66938.1 266.03,170.63 v1(265.45,171.21) ; v1(28.85,70.2) 27.59,70.2 PR111.1 v1(27.58,69.26) ; R20758.2 273.69,126 v1(273.32,126)
  IN1 w0.508: v1(131.55,62.87) 131.55,65.21 127.86,68.9 v1(127.86,70.07) ; v1(27.58,69.26) 27.76,69.43 29.67,69.43 30.91,68.2 30.91,67.33 v1(40.1,58.13)
  IN2 w0.508: v1(128.06,112.21) 128.06,111.61 128.52,111.15 128.52,99.61 129.47,98.66 129.47,89.51 127.52,87.56 127.52,84.61 126.65,83.75 126.65,72.24 127.4,71.49 127.4,70.53 v1(127.86,70.07) ; v1(295.9,76.47) 295.85,76.42 293.39,76.42 292.25,75.28 292.25,74.01 291.36,73.12 291.36,69.56 291.99,68.93 291.99,64.23 291.36,63.59 289.83,63.59 289.07,62.83 v1(287.83,62.83) ; 271.09,124.73 270.9,124.54 267.79,124.54 267.32,124.07 266.21,124.07 265.51,123.37 265.51,117.54 270.02,113.02 272.03,113.02 273.1,111.95 273.1,111.19 273.83,110.46 273.83,108.93 275.13,107.64 275.13,104.59 277.77,101.95 277.77,97.63 278.66,96.74 278.66,88.39 v1(279.56,87.48)
  IN3 w0.508: v1(231.02,115.44) 230.23,114.65 226.11,114.65 225.42,113.96 224.07,113.96 223.16,113.05 216.56,113.05 212.31,108.8 212.31,105.83 209.29,102.81 208.45,102.81 208,102.35 v1(208,101.92) 208,101.67 207.64,101.31 204.92,101.31 203.3,99.69 203.3,98.62 201.06,96.38 201.06,92.78 196.09,87.8 192.36,87.8 191.14,89.02 178.73,89.02 177.1,87.38 177.1,86.82 175.53,85.26 175.53,83.86 174.85,83.18 174.09,83.18 173.63,82.72 173.63,79.42 176.19,76.85 176.19,71.06 175.66,70.53 174.11,70.53 172.46,68.88 166.27,68.88 164.28,66.88 164.28,63.77 163.75,63.24 156.51,63.24 155.16,61.89 152.98,61.89 151.02,59.94 147.44,59.94 146.4,60.97 137.94,60.97 136.58,62.33 132.09,62.33 v1(131.55,62.87) 131.03,62.35 126.88,62.35 124.34,59.81 107.21,59.81 106.43,60.58 103,60.58 101.85,59.43 101.85,56.19 100.02,54.35 87.93,54.35 85.99,52.42 73.88,52.42 73.01,53.29 69.96,53.29 69.21,54.04 69.21,54.49 68.17,55.53 67.69,55.53 67.26,55.11 v1(66.8,55.11)
  IN4 w0.508: v1(129.27,113.82) 128.94,113.82 128.42,114.34 128.42,115.21 127.27,116.35 126.56,116.35 125.5,115.28 124.81,115.28 124.43,114.9 v1(124.43,114.72) ; v1(287.83,62.83) 287.83,60.07 286.49,58.73 286.49,58.37 283.99,55.87 283.99,54.08 283.59,53.67 283.26,53.67 282.85,53.27 282.85,52.61 283.8,51.65 288.54,51.65 288.87,51.32 v1(288.87,51.1) ; v1(229.48,115.42) 229.48,115.05 229.05,114.62 226.05,114.62 225.55,114.11 225.55,99.53 224.63,98.62 224.63,97.98 225.19,97.43 v1(225.52,97.43) ; v1(66.8,55.11) 64.01,55.11 62.44,56.68 61.52,56.68 60.24,57.95 56.81,57.95 55.55,59.22 53.24,59.22 51.91,60.54 49.3,60.54 48.78,61.07 43.67,61.07 41.55,58.94 40.91,58.94 v1(40.1,58.13)
  IN5 w0.508: v1(129.27,113.82) 128.85,113.4 128.85,113 v1(128.06,112.21) ; 273.07,130.65 272.97,130.75 272.97,143.25 274.19,144.47 274.19,169.92 273.45,170.65 265.96,170.65 265.45,171.16 v1(265.45,171.21) ; v1(230.97,116.21) 231.03,116.21 231.42,116.6 233.4,116.6 237.01,113 239.8,113 240.18,113.38 241.32,113.38 242.44,112.26 243.15,112.26 243.92,111.49 v1(243.92,111.31) 245.07,112.46 248.56,112.46 250.36,114.27 253.23,114.27 253.59,113.91 255.37,113.91 255.7,114.24 259.86,114.24 259.91,114.2 261.66,114.2 261.7,114.24 264.56,114.24 264.87,113.94 264.87,113.17 265.56,112.48 267.62,112.48 268.4,111.7 268.4,105.07 271.04,102.43 271.04,101.08 276.6,95.52 276.6,90.45 v1(279.56,87.48) 281.07,85.98 281.07,85.52 283.88,82.71 284.34,82.71 286.37,80.68 287.35,80.68 288.71,79.32 291.56,76.47 v1(295.9,76.47)
  BOTTOM w0.508: v1(124.43,114.72) 124.1,114.72 123.68,114.3 R67321.1 ; R194.1 225.55,97.45 v1(225.52,97.43) ; v1(304.19,45.66) 304.19,45.74 303.62,46.31 290.23,46.31 288.87,47.67 v1(288.87,51.1) ; v1(295.9,76.47) 296.57,77.13 R21170.1 ; R20824.1 219.22,140.44 219.03,140.63 v3(218.46,140.63) ; R20752.1 208.44,102.58 208.35,102.58 208,102.23 v1(208,101.92) ; v1(243.92,111.31) 243.95,111.34 243.98,111.34 244.18,111.55 244.18,111.58 244.66,112.06 C94498.1
  vias: v1(229.48,119.35) v1(229.48,118.56) v1(229.48,117.78) v1(229.48,116.2) v1(230.9,123.29) v1(230.9,122.51) v1(231.03,117.77) v1(230.96,116.98) v1(231.64,118.03) v3(216.78,141.42) v3(216.94,140.63) v3(217.55,141.42) v3(217.7,140.63) v3(218.31,141.42)
+VCCPGPPA: length 13.1
  TOP w0.254: v2(311.75,68.09) 311.73,68.09 311.34,67.7 U13113.BA31
  IN3 w0.254: v2(311.75,68.09) 312.87,68.09 317.39,72.61 319.43,72.61 319.68,72.36 320.7,72.36 v1(321.05,72.71)
  BOTTOM w0.254: R21332.1 321.49,72.71 v1(321.05,72.71)
+VCCPGPPBCH: length 4.8
  BOTTOM w0.254: R21333.1 315.52,74.19 v1(314.66,73.33) 314.4,73.6 C94831.2 313.55,73.6 313.33,73.37 313.33,72.74 312.95,72.36 312.48,72.36 v2(312.32,72.19)
+VCCPGPPEF: length 1.4
  TOP w0.254: v2(306.04,72.12) 305.85,72.12 U13113.AJ41 ; v2(307.06,72) 306.6,72.45 U13113.AL41
  vias: v1(308.17,74.92)
+VCCPGPPG: length 7.6
  TOP w0.254: U13113.AD41 303.1,72.51 302.76,72.17 v2(302.48,72.17)
  BOTTOM w0.254: v2(302.48,72.17) 302.05,72.17 301.49,72.73 301.04,72.73 v1(300.6,73.17) 300.32,73.45 C94834.2 300.32,76.38 R21335.1
+VCCPLL: length 2.5
  BOTTOM w0.254: R20823.1 231.16,125.38 v1(231.16,124.71) 230.65,124.71 C94539.2 230.5,124.48 v1(230.9,124.08)
+VCCPLL_OC: length 51
  TOP w0.254: v1(229.48,111.48) 229.48,111.41 U41.G11 ; R20821.1 270.28,105.88 270.15,106.01 v1(270.15,106.52)
  TOP w0.305: v1(260.39,111.84) 260.46,111.84 U41.BH13
  IN4 w0.254: v1(229.48,111.48) 229.48,111.56 230.56,112.64 231.2,112.64 231.96,111.88 232.72,111.88 233.23,112.39 235.39,112.39 235.9,111.88 236.7,111.88 237.23,112.41 238.12,112.41 238.65,111.88 244.45,111.88 245.08,112.52 250.41,112.52 250.97,111.96 256.17,111.96 257.34,113.13 258.01,113.13 259.31,111.84 260.39,111.84 v1(260.39,111.84)
  BOTTOM w0.254: v1(260.39,111.84) 260.55,111.99 260.74,111.99 C94536.2 261.18,112.44 262.1,112.44 C94537.2 262.15,112.26 262.63,111.78 263.24,111.78 v1(263.27,111.8) 263.29,111.78 265.27,111.78 265.84,111.21 265.84,111.05 266.21,110.68 266.67,110.68 267.27,110.09 268.84,110.09 269.87,109.06 269.99,109.06 270.4,108.65 270.4,106.77 v1(270.15,106.52)
+VCCPRIM_1.0V_AC17: length 0.6
  TOP w0.254: v2(302.66,59.96) 302.51,60.11 U13113.AC17
+VCCPRIM_1.0V_AJ20:
  vias: v2(305.23,63.97)
+VCCPRIM_1.0V_AJ20_AA23:
  vias: v2(301.34,63.21) v2(301.37,65.5) v2(301.37,64.71) v2(301.37,63.95) v2(302.13,65.5) v2(302.13,63.92) v2(302.13,63.21)
+VCCPRIM_1.0V_AJ20_AD15: length 2.3
  TOP w0.254: U13113.AD15 303.4,59.76 v2(303.68,60.04)
  BOTTOM w0.254: v2(303.68,60.04) 303.75,60.11 C96036.1 304.24,60.47 304.41,60.65 R21341.1
+VCCPRIM_1.0V_AL22: length 0.6
  TOP w0.254: v2(306.32,63.46) U13113.AL22
  vias: v1(307.82,65.19)
+VCCPRIM_3P3: length 3.9
  TOP w0.254: v2(307.12,55.12) 307.33,55.12 U13113.AN5
  BOTTOM w0.127: v1(307.66,55.54) 307.54,55.54 v2(307.12,55.12)
  BOTTOM w0.254: R21337.1 307.33,53.55 307.64,53.87 C94835.2 307.64,54.6 v2(307.12,55.12)
+VCCRTCPRIM_3.3V: length 1.1
  TOP w0.254: U13113.BA20 311.19,61.85 310.71,62.32 v2(310.54,62.32)
  vias: v1(311.02,61.87)
+VCCSPI:
  vias: v1(317.07,76.98)
+VCCSTG: length 23.7
  TOP w0.254: v1(228.83,125.65) 228.83,125.72 U41.G30 229.81,125.39 U41.H29
  BOTTOM w0.254: v1(228.83,125.65) 228.83,125.9 228.45,126.28 C273.2 227.51,126.28 227.21,126.58 226.49,126.58
  BOTTOM w0.508: R20822.1 219.03,139.63 219.42,139.24 R20824.2 219.98,139.17 v1(219.98,138.14) 219.98,137.33 220.49,136.82 223.67,136.82 224.23,136.26 224.23,130.85 225.57,129.51 225.57,127.5 226.49,126.58
+VCCUSB2PLL_1P0: length 5.4
  TOP w0.254: U13113.AL5 306.55,54.71 306.09,54.71 v2(306.03,54.77) 305.96,54.71 305.49,54.71 U13113.AJ5
  BOTTOM w0.203: C96249.1 305.76,54.5 v2(306.03,54.77)
  BOTTOM w0.381: v2(306.03,54.77) 305.85,54.77 305.51,55.11 305.51,56 v1(305.43,56.07) 305.51,56.15 305.51,57.45 305.3,57.65 R21353.2
+VDDQ: length 93.2
  IN2 w0.508: v1(236.04,56.13) 236.04,61.43 235.33,62.15 216.28,62.15 215.44,62.99 215.44,64.58 213.81,66.21 211.7,66.21 210.74,67.17 210.74,68.75 210.15,69.33 v1(208.6,69.33) ; v1(176.8,75.48) 176.8,75.91 177.69,76.8 195.32,76.8 195.6,76.52 195.6,74.13 197.12,72.61 201.54,72.61 203.58,70.58 v1(204.36,70.58)
  BOTTOM w0.508: v1(208.6,69.33) 207.36,70.58 v1(204.36,70.58) ; PC2034.1 PR2023.1 176.93,75.91 176.8,75.78 v1(176.8,75.48) ; v1(236.04,56.13) 236.32,55.85 236.32,55.4 R21407.2 236.52,55.19 238.69,55.19 240.35,56.86 240.35,66.69 240,67.05 R21434.2
+VDDQC: length 4
  TOP w0.254: v1(238.46,111.27) 238.76,111.57 U41.Y12
  BOTTOM w0.381: C94535.1 237.36,111.98 237.49,112.11 v1(237.86,112.11)
  BOTTOM w0.508: v1(237.86,112.11) 238.15,111.82 238.15,111.58 v1(238.46,111.27) 238.46,111.5 R151.1
+VIN: length 397.2
  TOP w0.203: PU44.1 253.71,152.92 253.57,152.78 PC9401.1 ; PU46.1 268.32,150.41 268.1,150.18 266.79,150.18 PC9405.1 ; PU39.1 246.47,152.92 246.22,152.67 246.02,152.67 245.88,152.81 244.6,152.81 PC9395.1 ; PC9419.1 260.76,150.17 260.93,150.33 260.93,151.49 PU45.1 ; PC2025.1 182.17,80.51 181.02,80.51 177.39,84.14 v1(174.72,84.14) ; PU38.1 239,152.76 238.75,152.52 237.81,152.52 237.26,151.97 PC5602.1
  TOP w0.254: PR66840.1 260.01,159.7 259.66,159.35 v1(259.35,159.35) ; R21438.1 44.32,50.29 44.32,50.99 v1(44.22,51.1) 43.63,51.68 v1(43.48,51.68) ; PR66972.1 PR84.1 212.08,163.9 215.16,166.97 215.16,168.9 214.88,169.18 213.81,169.18
  TOP w0.508: v1(35.66,66.29) 35.66,66.54 36.01,66.89 PR116.1 ; PR9032.2 142.44,63.54 142.51,63.47 PC9011.1 142.28,62.96 141.24,62.96 140.48,63.72 140.48,66.01 v1(140.36,66.13)
  IN2 w0.254: 88.72,65.42 88.72,66.16 87.46,67.41 87.46,74.83 85.52,76.78 84.73,76.78 84.22,77.28 81.78,77.28 80.36,75.86 62.02,75.86 59.53,73.37 53.13,73.37 51.46,75.05 49.63,75.05 47.77,73.19 44.04,73.19 43,72.15 40.79,72.15 39.11,70.48 39.11,69.74 v1(35.66,66.29) 35.66,65.88 36.22,65.32 36.22,61.21 42.67,54.75 42.67,52.49 v1(43.48,51.68)
  IN2 w0.762: v1(358.67,94.2) 356.48,92.02 354.15,92.02 352.93,90.8 352.93,89.42 351.94,88.43 v1(350.03,88.43)
  IN3 w0.508: v3(131.64,71.26) 131.87,71.49 135.43,71.49 137.15,69.77 137.15,67.35 138.68,65.83 140.05,65.83 v1(140.36,66.13)
  IN4 w1.016: v1(281.97,94.46) 281.97,94.67 ; 281.97,94.67 274.87,101.77 274.87,107.69 275.46,108.27 275.46,143.17 273.2,145.43 237.28,145.43 233.83,148.89 231.49,148.89 228.34,145.74 225.42,145.74 224.7,146.46 224.7,151.39 ; 281.97,94.67 281.98,94.66 v1(281.98,93.38)
  IN5 w1.016: 349.57,87.75 348.97,87.14 343.48,87.14 342.51,88.1 339.24,88.1 338.21,87.08 336.76,87.08 334.79,85.11 332.71,85.11 330.37,82.77 299.99,82.77 297.81,84.95 295.52,84.95 293.69,86.78
  BOTTOM w0.203: v1(174.72,84.14) 174.95,84.14 174.95,84.17 175.37,84.59 175.59,84.59 PR2021.1
  BOTTOM w0.254: 233.55,154.35 238.59,159.39 240.09,159.39 240.3,159.6 255.77,159.6 256.23,159.15 257.68,159.15 258.01,158.82 259.1,158.82 259.35,159.07 v1(259.35,159.35)
  BOTTOM w0.508: PR171.1 79.11,78.26 77.85,77 68.55,77 66.39,74.85 66.39,70.89 v3(68.66,68.62)
  BOTTOM w0.762: PJ9027.2 371.21,92.62 370.13,93.7 362.61,93.7 361.63,92.73 360.14,92.73 v1(358.67,94.2)
  vias: v1(93.26,67.1) v1(108.94,66.21) v1(108.96,66.87) v1(109.16,63.16) v1(109.37,67.4) v1(109.82,63.16) v1(109.95,67.02) v1(110.51,67.4) v1(180.77,80.03) v1(238.45,157.7) v1(268.8,156.2) v1(292.25,87.34) v1(293.01,87.21) v1(349.27,88.48) v3(79.52,64.74) v3(79.49,63.9) v3(80.28,64.74) v3(80.29,63.91) v3(80.99,54.62) v3(81.1,64.71) v3(81.1,63.93) v3(81.3,53.92) v3(81.63,55.61) v3(81.78,54.53) v3(82.23,55.13) v3(89.56,63.59) v3(89.94,62.83) v3(90.32,63.59) v3(90.7,62.83) v3(91.08,63.59) v3(91.46,62.83) v3(91.84,63.59) v3(105.05,96.51) v3(105.04,95.74) v3(105.13,94.96) v3(105.61,97.04) v3(105.79,96.31) v3(105.81,95.55) v3(105.84,94.71) v3(106.24,97.45) v3(106.45,96.69) v3(106.47,95.93) v3(106.52,95.14) v3(106.52,94.38) v3(106.6,98.19) v3(106.8,98.92) v3(107.18,99.58) v3(107.74,100.17) v3(108.48,100.55) v3(128.34,71.34) v3(128.67,70.63) v3(128.82,71.97) v3(129.28,71.37) v3(129.43,70.63) v3(129.59,72.15) v3(130.04,71.47) v3(130.2,70.63) v3(130.42,72.2) v3(130.8,71.52) v3(130.98,70.74) v3(183.56,76.06) v3(184.32,76.06) v3(185.08,76.06) v3(185.41,80.31) v3(185.82,79.26) v3(185.82,78.5) v3(190.01,180.38) v3(189.96,179.42) v3(190.04,178.48) v3(190.04,177.69) v3(190.01,176.93) v3(190.01,176.14) v3(190.16,175.33) v3(190.62,179.92) v3(190.65,178.99) v3(190.7,180.69) v3(190.75,178.12) v3(190.75,177.36) v3(190.77,176.6) v3(190.8,175.84) v3(190.93,175) v3(191.23,179.47) v3(191.31,178.63) v3(191.43,177.79) v3(191.43,177.03) v3(191.46,176.24) v3(207.16,171.8) v3(207.92,171.75) v3(208.71,171.64) v3(209.54,171.64) v3(209.54,170.88) v3(210.31,171.64) v3(210.31,170.88) v3(210.31,170.12) v3(211.07,171.64) v3(211.07,170.88) v3(211.07,170.12) v3(211.83,171.64) v3(211.83,170.88) v3(211.83,170.12) v3(212.59,171.64) v3(212.59,170.88) v3(212.59,170.12) v3(213.35,171.64) v3(213.35,170.88) v3(213.35,170.12) v3(214.45,169.97) v3(215.23,169.94) v3(216,169.92) v3(226.23,153.36) v3(226.23,152.59) v3(226.23,151.83) v3(226.23,151.07) v3(226.99,153.36) v3(226.99,152.59) v3(226.99,151.83) v3(226.99,151.07) v3(227.76,153.36) v3(227.76,152.59) v3(227.76,151.83) v3(227.76,151.07) v3(239.06,158.08) v3(239.06,157.32) v3(239.82,158.08) v3(239.82,157.32) v3(246.37,158.23) v3(246.37,157.47) v3(247.14,158.23) v3(247.14,157.47) v3(253.87,158.18) v3(253.87,157.42) v3(254.63,158.18) v3(254.63,157.42) v3(260.95,155.74) v3(260.95,154.98) v3(261.72,155.74) v3(261.72,154.98) v3(268.4,155.58) v3(268.4,154.8) v3(269.16,155.58) v3(269.16,154.8)
+VIN_FBVDDQ: length 14.9
  TOP w0.305: v1(120.42,70.76) 120.42,69.71 120.17,69.47 PR9142.1
  BOTTOM w0.305: v1(120.42,70.76) 120.38,70.79 120.38,75.81 120.99,76.42 120.99,76.48 121.09,76.59 121.09,77.07 123.69,79.67 123.69,82.26
  vias: v1(105.66,79.49) v3(106.37,80.03) v3(106.37,79.26) v3(106.37,78.5) v3(107.13,80.03) v3(107.13,79.26) v3(107.13,78.5) v3(123.46,84.17) v3(123.46,83.4) v3(123.46,82.64) v3(124.23,84.17) v3(124.23,83.4) v3(124.23,82.64)
+VIN_GPU_TOTAL:
  vias: v1(126.28,78.22)
+VIN_VCCSA: length 3.5
  TOP w0.203: PC9426.1 226.65,147.84 226.66,147.82 226.66,146.19 226.83,146.03 PU43.1
  vias: v1(233.07,148) v3(231.13,145.79) v3(232.33,147.51) v3(232.3,146.75)
+VIN_VGACORE:
  vias: v1(130.32,80.28) v1(130.78,82.31) v1(130.78,81.67) v1(130.78,81.02) v1(131.03,80.28) v1(132.1,88.33) v1(133.52,94.4) v1(133.52,93.39) v1(133.52,92.42) v1(154.2,70.98) v1(154.86,70.98) v1(155.57,70.98) v1(156.28,70.98) v1(166.03,70.83) v1(166.9,70.83) v1(167.86,70.83) v3(129.33,79.11) v3(129.43,78.35) v3(129.48,80.05) v3(129.99,79.49) v3(130.02,77.87) v3(130.12,78.66) v3(130.68,79.16) v3(130.7,78.17) v3(132.07,91.48) v3(132.07,90.72) v3(132.07,89.96) v3(132.07,89.2) v3(157.42,70.12) v3(158.19,70.12) v3(158.95,70.12) v3(159.71,70.12) v3(169.34,70.14) v3(170.1,70.15) v3(170.86,70.15) v3(171.61,70.14)
AVDDH: length 12.7
  TOP w0.203: U13143.22 v1(351.81,74.92) 351.44,75.3 v1(351.23,75.3) ; 351.81,68.16 U13143.9
  TOP w0.254: 351.81,68.16 351.96,68.01 352.67,68.01 v1(352.7,67.99)
  IN1 w0.254: v1(351.81,74.92) 351.81,74.54 352.7,73.65 v1(352.7,67.99)
  BOTTOM w0.254: v1(351.81,74.92) 351.78,74.9 C94981.2 ; v1(352.7,67.99) 352.22,68.47 C94984.2 C94980.1
AVDDL: length 30
  TOP w0.178: U13143.31 348.13,73.14 348.24,73.24 348.24,73.46 v1(347.95,73.75)
  TOP w0.203: v1(350.84,67.28) 350.61,67.51 U13143.6 ; v1(353.97,72.74) U13143.19 ; v1(353.95,70.34) U13143.13
  TOP w0.254: v1(344.83,71.16) 344.86,71.2 L4243.2 L4244.1
  IN2 w0.254: v1(344.83,71.16) 347.42,73.75 v1(347.95,73.75) 348.28,74.08 351.71,74.08 352.32,73.47 353.72,73.47 353.97,73.22 v1(353.97,72.74) 353.26,72.03 353.26,71.06 353.95,70.37 v1(353.95,70.34) 350.89,67.28 v1(350.84,67.28)
  BOTTOM w0.254: C94987.1 353.72,70.58 v1(353.95,70.34) ; C94978.1 C94977.2 350.84,68.35 v1(350.84,67.28) ; v1(353.97,72.74) 353.85,72.86 C94988.2 ; C94974.2 347.5,73.3 v1(347.95,73.75)
AVDDVCO: length 1.8
  TOP w0.203: 347.1,71.94 U13143.34
  TOP w0.254: 347.1,71.94 347.06,71.97 L4243.1
DVDD_IO: length 9.5
  TOP w0.203: v1(32.07,44.72) 32.52,44.28 U13157.12
  BOTTOM w0.14: v1(32.11,42.5) 32.11,43.58 R67353.2
  BOTTOM w0.254: R67353.2 32.07,44.09 32.11,44.06 C96237.2 32.58,44.21 v1(32.07,44.72) 31.62,44.72 31.3,45.03 R67373.2 31.3,45.6 31.74,46.04 Q7947.5 Q7947.2 31.74,48.1 31.96,48.31 R67374.2
DVDDL: length 7.3
  TOP w0.203: 347.03,70.5 347.27,70.74 U13143.37
  TOP w0.254: v1(346.81,70.5) 347.03,70.5
  BOTTOM w0.254: C94969.1 C94970.2 346.88,70.58 v1(346.81,70.5) 346.76,70.5 346.35,70.1 346.35,68.37 346.2,68.22 v1(344.09,68.22)
  vias: v1(342.06,67.99)
GND: length 3777.8
  TOP w0.079: U21.Y13 346.15,52.55
  TOP w0.102: v4(202.19,156.86) v4(202.19,157.51) ; v4(202.19,157.51) v4(202.19,158.16) ; v4(202.19,157.51) v4(202.84,157.51) ; v4(202.84,117.25) v4(202.19,117.25) v4(202.19,116.6) ; v4(124.72,145.45) v4(124.72,146.1) ; v4(153.75,173.18) 153.75,173.18 v4(154.4,173.18) ; v4(173.7,165.38) v4(173.7,166.03) v4(174.35,166.03) ; v4(173.7,175.13) v4(173.05,175.13) ; v4(153.75,167.98) v4(153.75,167.33) v4(153.75,166.68) v4(153.1,166.68) ; v4(120.17,150.65) v4(120.17,151.3) ; v4(204.14,152.31) v4(203.49,152.31) v4(203.49,151.66) ; v4(153.75,175.13) v4(153.75,174.48) v4(154.4,174.48) ; v4(148.55,173.18) v4(149.2,173.18) ; v4(148.55,173.18) v4(147.9,173.18) ; v4(148.55,173.18) v4(148.55,173.83) ; v4(204.14,142.15) 204.14,141.5 v4(204.14,141.5) ; v4(126.02,151.3) v4(126.02,150.65) ; v4(126.02,150.65) v4(125.37,150.65) ; v4(126.02,150.65) v4(126.67,150.65) v4(126.67,150) ; v4(148.55,176.43) v4(148.55,175.78) ; v4(148.55,175.78) v4(148.55,175.13) ; v4(148.55,175.78) v4(147.9,175.78) ; v4(148.55,175.78) v4(149.2,175.78) ; v4(120.17,144.8) v4(120.17,145.45) ; v4(120.17,145.45) v4(120.17,146.1) ; v4(120.17,145.45) v4(119.52,145.45) ; v4(195.69,152.31) v4(195.69,152.96) ; v4(130.26,175.13) v4(129.61,175.13) ; v4(148.55,168.63) v4(149.2,168.63) ; v4(202.19,123.1) v4(202.19,122.45) ; v4(202.19,122.45) v4(202.19,121.8) ; v4(202.19,122.45) v4(202.84,122.45) ; v4(142.91,143.3) 143.26,142.94 143.93,142.94 U13114.K2 ; v4(118.22,150.65) 118.87,150.65 v4(118.87,150.65) 118.87,151.3 v4(118.87,151.3) ; v4(196.99,117.9) v4(197.64,117.9) ; 146.58,173.86 v4(146.6,173.83) ; v4(202.19,152.31) v4(202.19,151.66) ; v4(195.69,117.25) v4(195.69,117.9)
  TOP w0.127: U41.AL7 247.09,108.35 247.09,108.93 U41.AL8 ; v4(127.32,126.4) 127.32,125.75 U13141.V2 ; v4(149.17,149.56) 149.53,149.2 149.53,148.54 U13114.B10 ; v4(148.55,170.58) v4(148.55,171.23) ; v1(246.35,103.37) 245.93,103.79 U41.AJ1 245.93,104.54 245.94,104.55 245.94,104.89 245.93,104.9 U41.AJ2
  TOP w0.14: TP13158.1 21.43,76.8 v1(21.41,76.78) ; TP70.1 373.76,58.82 v1(373.4,58.46) ; PU46.19 266.81,152.05 266.62,152.24 PC5634.2 265.68,152.24 v3(265.45,152.47) ; TP13159.1 13.43,60.93 v1(13.56,61.05) ; v1(373.3,66.54) 373.58,66.26 TP63.1 ; C94703.1 355.14,79.41 v1(354.76,79.8) ; v3(243.48,154.86) 243.74,154.6 PC5608.2 ; v1(373.43,64.51) 373.58,64.66 TP65.1 ; TP13165.1 13.43,58.41 v1(13.2,58.18) ; U13114.BL10 149.56,114.33 149.45,114.44 149.45,114.82 149.35,114.93 149.35,115.4 U13114.BJ10 ; TP62.1 13.36,39.26 v1(13.58,39.03) ; TP13157.1 21.42,79.05 v1(21.43,79.06) ; v4(195.04,141.5) v4(195.04,142.15) ; v1(373.43,60.82) 373.76,60.49 TP68.1 ; v1(373.37,54.4) 373.5,54.53 TP13156.1 ; v1(13.48,41.37) 13.36,41.24 TP13178.1 ; v1(373.32,56.43) 373.5,56.25 TP72.1 ; 250.92,154.6 250.92,154.6 250.95,154.6 ; v1(302.56,52.26) 302.52,52.3 U13113.AC1
  TOP w0.15: v4(118.19,148.62) 118.19,148.83 117.84,149.18 117.84,149.61 U13142.U5
  TOP w0.152: U13114.F25 v4(160.06,146.41) U13114.D25 ; v4(153.76,146.41) U13114.D16 ; U13113.V45 300.23,74.41 v1(299.79,74.85) ; v4(146.07,138.71) U13114.T4 ; v4(164.26,142.21) U13114.K31 ; U13114.K2 v4(144.66,142.91) U13114.K4 ; U13113.AM45 307.05,74.86 v1(307.1,74.91) ; v1(302.61,74.86) 302.61,74.49 U13113.AC45 ; v1(304.69,74.86) 304.69,74.86 304.69,74.46 U13113.AH45 ; U13114.AE43 v4(171.96,132.41) ; U13114.G51 v4(177.56,145.01) ; v4(150.26,132.41) U13114.AE10 ; U13114.D19 v4(155.86,146.41) ; U13114.F37 168.46,145.01 v4(168.46,145.01) ; U13114.H22 v4(157.96,143.61) ; U13114.AH4 v4(146.06,130.31) ; U13114.N51 177.59,140.81 v4(177.21,140.43) ; U13114.H31 v4(164.26,143.61) ; v4(172.66,146.41) 172.66,147.11 U13114.D43 ; U41.AF4 243.44,106.33 243.44,105.72 U41.AF3 243.43,105.69 243.43,105.07 U41.AF2 U41.AF1 ; U13114.G4 v4(144.66,145.01) ; v4(172.66,145.01) 172.66,145.01 U13114.F43 ; v4(162.16,142.21) U13114.K28 ; v4(171.96,138.71) U13114.T43 v4(173.36,138.71) U13114.T45 ; v4(148.86,140.81) U13114.N8 ; U13114.D22 v4(157.96,146.41) ; v4(168.46,146.41) 168.46,146.41 U13114.D37 ; U13113.A32 290.27,68.11 v1(290.19,68.19) ; U13114.F28 v4(162.16,145.01) ; U13114.K19 v4(155.86,142.21) ; v4(146.06,132.41) U13114.AE6 ; v4(160.06,142.21) U13114.K25 ; U13113.AU45 v1(309.35,75.04) ; v4(168.46,142.21) 168.46,142.21 U13114.K37 ; v4(155.86,143.61) U13114.H19 ; v1(314.09,61.53) 313.86,61.3 U13113.BE18 ; U13114.AU47 U13114.AU45 ; U13114.K8 v4(147.46,142.91) 147.46,142.91 146.76,142.91 U13114.K6 ; U13113.BE32 314.1,68.12 v1(314.24,68.27) ; U13114.F7 v4(147.46,145.01) ; U13114.N4 v4(146.06,140.81) ; v4(150.26,138.71) U13114.T10 ; U13114.AL43 v4(171.96,128.21) ; v4(170.56,146.41) 170.56,146.41 U13114.D40 ; U13114.G6 v4(146.06,145.01) ; U13114.H16 v4(153.76,145.01) U13114.F16 ; v4(151.66,142.21) U13114.K13 ; U13113.BE14 314.1,59.03 314.14,59.07 v1(314.14,59.07) ; U13114.D46 v4(174.76,146.41) ; v4(177.56,124.01) U13114.AU51 ; v1(291.15,61.15) 291.29,61.29 U13113.A18 ; U13114.AH8 v4(147.46,130.31) ; v4(147.46,138.71) U13114.T6 ; v4(177.91,147.46) v4(177.21,147.46) ; U41.AL7 247.03,108.32 246.83,108.12 246.63,108.12 246.45,107.94 246.22,107.94 U41.AJ6 ; v1(306.12,74.87) 306.27,74.71 306.27,73.55 306.01,73.29 U13113.AK42 ; U13114.H28 v4(162.16,143.61) ; v4(162.16,146.41) U13114.D28 ; v4(174.76,140.81) U13114.N45 ; v4(166.36,146.41) 166.36,146.41 U13114.F34 ; v1(314.09,66.03) 313.5,66.03 U13113.BE28 ; U13114.F10 v4(149.56,146.41) U13114.D10 ; U13114.AU49 v4(176.16,124.01) ; U13114.AB4 v4(146.06,134.51) ; U13114.W45 v4(174.76,136.61) ; v4(157.96,142.21) U13114.K22 ; U13114.AE49 v4(176.16,132.41) ; v4(150.26,134.51) U13114.AB10 ; v4(173.36,134.51) U13114.AB45 ; U13114.K34 166.36,142.21 v4(166.36,142.21) ; U13114.AE47 v4(174.76,132.41) U13114.AE45 ; v1(313.81,63.57) U13113.BE23 ; v4(150.26,140.81) U13114.N10 ; v1(304.88,52.14) 304.79,52.23 U13113.AH1 ; v4(150.26,136.61) U13114.W10 ; U13114.N49 v4(176.16,140.81) ; U13114.W43 v4(171.96,136.61) ; v4(176.16,134.51) U13114.AB49 ; U13114.AH43 v4(171.96,130.31) ; v4(148.86,136.61) U13114.W8 v4(147.46,136.61) U13114.W6 ; U13114.K16 v4(153.76,142.21) ; v4(148.86,132.41) U13114.AE8 ; U13114.D7 v4(147.46,147.81) ; v4(150.26,130.31) U13114.AH10 ; U13114.T49 v4(176.16,138.71)
  TOP w0.178: U41.F15 228.17,114.57 227.66,114.57 U41.D16 ; 345.79,54.86 345.64,55 U21.AB8 U21.AC8 344.47,55 v1(344.23,55.25) ; 345.79,54.86 v4(345.84,54.8) ; 345.79,54.86 345.79,55.58 U21.AB6 U21.AC6 ; v1(355.63,54.08) U21.A10 U21.B10 354.22,54.08 ; 354.32,50.3 354.32,49.81 U21.B20 ; 354.32,50.3 354.43,50.4 U21.B18 U21.A18 v1(355.75,50.4) ; 354.32,50.3 354.21,50.3 U21.D18 ; U41.D30 227.58,125.67 228.07,125.67 228.49,125.26 U41.F29 ; U21.C22 U21.C23 354.19,48.06 354.88,47.36 ; U21.C22 354.19,48.64 353.94,48.89 ; U21.C22 U21.B22 U21.A22 355.5,48.17 v1(355.87,48.17) ; U13113.P45 297.96,74.47 297.68,74.74 v1(297.68,75.23) ; U21.L22 U21.L23 350.51,47.68 v1(350.39,47.57) ; v1(347.37,47.41) 347.37,47.59 347.75,47.97 U21.U23 U21.U22 ; U13147.21 67.59,44.04 67.11,44.52 v1(67.11,44.89) ; U13149.21 43.25,38.32 43.63,37.94 v1(43.71,37.94) ; U21.K2 U21.K1 350.97,58.44 350.71,58.7 v1(350.71,58.83) ; 353.94,48.89 353.59,48.89 U21.E22 U21.E23 353.27,47.58 v1(353.27,47.58) ; 353.94,48.89 354.05,48.89 U21.B20 ; U21.J22 U21.J23 351.43,47.75 v1(351.68,47.49) ; v1(51.53,48.66) 52.01,48.18 52.01,47.55 52.21,47.34 U13148.21 ; U21.AB14 U21.AC14 344.89,52.24 344.43,51.79 v1(344.43,51.67) ; U21.B16 U21.A16 355.67,51.32 v1(355.75,51.4) ; 345.79,50.4 U21.AB18 U21.AC18 ; U21.AC16 U21.AB16 345.64,51.32 v4(345.84,51.53) ; v1(69.89,46.72) 69.74,46.57 U13147.18 ; v4(345.86,53.48) 345.54,53.16 U21.AB12 U21.AC12 344.33,53.16 v1(344.13,52.96) ; v1(59.73,38.2) 59.58,38.05 U13146.18 ; v1(54.27,49.95) 54.27,48.88 54.12,48.73 U13148.18 ; v1(44.49,41.09) 44.34,40.94 U13149.18 ; 345.88,49.48 U21.AB20 U21.AC20 ; v1(349.22,58.74) 349.13,58.65 U21.P1 U21.P2 ; U21.AB22 U21.AC22 344.14,47.72 v1(344.14,47.13) ; U21.W23 U21.W22 ; v1(72.39,38.88) 72.54,39.03 U13147.38 ; v1(46.99,33.03) 47.14,33.18 U13149.38 ; U13113.C37 U13113.B37 291.77,70.48 U13113.A37 ; U21.H2 U21.H1 351.89,58.72 351.77,58.83 v1(351.75,58.83) ; v1(355.66,52.45) 355.41,52.45 355.2,52.24 U21.A14 U21.B14 354.22,52.24 U21.D13 ; v1(344.29,53.96) 344.41,54.08 U21.AC10 U21.AB10 ; U21.B20 U21.A20 355.76,49.48 v1(355.8,49.45) ; v1(348.47,58.76) 348.47,58.63 348.21,58.36 U21.T1 U21.T2 ; 354.29,55 U21.B8 U21.A8 v1(355.65,55) ; 354.25,55.92 U21.B6 U21.A6 355.47,55.92 355.61,55.78 v1(355.61,55.75) ; U13148.38 56.92,42.2 v1(56.64,41.92) ; v2(147.11,115.96) 146.41,115.96 U13114.BH5 146.41,116.66 v2(147.11,116.66) ; U21.R22 U21.R23 348.67,47.97 348.56,47.86 348.56,47.51 v1(348.38,47.34) ; 258.27,152.33 258.62,151.98 PC5639.2 ; PU43.11 228.47,147.81 v1(228.24,148.05) ; v1(349.37,47.39) 349.37,47.46 349.59,47.68 U21.N23 U21.N22 ; v1(62.23,30.12) 62.38,30.27 U13146.38 ; v1(40.63,68.01) 40.69,68.07 PU8.11 ; PU9004.11 PU9004.15 ; PC5608.2 244.38,154.56 PU39.19 ; U21.G23 U21.G22 ; U21.D12 U21.B12 U21.A12 v1(355.66,53.16) ; v1(350.05,58.8) U21.M1 U21.M2 ; U13146.21 57.68,35.53 56.81,36.39 v1(56.81,36.54) ; U21.AA23 U21.AA22 ; U21.AC2 U21.AC1 344.99,58.79 v1(345.04,58.85) 345.45,58.44 U21.AB1 U21.AB2 U21.AC2
  TOP w0.2: v4(151.41,175.62) 151.49,175.54 152.64,175.54 152.73,175.46 U13140.U5
  TOP w0.203: PU44.19 251.55,154.56 PC5623.2 250.95,154.6 250.87,154.68 ; v1(240.18,170.15) 240.18,169.76 240.44,169.5 D13079.1 ; C96024.1 29.05,80.97 v1(29.15,80.86) ; v1(36.55,30.88) 36.52,30.85 C95903.1 ; PR66889.1 260.85,169.08 v1(260.57,169.36) ; D13086.1 248.94,169.56 v1(249.52,170.15) ; D13029.1 v1(372.32,42.68) ; v1(133.04,64.79) 133.09,64.74 C94787.2 ; v1(377.93,10.77) 377.85,10.69 U13152.32 ; R67180.2 364.96,19.04 364.23,19.78 v1(364.23,19.98) ; U41.W3 U41.W4 ; v1(24.63,88.03) 24.66,88.05 C95522.2 ; v1(262.15,167.35) 261.8,167.7 PC5585.2 ; D13071.1 217.95,171.01 v1(218.03,171.09) ; v1(24.81,50.21) 25.08,49.93 U13124.19 ; v1(30.63,47.41) 30.51,47.53 U13124.3 ; v1(189.94,68.44) 189.6,68.11 U49.104 ; v1(177.06,55.46) 177.32,55.2 U49.27 ; v1(120.35,76.81) 119.96,76.42 PC9124.2 PR9147.2 ; v1(311.23,75.77) 311.23,74.83 310.97,74.57 U13113.AY45 ; C94964.1 23.11,35.52 v1(23.34,35.28) ; R21586.1 155.97,107.21 v1(155.73,107.44) ; v1(155.16,105.99) 155.06,106.09 R21585.1 ; v1(36.57,42.66) 37,42.66 37.08,42.58 U13157.47 ; v1(44.65,62.48) C95988.2 ; v1(268.57,127.19) 268.93,127.55 C807.1 ; C95991.2 33.68,56.71 33.85,56.53 v1(33.85,56.3) ; U41.AD9 241.63,109.52 241.62,109.51 241.62,109.13 241.63,109.12 U41.AD8 ; D13072.1 219.21,170.39 v1(219.78,170.96) 219.78,170.84 D13073.1 ; C95907.1 328.02,75.88 328.19,76.05 C94707.1 ; U13113.BE37 313.58,70.68 313.86,70.68 v1(313.91,70.73) ; PU45.19 258.94,152.1 PC5639.2 ; v1(224.89,170.93) 224.89,170.65 225.15,170.39 D13077.1 ; v1(49.68,72.38) C95544.2 C95542.2 ; U13157.38 37.13,38.98 36.91,39.21 36.9,39.21 36.52,39.59 v1(36.52,39.77) ; U13157.15 32.38,42.18 v1(32.86,42.66) ; U13113.V18 299.98,61.45 299.62,61.45 U13113.U18 ; U41.BH10 260.85,110.28 260.85,110.9 U41.BH11 ; R21294.1 298.25,81.73 297.91,81.4 297.91,81.37 ; v1(188.92,70.93) 188.92,70.43 188.62,70.12 C897.1 ; v1(16.15,40.05) 16.28,39.92 U13122.3 ; D13083.1 245.6,169.47 v1(244.95,170.12) 244.37,169.54 D13082.1 ; CN2076.4 134.05,62.4 133.73,62.73 v1(133.73,62.96) 133.37,62.96 133.24,62.83 C94786.2 ; C94946.1 35.33,27.52 v1(35.58,27.78) ; R20813.1 R20756.1 269.62,124.88 v1(269.87,125.14) ; U13152.7 374.13,11.56 373.78,11.9 373.5,11.9 373.27,12.13 373.27,13.53 372.36,14.44 v1(371.98,14.44) ; PR66875.1 272.3,167.11 PR66870.1 ; D13085.1 247.81,169.5 v1(247.21,170.1) 246.78,169.66 D13084.1 ; C94605.1 358.63,58.41 C95994.2 ; v1(349.81,74.9) U13143.27 ; PR9007.2 144.22,74.34 v1(143.83,74.72) ; v4(354.25,51.53) 354.45,51.32 U21.B16 ; v1(378.99,46.47) 379.09,46.38 CN18.A12 ; v1(326.59,76.39) 326.59,76.06 326.77,75.88 C94708.1 ; v1(272.64,126.2) 272.36,125.92 C85.2 ; PQ9020.1 111.04,68.34 v1(111.25,68.14) ; C94966.2 34,28.85 v1(33.95,28.9) ; C96033.2 300.6,78.81 v1(300.32,79.09) ; D13027.1 367.25,47.9 v1(367.02,47.67) ; R124.2 274.16,127.4 273.96,127.6 v1(273.58,127.6) ; C94682.1 356.41,78.68 v1(356.97,78.12) ; U13124.6 30.47,48.73 v1(30.5,48.71) ; v1(327.72,52.65) 327.91,52.65 328.3,52.25 U13102.3 ; PC5591.2 262.28,168.83 261.79,169.31 v1(261.79,169.41) ; v1(132.35,68.04) 132.35,67.66 131.97,67.28 C94785.2 ; U41.AP9 249.86,109.59 249.88,109.57 249.88,109.17 249.86,109.15 U41.AP8 ; D13076.1 v1(224.18,170.98) ; C94934.1 29.05,25.32 28.47,24.73 ; PC5594.2 v1(271.6,158.08) ; PU38.19 237.54,154.53 237.16,154.9 PC5600.2 236.92,154.96 v1(236.37,154.96) ; U21.J22 351.43,48.72 v4(351.67,48.96) ; v1(222.02,170.98) 222.02,170.9 D13074.1 ; D13054.2 180.07,49.49 180.24,49.66 C94776.1 ; C94545.2 337.18,51.33 337.48,51.02 v1(338.55,51.02) 339.36,51.02 v1(339.77,51.43) ; v1(119.83,71.7) 119.56,71.97 PR9135.2 PC9128.2 ; D13075.1 v1(222.91,171.01) ; PC5653.2 228.24,148.64 v1(228.24,148.05) ; D13080.1 241.99,169.5 v1(242.67,170.17) 242.72,170.12 242.72,169.74 242.96,169.5 D13081.1 ; v1(368.51,59.21) 368.51,59.37 369.16,60.01 U13127.8 ; v1(195.22,63.72) 195.1,63.6 U49.91 ; C94642.2 180.87,70.12 v1(180.56,70.43) ; 297.91,81.37 297.89,81.4 Q7842.1 ; 297.91,81.37 v1(297.91,81.35) ; U41.T10 U41.T9 ; v1(30.04,44.9) 29.99,44.85 C96231.1 ; U21.W22 346.83,48.68 v4(347.12,48.98) ; PC5583.2 271.11,168.82 v1(271.67,169.38) ; v1(290.67,70.83) 290.83,70.68 291.42,70.68 U13113.A37 ; v1(253.26,162.65) 253.64,162.65 254.68,163.7 C94725.1 ; C95057.1 134.99,115.46 v1(135.4,115.87) ; U41.W1 U41.W2 ; C96159.2 C755.2 272.62,131.41 v1(272.26,131.77) ; C96161.1 C96164.1 201.6,73.09 v1(201.44,73.24) ; v1(342.03,50.11) 342.29,49.85 C95892.1 ; v1(309.52,52.05) 309.36,52.21 U13113.AU1 ; PC5602.2 236.49,152.03 237.56,153.1 237.89,153.1 v1(237.92,153.08) ; v1(46.27,55.62) 46.27,55.36 45.74,54.83 C95987.2 ; v1(177.85,68.24) 178.1,67.99 178.1,66.86 177.52,66.28 177.52,65.79 177.7,65.6 U49.1 ; U41.N5 U41.N4 U41.N3 U41.N2 ; D13030.1 v1(366.9,45.79) ; U13113.BE9 313.5,56.55 314.52,56.55 v1(314.75,56.32) ; v1(34.82,40.5) 34.52,40.2 U13157.30 ; PR9140.2 112.98,69.82 111.89,70.92 v1(111.89,71.07) 111.53,71.07 PR9126.1 PR9139.2 ; v1(227.07,171.01) 227.02,170.96 227.02,170.53 226.88,170.39 D13078.1 ; v1(372.16,40.57) 372.16,40.57 D8599.1 ; C95992.1 v1(34.56,56.3) ; v1(43.86,62.42) C95989.1 ; v4(124.39,123.32) 124.39,123.6 123.95,124.04 v4(123.95,124.29) 123.75,124.49 U13141.M1 ; v1(185.95,53.09) 185.95,52.9 186.4,52.45 U49.49 ; v1(326.79,71.24) C94705.1
  TOP w0.216: U13114.AP43 172.61,126.16 v4(171.98,126.16)
  TOP w0.229: v1(364,53.71) 363.87,53.58 U13128.14 ; U41.T5 U41.T4 ; U41.BE4 258.5,106.49 258.5,106.88 258.5,106.88 U41.BE5 ; v1(287.68,73.85) 287.68,74.44 C94843.2 ; C94844.2 292.65,77.13 293.44,76.34 v1(293.44,75)
  TOP w0.25: U13140.V2 v4(155.05,176.43) U13140.V1 v4(155.73,176.46) ; v4(173.05,175.13) U13137.D2 v4(172.4,174.48) U13137.D1 ; U13142.M1 121.05,152.37 v4(121.05,152.82) ; v4(146.57,165.35) 146.6,165.38 146.6,165.38 U13140.B14 ; U13140.H1 155.5,169.49 156.25,169.49 v4(156.5,169.73) ; v4(127.16,174.87) 127.2,174.83 v4(128.07,174.83) 128.09,174.81 U13139.D1 v4(128.96,174.48) U13139.D2 v4(129.61,175.13) ; v4(154.4,167.33) U13140.D2 ; U13137.W10 178.07,164.91 v4(178.25,164.73) ; U13140.B1 155.7,165.38 v4(155.73,165.38) 156.23,165.38 156.52,165.67 v4(156.57,165.67) ; v4(138.21,173.83) v4(138.21,174.67) v4(137.62,174.67) 137.22,174.67 U13139.D14 ; v4(128,124.05) 128,124.42 U13141.V1 ; v4(156.57,168.07) 156.4,168.23 v4(155.86,168.23) 155.78,168.31 U13140.F1 v4(155.05,167.98) U13140.F2 ; v4(124.72,125.1) U13141.P1 125.27,124.55 v4(125.27,124.05) ; v4(124.07,133.55) U13141.M14 ; v4(126.67,145.45) U13142.D11 126.06,146.06 v4(126.02,146.1) U13142.E10 ; U13137.M14 v4(180.85,169.28) ; U13137.R5 174.78,167.77 v4(175,167.98) ; v4(130.91,166.68) U13139.U5 ; U13140.M1 155.5,172.33 v4(155.92,172.33) ; U13140.N5 152.74,172.82 152.03,172.82 v4(151.95,172.74) ; U13142.D14 126.47,143.94 126.47,144.36 U13142.D13 v4(126.02,144.8) ; v4(181.65,171.05) 181.57,171.05 181.44,170.92 180.53,170.92 U13137.K14 ; U13137.R10 v4(178.25,167.33) U13137.T11 178.69,166.89 v4(178.9,166.68) ; v4(122.12,131.6) U13141.J12 ; U13137.D13 v4(180.2,175.13) U13137.D14 ; U13139.V1 v4(128.96,165.38) U13139.V2 v4(128.96,166.03) U13139.V1 ; U13139.V1 v4(128.27,165.34) ; U13141.L3 v4(122.77,126.4) U13141.K3 ; U13137.M1 171.9,169.44 v4(171.62,169.44) ; v4(117.1,134.59) 116.92,134.42 v4(116.92,133.55) U13141.B14 v4(116.92,132.9) U13141.B13 ; v4(180.99,172.32) 180.63,172.32 U13137.H14 ; v4(127.98,133.6) 127.65,133.26 U13141.V14 v4(127.97,132.9) U13141.V13 ; U13141.K3 v4(122.12,126.4) U13141.J3 v4(122.12,125.75) U13141.K3 ; v4(171.65,166.8) 171.86,167.01 U13137.T1 172.07,167.01 v4(172.4,167.33) U13137.T2 ; v4(122.52,152.96) 122.45,152.89 U13142.K1 ; U13137.B2 v4(172.4,176.43) U13137.B1 171.75,176.43 v4(171.72,176.43) ; U13142.W5 116.24,149.31 116.21,149.31 116.18,149.28 v4(116.06,149.28) ; U13137.K3 v4(173.05,171.23) U13137.J3 173.37,171.56 v4(173.7,171.23) U13137.K3 ; U13137.K3 173.37,170.91 v4(173.7,170.58) U13137.L3 ; v4(118.86,130.29) U13141.E10 v4(119.52,130.95) ; v4(128.36,164.11) 128.19,163.94 v4(128.19,163.57) ; v4(145.73,175.13) v4(146.6,175.13) U13140.T14 v4(147.25,175.13) U13140.T13 ; U13137.V2 v4(172.4,165.38) U13137.V1 v4(171.64,165.28) ; v4(173.05,167.98) U13137.P2 v4(172.4,168.63) 172.07,168.31 U13137.P1 171.87,168.1 v4(171.4,168.1) ; v4(180.93,174.56) 180.77,174.56 U13137.D14 ; U13140.V14 146.58,176.45 v4(146.42,176.45) ; v4(132.36,175.76) 132.35,175.75 131.53,175.75 U13139.C5 v4(130.91,175.78) ; v4(155.74,166.69) 155.43,167.01 U13140.D1 ; U13142.P1 119.85,152.81 v4(119.82,152.83) ; U13141.P14 125.05,133.26 v4(125.39,133.61) ; v4(128.16,169.58) 128.19,169.61 U13139.M1 ; v4(180.85,166.68) U13137.T14 180.41,167.12 179.98,167.12 U13137.T13 ; v4(180.85,165.38) 180.66,165.57 U13137.V14 v4(180.2,165.38) U13137.V13 ; v4(117.56,146.76) U13142.U10 v4(117.57,146.1) ; v4(177.56,177.05) 177.63,177.05 U13137.A10 178.07,176.61 v4(178.25,176.43) ; U13137.W5 v4(175,164.73) ; U13137.C5 174.52,175.61 v4(174.35,175.78) ; v4(118.87,125.75) U13141.D2 v4(118.87,125.1) U13141.D1 118.55,124.3 v4(118.54,124.29) ; U13139.K14 137.21,171.03 137.94,171.03 v4(138.34,170.64) ; v4(121.17,124.25) 121.17,124.75 U13141.H1 ; U13142.F13 v4(124.72,144.15) U13142.F14 ; v4(173.05,173.83) U13137.F2 ; U13139.H14 137.34,172.46 v4(137.62,172.46) ; U13141.D13 v4(118.22,132.9) U13141.D14 118.78,133.45 v4(118.78,133.72) v4(118.78,134.59) v4(119.4,134.59) ; U13137.K1 172.03,170.95 171.26,170.95 v4(171.07,171.14) ; U13140.K1 155.97,170.91 v4(156.06,170.81) ; U13140.D11 v4(148.55,166.68) ; v4(147.9,167.33) U13140.D13 147.46,166.89 147.04,166.89 U13140.D14 ; v4(154.4,173.18) U13140.P2 ; U13140.P13 v4(147.9,173.18) ; v4(126.02,132.25) U13141.T13 126.24,132.68 126.24,133.11 U13141.T14 126.53,133.41 v4(126.73,133.61) ; v4(127.61,171.14) 127.8,170.95 128.6,170.95 U13139.K1 ; v4(128.17,168.06) 128.39,168.06 U13139.P1 v4(128.96,168.63) U13139.P2 v4(129.61,167.98) ; v4(126.67,131.6) U13141.T11 v4(126.02,130.95) U13141.R10 ; v4(120.82,130.95) U13141.G10 v4(120.17,130.3) ; v4(120.17,144.8) U13142.P13 v4(119.52,144.15) ; U13140.G5 v4(153.1,168.63) ; U13142.N10 v4(120.17,146.1) ; v4(118.83,146.79) U13142.R10 v4(119.55,146.77) ; U13139.B1 128.51,176.11 v4(128.18,176.43) ; v4(180.87,175.13) 180.55,174.81 U13137.D14 ; v4(174.35,169.28) U13137.N5 ; U13139.V13 v4(136.76,165.38) ; U13141.F13 v4(119.52,132.9) 119.85,133.22 U13141.F14 ; U13137.B13 v4(180.2,176.43) U13137.B14 v4(180.85,176.43) ; v4(154.4,169.93) U13140.J3 ; U13137.L12 v4(179.55,169.93) ; v4(128.06,172.23) 128.08,172.21 U13139.H1 ; v4(177.6,173.18) U13137.G10 v4(178.25,172.53) ; U13142.M14 v4(120.82,143.5) ; v4(180.85,167.98) U13137.P14 v4(180.2,167.98) U13137.P13 ; v4(170.6,172.47) 170.78,172.28 v4(171.59,172.28) 171.67,172.28 171.7,172.31 171.99,172.31 172.07,172.23 U13137.H1 ; v4(118.87,144.8) U13142.T13 v4(118.22,144.15) ; v4(149.89,174.53) U13140.R10 v4(149.88,173.81) ; U13139.T1 128.64,167.01 v4(128.96,167.33) U13139.T2 ; U13141.F2 v4(119.52,125.1) U13141.F1 119.85,124.28 v4(119.92,124.21) ; v4(122.54,134.08) 122.42,133.97 122.42,133.25 U13141.K14 ; U13137.F1 v4(171.61,173.51) ; v4(128.02,143.46) 127.99,143.49 127.99,143.49 U13142.B14 ; U13140.T1 v4(155.88,174.81) ; v4(130.91,165.38) U13139.W5 v4(131.56,164.73) ; v4(128.09,173.51) U13139.F1 ; v4(126.67,124.08) 126.67,124.45 U13141.T1 v4(126.02,125.1) U13141.T2 ; U13137.E5 175.06,174.16 v4(175.2,174.29) ; v4(135.46,171.23) U13139.J12 ; U13137.U5 v4(174.35,166.03) ; U13137.U5 v4(174.35,166.68) ; U13137.U5 v4(175,166.03) ; U13137.F14 v4(180.2,173.83) U13137.F13 ; U13140.U10 v4(149.2,175.78) ; v4(196.99,134.35) 196.99,133.15 v4(196.82,132.97) ; v4(136.11,167.33) U13139.T13 136.55,167.12 136.98,167.12 U13139.T14 v4(137.41,166.68) ; U13140.M14 146.37,172.76 145.86,172.76 145.85,172.75 v4(145.85,172.73) 145.27,172.73 v4(145.25,172.76) ; U13141.C10 v4(117.56,130.28) ; U13139.F14 v4(136.76,173.83) U13139.F13 ; U13137.N10 v4(178.25,168.63) ; v4(177.56,175.76) 177.62,175.76 U13137.C10 v4(178.25,175.13) U13137.D11 ; v4(175.08,177.15) 175.06,177.15 U13137.A5 ; U13139.B13 v4(136.76,176.43) U13139.B14 137.34,176.36 v4(137.49,176.36) 138.15,176.36 v4(138.17,176.39) ; v4(178.25,166.03) U13137.U10 ; U13140.P1 155.91,173.51 v4(155.94,173.54) ; v4(174.35,172.53) U13137.G5 174.76,172.77 175.39,172.77 175.58,172.96 v4(175.58,173.17) ; v4(122.22,123.9) 122.42,124.1 122.42,124.74 U13141.K1 ; v4(153.1,166.68) U13140.C5 ; v4(136.11,169.93) U13139.L12 ; v4(153.1,173.83) U13140.R5 152.52,174.41 152.49,174.41 v4(152.31,174.59) ; v4(120.82,133.55) U13141.H14 ; v4(146.6,173.83) U13140.P14 ; v4(194.36,125.5) v4(194.36,124.59) ; v4(123.42,132.25) U13141.L12 ; v4(134.14,175.8) U13139.C10 ; U13140.F14 v4(147.25,168.63) U13140.F13 ; v4(178.25,173.83) U13137.E10 177.61,174.47 v4(177.58,174.47) ; v4(137.41,169.28) U13139.M14 ; v4(154.4,174.48) U13140.T2
  TOP w0.254: U41.AR5 251.03,107.01 v1(251.39,106.65) 251.23,106.49 251.1,106.49 U41.AR4 ; U13114.AF45 173.74,132.03 v4(173.71,132.03) ; U13113.V25 300.19,64.34 300.56,64.72 v2(300.57,64.72) ; v4(175.11,145.4) 174.79,145.71 U13114.F46 174.74,145.71 v4(174.39,146.06) 174.74,146.41 v4(174.76,146.41) ; v4(175.11,145.4) 175.11,145.34 174.78,145.01 v4(174.76,145.01) ; v4(175.11,145.4) 175.28,145.23 175.28,145.19 U13114.G47 175.66,145.21 175.66,145.25 v4(175.81,145.4) 175.96,145.25 175.96,145.21 v4(176.16,145.01) ; U13114.AL47 175.46,128.25 v4(175.11,128.6) ; U41.BB12 256.08,111.57 v1(255.81,111.3) ; CN2063.2 277.93,55.93 v1(276.5,57.37) ; U13155.E7 U13155.E6 ; U13155.E7 U13155.E8 ; U13155.E7 U13155.F7 ; U13155.E6 U13155.F6 ; U13155.E6 U13155.E5 U13155.F5 ; U41.L34 232.12,128.76 v1(232.19,128.76) ; CN2063.89 256.18,62.72 v1(255.72,63.19) ; v4(173.01,130.7) 173.18,130.53 173.18,130.49 v4(173.36,130.31) ; v4(173.01,130.7) 173.04,130.7 U13114.AG44 ; v4(173.01,130.7) 172.66,130.35 U13114.AH43 ; v4(168.84,143.26) 168.49,142.91 U13114.K37 ; v4(168.84,143.26) 169.16,143.58 U13114.J38 ; v4(168.84,143.26) 168.78,143.26 168.46,143.59 v4(168.46,143.61) 168.46,143.61 168.42,143.61 v4(168.07,143.96) 168.42,144.31 U13114.H37 168.49,144.31 v4(168.84,144.66) ; U13114.BL2 U13114.BL1 142.8,113.76 v2(142.62,113.76) ; v4(176.51,143.3) 176.3,143.08 176.3,143.05 v4(176.16,142.91) ; v4(176.51,143.3) 176.82,143.61 U13114.J49 ; v4(176.51,143.3) 176.86,142.95 U13114.K49 176.86,142.88 v4(177.21,142.53) 177.56,142.88 v4(177.56,142.91) 177.56,142.95 v4(177.91,143.3) 178.26,142.95 U13114.K51 ; U13114.BC19 155.86,119.81 v2(156.21,120.16) ; v1(255.82,131.36) 255.75,131.36 U41.BA38 ; v1(269.13,63.59) 269.69,63.04 CN2063.35 ; U13113.AH17 304.86,60.47 v2(305.21,60.82) ; U13139.W10 v4(134.81,164.73) 134.81,164.15 134.82,164.15 v4(134.82,164.1) ; U13135.A10 205.87,137.28 v4(206.19,136.95) ; U21.Y13 v4(346.47,52.19) U21.W13 ; v1(239.28,130.71) 239.21,130.71 U41.Y37 ; v1(229.1,65.19) 229.44,65.53 CN2062.188 ; v1(227.22,56.58) 228.43,55.37 CN2063.192 ; U13114.AP2 143.96,126.11 v2(143.61,125.76) ; U41.AD30 U41.AD29 242.03,124.38 241.4,123.74 v1(240.23,123.74) 239.67,124.3 U41.AA29 U41.AA30 ; U13114.A50 v4(177.91,149.56) U13114.A51 178.31,149.21 v4(178.66,148.86) ; U21.M19 v4(350.37,49.59) ; v4(350.37,49.59) U21.M20 ; v4(350.37,49.59) U21.L20 ; v4(126.67,150) U13142.C5 127,149.67 v4(126.67,149.35) ; v1(251.93,54.88) CN2063.106 ; v1(332.61,59.96) 332.89,60.24 C94544.2 332.89,61.08 C94547.2 ; U41.BB4 255.9,106.27 255.9,105.79 U41.BB3 255.93,105.64 255.93,105.12 U41.BB2 256.04,105.05 v1(256.43,104.66) 256.26,104.49 256.07,104.49 U41.BB1 ; CN2063.1 278.19,63.53 v1(277.49,64.23) ; U41.D10 227.59,109.92 ; 227.59,109.92 227.21,109.54 U41.D9 226.88,109.18 v1(226.88,109.12) 226.56,108.79 U41.C8 ; 227.59,109.92 227.86,109.65 U41.E9 ; v1(227.18,76.06) CN2062.197 ; v4(154.14,146.06) 153.79,146.41 v4(153.76,146.41) ; v4(154.14,146.06) 154.46,145.75 U13114.F17 ; v4(154.14,146.06) 153.79,145.71 U13114.F16 ; v2(168.81,115.26) 168.46,114.91 U13114.BL37 ; v2(168.81,115.26) 169.16,115.61 U13114.BJ38 U13114.BJ39 ; v2(168.81,115.26) 168.46,115.61 U13114.BJ37 168.11,115.96 ; U21.T18 v4(348.42,50.24) U21.R18 ; U21.AC20 344.25,49.48 343.86,49.88 v1(343.86,50.69) ; v1(244.14,123.62) 244.4,123.87 U41.AG29 U41.AG30 ; U13114.B51 178.31,148.51 v4(178.66,148.86) ; U13136.U5 204.52,118.29 204.52,118.79 204.41,118.9 204.41,119.4 204.71,119.69 v4(204.86,119.69) ; U41.C5 226.56,107.21 v1(226.88,107.54) 226.88,107.61 U41.D6 ; U13114.U7 147.49,138.01 v4(147.81,138.33) ; v4(176.51,125.71) 176.86,126.06 U13114.AP49 ; v4(145.01,130.7) 144.69,131.01 U13114.AG3 ; v4(145.01,130.7) 144.66,130.35 v4(144.66,130.31) 144.55,130.2 144.55,130.16 v4(144.31,129.93) 143.99,129.61 U13114.AJ2 143.92,129.61 v4(143.61,129.93) ; v4(145.01,130.7) 145.36,130.35 U13114.AH4 ; v4(173.06,146.07) 172.71,146.41 v4(172.66,146.41) 172.62,146.41 v4(172.27,146.06) 172.62,145.71 U13114.F43 172.7,145.71 v4(173.06,146.07) ; v4(173.06,146.07) 173.36,145.77 U13114.F44 ; U13113.Y28 300.96,65.88 v2(300.59,65.5) 300.96,65.13 U13113.Y26 ; U13114.AK44 173.32,128.91 v4(173.01,128.6) ; U41.AG8 244.53,108.97 v1(244.84,109.27) ; U13141.P14 v4(125.37,132.9) U13141.P13 ; U13113.AB4 301.84,54.35 U13113.AB5 301.71,54.63 v2(301.41,54.92) ; U13155.F6 U13155.G6 ; U13155.F6 U13155.F7 ; U13155.F6 U13155.F5 ; U13139.D14 137.09,174.81 v4(136.76,175.13) U13139.D13 ; v1(271.17,56.05) 270.68,55.57 270.68,54.88 270.93,54.63 CN2063.30 ; v1(255.67,64.56) 254.93,65.29 CN2062.94 ; U41.BB30 U41.BB29 256.21,124.4 v1(256.94,123.66) ; v2(154.11,115.26) 153.76,114.91 ; 153.76,114.91 U13114.BL16 ; 153.76,114.91 153.76,114.91 v2(153.43,115.25) U13114.BJ15 ; v1(248.02,104.7) 248.11,104.7 248.45,105.03 U41.AM2 ; v1(234.56,131.36) 234.49,131.36 U41.P38 ; U13113.AV31 310.18,67.28 v2(310.18,67.14) ; U21.V8 v4(347.12,55.44) 346.8,55.11 U21.W8 ; CN2063.43 267.69,62.98 v1(267.79,63.08) ; U41.AM1 v1(248.05,104.01) 247.89,104.01 247.25,103.37 v1(246.35,103.37) ; U13136.L3 200.57,116.93 v4(200.24,117.25) U13136.K3 ; v4(173.01,128.6) 173.36,128.25 v4(173.36,128.21) ; v4(173.01,128.6) 172.66,128.25 U13114.AL43 ; v1(213.58,57.42) 213.08,56.91 213.08,55.01 213.43,54.65 CN2063.252 ; v1(256.44,107.32) 256.77,107.66 U41.BC6 ; v1(256.44,107.32) 256.11,107.66 U41.BB6 ; v1(256.44,107.32) 256.3,107.18 256.16,107.18 U41.BB5 ; v4(149.21,139.1) 149.56,138.75 U13114.T10 149.56,138.68 v4(149.21,138.33) 148.89,138.01 U13114.U9 ; v1(254.88,111.28) 255.17,111.57 U41.BA12 ; CN2063.9 276.19,62.85 v1(276.42,63.08) ; U13155.G8 U13155.H8 369.62,28.04 v1(370.06,28.47) ; U13155.G8 369.12,28.2 v1(369.41,28.49) ; U13155.G8 U13155.G7 ; U13155.G8 U13155.F8 ; v4(149.2,166.03) U13140.C10 ; v1(257.2,167.73) 257.42,167.73 C94723.1 ; v1(231.8,124.05) U41.L29 U41.L30 ; C94823.2 329.15,48.56 v1(329.05,48.66) ; v4(163.87,149.56) 164.31,149.13 164.31,148.56 U13114.B31 ; v4(147.84,146.76) 148.16,146.45 U13114.E8 ; v4(147.84,146.76) 147.49,146.41 v4(147.46,146.41) 147.42,146.41 v4(147.07,146.06) 147.42,145.71 U13114.F7 ; v4(147.84,146.76) 147.78,146.76 147.46,147.09 U13114.D7 ; CN2062.230 218.94,65.29 v1(218.1,64.46) ; v4(140.23,145.69) 140.02,145.48 v4(140.02,144.26) 140.02,143.56 v4(140.29,143.3) ; v4(140.23,145.69) 140.66,145.25 141.06,145.25 v4(141.5,145.69) 141.93,145.25 143.46,145.25 v4(143.61,145.4) 143.96,145.05 U13114.G2 144.01,144.96 144.61,144.96 v4(144.66,145.01) ; v4(140.23,145.69) 140.23,148.02 v4(140.37,148.16) 140.86,148.65 141.15,148.65 v4(141.64,148.16) 142.13,148.65 142.42,148.65 v4(142.91,148.16) ; CN2063.85 257.18,63.41 v1(257.63,63.85) ; U13139.P14 v4(136.76,167.98) U13139.P13 ; v1(227.12,65.24) 227.43,65.56 CN2062.196 ; U13138.G5 v4(197.64,152.96) ; U13113.H27 295.1,64.88 v2(295.19,64.78) 295.19,64.33 U13113.H24 ; U41.AU34 252.34,128.43 v1(252.66,128.1) 252.59,128.1 U41.AU33 ; U41.AY33 254.95,128.1 v1(255.03,128.1) ; v2(302.51,56.58) 302.08,56.15 U13113.AB8 U13113.AB10 ; v4(179.99,140.41) 179.99,140.65 179.44,141.2 v4(179.31,141.2) ; v2(293.72,60.06) 293.53,60.25 U13113.D16 293.09,60.34 U13113.D17 ; U13113.AD11 302.7,57.68 v2(302.48,57.9) 302.26,57.68 U13113.AB11 ; U41.D12 226.56,111.22 U41.C11 226.23,110.76 v1(226.23,110.69) ; U13113.AW29 310.58,66.28 310.26,65.96 v2(309.73,65.96) 309.73,65.53 U13113.AV27 ; v1(257.66,111.86) 257.48,111.86 U41.BC12 ; U41.BM26 262.96,122.99 v1(262.96,123.06) 262.96,123.13 U41.BM27 ; U13155.G6 U13155.G5 ; U13155.G6 U13155.G7 ; U13155.G5 U13155.F5 ; U13155.G5 U13155.H5 369.95,26.16 v1(370.06,26.16) 369.89,25.99 U13155.H4 369.62,25.64 v1(369.77,25.49) ; U41.BM12 U41.BM13 263.61,112.76 v1(263.61,112.82) ; U41.AL8 247.03,108.97 v1(246.7,109.3) 246.86,109.47 246.97,109.47 U41.AL9 247.13,109.62 247.46,109.95 v1(247.57,109.95) v1(247.57,110.59) v1(247.57,111.27) ; U41.BA10 255.35,110.36 255.65,110.66 v1(255.81,110.66) ; U13114.H1 142.63,144.31 141.64,143.32 v4(141.64,143.3) ; v2(297.91,54.44) 297.63,54.16 U13113.N4 ; v2(297.91,54.44) 297.54,54.81 U13113.N5 297.15,54.54 297.15,54.47 296.97,54.47 U13113.L4 296.64,54.15 U13113.K4 296.12,54.07 295.82,54.07 U13113.J3 295.43,53.68 U13113.H3 ; v2(297.91,54.44) 298.17,54.44 U13113.R5 ; v1(235.72,111.23) v1(235.72,110.57) 235.84,110.57 U41.T10 ; v1(235.72,111.23) 236.05,111.57 U41.T12 236.33,111.75 236.88,111.75 U41.V12 237.15,111.57 237.34,111.75 237.74,111.75 237.92,111.57 U41.W12 ; v1(235.72,111.23) 235.38,111.57 U41.R12 ; v1(235.72,111.23) 235.83,111.23 U41.T11 ; U13142.D2 v4(126.67,151.95) U13142.D1 126.69,152.62 v4(126.69,152.69) 126.69,152.86 v4(126.09,153.46) ; U41.AH33 244.86,127.46 v1(244.79,127.46) ; v4(151.27,143.26) 151.62,142.91 U13114.K13 151.69,142.91 v4(152.04,143.26) 151.69,143.61 v4(151.66,143.61) ; v4(151.27,143.26) 151.31,143.26 v4(151.66,143.61) ; v4(151.27,143.26) 150.96,143.58 U13114.J12 ; v4(205.99,144.3) 205.99,144.03 v4(205.44,143.48) 205.44,143.45 U13135.B1 v4(205.44,142.8) U13135.B2 ; v2(145.01,125.76) 145.36,126.11 U13114.AP4 ; U41.K1 230.8,104.45 230.8,104.91 230.84,104.95 U41.K2 230.71,105.05 v1(230.42,105.35) 230.49,105.35 230.84,105.7 U41.K3 230.82,105.7 230.69,105.84 230.58,105.84 v1(230.42,106) 230.61,106.19 230.7,106.19 230.84,106.33 U41.K4 ; v1(230.2,111.48) 230.74,110.94 U41.K11 230.55,110.73 230.55,110.45 U41.K10 230.67,110.27 v1(230.34,109.94) ; v1(230.2,111.48) 229.81,111.87 U41.H12 ; v1(230.2,111.48) 229.81,111.09 U41.H11 229.81,110.69 229.88,110.61 U41.J10 230.24,109.94 v1(230.34,109.94) ; v2(160.41,115.26) U13114.BJ25 ; v2(160.41,115.26) 160.06,114.91 U13114.BL25 ; v2(160.41,115.26) U13114.BJ26 U13114.BJ27 ; v1(350.35,79.86) CN2042.23 ; v4(145.01,146.76) U13114.D4 v4(145.01,147.46) ; v4(131.5,177.2) 131.24,176.94 U13139.A5 ; CN2063.22 v1(272.93,55.29) ; v1(232.48,55.06) 232.44,55.02 CN2063.176 ; v4(206.32,118.6) 205.95,118.23 U13136.W5 ; U13114.B13 v4(151.66,147.81) 151.71,147.76 151.71,147.16 U13114.D13 151.62,147.11 v4(151.27,146.76) 150.96,147.08 U13114.D12 ; CN2063.234 217.94,55.55 v1(218.5,56.11) ; U41.J32 229.9,127.46 v1(229.83,127.46) 230.15,127.78 U41.J33 ; U41.N11 233.3,110.92 v1(232.96,111.26) ; U13155.E8 U13155.D8 367.26,27.99 v1(367.15,27.88) 367.04,27.99 U13155.B8 ; U13155.E8 U13155.F8 ; v1(303.8,79.34) 303.8,78.91 303.68,78.78 R21286.1 ; v1(255.72,77.61) 257.18,76.15 CN2062.85 ; v4(201.54,140.85) U13135.G5 ; v4(202.19,158.16) U13138.P13 v4(202.84,158.81) U13138.P14 ; v4(196.99,152.96) U13138.E5 ; v1(225.18,63.22) CN2063.205 ; v4(173.71,132.03) 173.71,132.06 v4(173.36,132.41) ; v4(173.71,132.03) 174.06,132.38 U13114.AE45 174.06,132.45 v4(173.71,132.8) ; U13114.F37 168.55,145.8 168.55,146.32 v4(168.46,146.41) ; v1(229.1,63.75) 228.18,62.83 CN2063.193 ; v1(274.31,63.26) 274.68,62.89 CN2063.15 ; U13113.H22 295.07,62.87 295.1,62.85 295.1,62.48 v2(294.96,62.35) ; U41.AN29 249.12,125.05 249.62,124.55 v1(250.97,124.55) ; v4(151.66,143.61) 151.81,143.76 151.81,144.16 U13114.H13 151.69,144.31 v4(152.04,144.66) 151.69,145.01 v4(151.66,145.01) 151.62,145.01 v4(151.27,145.36) 151.62,145.71 U13114.F13 ; v2(147.81,124.36) 148.16,124.71 U13114.AT8 ; U41.BP21 264.91,119.05 v1(264.91,119.12) 265.24,118.8 U41.BR21 U41.BT21 ; v2(170.91,115.26) 170.56,114.91 U13114.BL40 ; v2(170.91,115.26) 170.56,115.61 ; v2(170.91,115.26) 170.91,115.26 U13114.BJ41 U13114.BJ42 171.96,115.61 v2(172.31,115.96) U13114.BH42 ; v2(304.82,54.34) 304.63,54.34 304.45,54.16 U13113.AG4 ; U13114.BC22 158.13,119.64 158.13,118.59 U13114.BE22 157.96,118.41 v2(157.61,118.06) U13114.BE21 ; v4(118.22,143.5) U13142.T14 v4(118.22,144.15) ; U21.N9 v4(349.72,54.79) U21.N8 ; U41.AD10 241.3,110.6 v1(241.18,110.6) ; v1(224,63.8) 223.18,62.98 CN2063.213 ; v4(203.97,114.4) 203.97,115.05 v4(203.89,115.13) 203.82,115.2 U13136.T1 v4(204.14,115.95) U13136.T2 v4(203.49,116.6) ; C95624.2 46.53,30.93 v1(46.3,31.16) ; U13114.B46 174.76,148.16 v4(174.62,148.02) 175.15,147.49 v4(175.15,147.47) 174.79,147.11 U13114.D46 ; v1(267.76,76.72) 268.69,75.8 CN2062.39 ; U41.AF13 U41.AF14 243.51,112.87 v1(244.01,113.36) ; v1(232.96,111.26) 232.8,111.26 U41.M12 U41.M13 232.61,112.33 232.61,112.75 U41.M14 ; v1(232.96,111.26) 233.1,111.26 U41.N12 233.72,111.88 233.86,111.88 v1(233.86,111.88) 234,111.88 U41.P12 234.65,111.9 v1(234.78,111.9) 234.9,111.9 U41.R12 ; U41.F13 228.51,112.8 U41.G14 229.48,113.77 v1(229.48,113.84) ; U13093.2 263.4,51.46 263.72,51.78 v1(263.72,51.81) 263.9,51.63 U13093.1 ; v4(199.85,149.99) 199.89,150.04 199.89,150.66 U13138.K1 ; v4(146.07,138.71) 146.22,138.57 146.22,138.57 v4(146.43,138.35) 146.6,138.52 146.6,138.56 U13114.T6 ; U13142.P2 119.85,151.62 v4(120.17,151.3) ; CN2063.94 254.93,55.21 255.35,55.62 v1(255.47,55.62) 255.73,55.62 256.1,55.25 256.1,54.68 255.93,54.51 CN2063.90 ; U13114.W43 172.66,136.65 v4(173.01,137) 173.25,136.76 173.25,136.72 v4(173.36,136.61) 173.55,136.8 173.55,136.83 v4(173.71,137) 174.06,136.65 U13114.W45 ; U13114.T2 v4(144.66,138.71) 144.66,138.75 v4(145.01,139.1) 145.36,138.75 U13114.T4 ; U13135.F2 202.52,142.48 v4(202.84,142.15) ; v1(227.12,64.53) 226.82,64.53 225.94,65.41 CN2062.202 ; U13113.AL17 U13113.AM17 307.26,60.23 v2(307.26,59.88) ; v4(126.71,143.46) U13142.D14 ; U13135.V13 v4(194.39,135) U13135.V14 v4(194.39,134.35) 194.39,133.13 v1(194.17,132.91) ; U41.BA7 255.25,108.32 v1(254.94,108.63) ; CN2071.7 188.35,48.21 v1(188.59,47.97) 188.85,48.23 CN2071.8 ; CN2062.167 234.69,76.15 v1(232.66,78.17) ; 366.52,84.73 PU8006.4 ; 366.52,84.73 PU8006.11 ; 366.52,84.73 PU8006.15 366.87,84.73 367.02,84.57 PU8006.5 ; U13113.BB16 311.33,60.07 v2(311.04,59.78) ; v4(202.99,140.09) 203.17,140.27 U13135.E5 ; v4(152.39,177.17) 152.78,176.79 U13140.W5 152.94,176.92 v4(153.11,177.09) ; U13136.B1 194.72,115.6 195.02,115.3 v4(195.02,115.25) ; U13136.B1 v4(194.39,115.95) U13136.B2 ; U13136.B1 194.39,115.3 v4(194.39,115.23) ; CN2062.64 262.44,65.41 v1(262.61,65.24) ; U13114.AT5 v2(146.41,124.36) U13114.AU6 ; v4(147.46,147.81) 147.42,147.81 v4(147.07,148.16) 147.42,148.51 U13114.B7 147.51,148.51 v4(147.85,148.85) 147.49,149.21 v4(147.49,149.22) ; CN2070.33 v1(38.74,21.17) ; U13114.BE34 v2(166.01,118.76) ; v4(204.79,140.85) U13135.C5 204.79,140.2 v4(204.79,139.51) ; U13113.J10 295.17,56.85 v2(294.99,57.03) 294.99,57.29 295.19,57.49 U13113.J11 ; U13114.AP6 146.76,126.11 v2(146.41,125.76) ; v4(195.04,140.2) U13135.U5 v4(195.69,140.85) ; U13142.E5 125.7,149.67 125.37,149.35 v4(125.37,149.35) ; v1(241.36,107.32) 241.25,107.32 240.94,107.01 U41.AC5 ; v1(241.36,107.32) 241.02,107.66 U41.AC6 U41.AB6 239.78,107.66 239.34,108.09 239.11,108.09 U41.Y7 238.94,108.32 239.26,108.64 v1(239.33,108.64) 239.09,108.88 238.98,108.88 U41.Y8 238.86,109 238.86,109.52 238.89,109.55 U41.Y9 U41.Y10 238.75,110.27 v1(238.42,110.6) 238.61,110.79 238.76,110.79 U41.Y11 ; v1(241.36,107.32) 241.7,107.66 U41.AD6 241.63,107.76 U41.AD7 U41.AD8 ; U41.G24 228.83,121.65 v1(228.83,121.72) ; v2(144.31,125.76) 145.36,126.81 U13114.AN4 ; v2(147.11,116.66) 147.46,117.01 U13114.BG7 U13114.BF6 ; v1(277.21,76.72) 277.08,76.6 276.88,76.6 276.19,75.9 CN2062.9 ; U41.BF12 258.84,111.57 v1(258.55,111.28) 258.26,111.57 U41.BD12 ; v4(173.71,124.4) 173.71,124.36 U13114.AU45 173.71,123.66 v4(173.71,123.63) 174.02,123.31 U13114.AV45 U13114.AW46 ; CN2063.18 273.93,55.74 v1(272.94,56.73) ; U41.P6 234.04,107.81 233.51,107.81 U41.N6 ; PC9379.2 89.91,77.62 89.87,77.58 PC9376.2 ; v2(300.56,63.95) 300.18,63.58 U13113.V23 ; CN2063.171 233.69,62.82 233.37,63.13 v1(232.69,63.13) CN2063.175 ; U41.AE34 243.15,128.1 v1(243.22,128.1) ; U41.AM5 248.45,107 248.76,106.69 v1(248.9,106.69) 249.02,106.69 249.33,107.01 U41.AN5 249.4,107.07 249.4,107.54 U41.AN6 ; v4(173.36,132.41) 173.01,132.76 v4(173.01,132.8) ; v4(173.36,132.41) 173.71,132.76 v4(173.71,132.8) ; v1(49.32,55.08) 49.32,55.31 v1(48.84,55.8) 48.53,56.1 R22187.2 ; U41.BG12 259.89,111.6 259.89,112.06 259.92,112.09 U41.BG13 259.6,112.54 v1(259.46,112.54) ; U13138.T13 v4(204.14,158.81) U13138.T14 v4(204.14,159.46) 204.14,160.48 v4(204.11,160.51) ; U13139.K3 v4(129.61,171.23) U13139.J3 129.94,171.56 v4(130.26,171.23) U13139.K3 ; U13139.K3 v4(130.26,170.58) U13139.L3 ; v1(213.61,76.14) 213.69,76.06 CN2062.251 ; U13113.M35 296.96,69.01 v2(297.02,68.95) 297.39,69.32 U13113.N35 ; v4(174.5,138.45) 174.32,138.45 U13114.T45 ; CN2063.243 215.69,62.74 215.62,62.81 215.62,63.34 v1(216.18,63.91) 216.71,63.39 216.71,62.8 216.69,62.78 CN2063.239 ; v1(271.14,64.28) 271.93,65.07 CN2062.26 ; U41.BR24 U41.BT24 266.47,121.09 v1(266.64,120.92) ; CN2069.15 v1(60.24,21.17) ; U13113.AL11 U13113.AL13 306.36,58.54 v2(306.08,58.26) 305.94,58.39 305.94,58.77 U13113.AJ14 U13113.AJ15 ; v4(156.24,143.26) 156.56,143.58 U13114.J20 ; v4(156.24,143.26) 156,143.5 155.97,143.5 v4(155.86,143.61) ; v4(156.24,143.26) 155.89,142.91 U13114.K19 ; v4(125.29,153.46) 125.37,153.38 v4(125.37,152.6) U13142.F1 125.05,152.27 v4(125.37,151.95) U13142.F2 ; v4(195.69,122.45) U13136.D11 196.02,122.13 v4(196.34,121.8) U13136.E10 ; v1(224,65.27) 223.94,65.33 CN2062.210 ; U41.BA11 255.31,110.92 255.02,110.63 v1(254.91,110.63) ; CN2063.51 265.69,63.02 v1(265.81,63.14) ; U13114.B28 162.16,148.11 v4(162.07,148.02) 162.07,147.92 v4(162.54,147.45) ; U41.G22 228.83,119.42 v1(228.83,119.35) 228.83,119.28 U41.F21 ; C95546.1 51.07,57.27 v1(50.77,57.57) ; v1(263.88,64.99) 264.44,65.55 CN2062.56 ; v1(213.61,77.97) 213.68,77.97 215.69,75.97 CN2062.243 ; U41.AH34 244.86,128.1 v1(244.79,128.1) ; U13113.AJ26 U13113.AH26 304.82,65.12 v2(304.44,64.73) ; U21.M11 v4(349.72,54.14) U21.N11 ; v2(295.8,72.6) 296.17,72.97 U13113.K42 ; v1(228.17,106.75) 228.53,107.11 U41.F5 ; v1(228.17,106.75) 227.83,106.41 U41.E4 ; v1(228.17,106.75) 228.52,106.4 U41.F4 228.52,105.81 U41.F3 ; v1(247.57,111.27) 247.87,111.57 U41.AM12 248.17,111.57 v1(248.49,111.25) 248.81,111.57 U41.AN12 ; v1(247.57,111.27) 247.27,111.57 U41.AL12 ; U41.AM4 248.45,106.32 248.14,106.01 v1(248.03,106.01) 247.87,106.01 247.56,106.32 U41.AL4 ; v4(140.29,143.3) 140.29,143.31 v4(141.22,144.24) ; v4(140.29,143.3) 140.73,142.86 141.2,142.86 v4(141.64,143.3) ; U21.R20 v4(348.42,49.59) U21.R19 ; U41.N34 233.24,128.3 233.24,127.91 U41.N33 233.31,127.78 v1(232.98,127.45) ; CN2063.251 213.69,63.01 v1(213.61,63.08) ; v4(152.45,166.04) 152.45,166.04 U13140.C5 ; U41.J18 U41.H18 229.77,116.6 229.68,116.69 229.28,116.69 229.19,116.6 U41.G18 ; v2(143.61,115.96) 143.96,116.31 U13114.BH2 ; v4(177.21,139.1) 176.89,139.41 U13114.R49 ; v4(177.21,139.1) 177.38,138.92 177.38,138.89 v4(177.56,138.71) 177.61,138.66 178.21,138.66 U13114.T51 ; v4(177.21,139.1) 176.86,138.75 U13114.T49 ; U41.BM38 263.14,131.1 v1(262.78,131.46) 262.43,131.11 U41.BL38 ; v2(145.01,122.96) U13114.AW4 ; U13114.K28 162.19,142.91 v4(162.54,143.26) 162.19,143.61 v4(162.16,143.61) ; v1(260.8,77) 261.41,77 262.19,76.23 CN2062.65 ; U41.AW5 253.8,106.68 v1(253.88,106.68) 253.56,106.35 U41.AW4 ; v2(168.11,118.06) 168.46,118.41 U13114.BE37 ; v2(168.11,118.06) U13114.BE36 ; v2(168.11,118.06) v2(168.81,117.36) 168.46,117.01 U13114.BG37 ; U13114.BH27 U13114.BJ27 ; U13114.BJ27 U13114.BJ28 v2(162.51,115.26) ; v4(164.89,150.83) 164.66,150.83 164.46,150.63 164.46,150.08 164.87,149.67 v4(164.89,149.7) 164.89,149.67 164.96,149.6 U13114.A32 ; v1(276.47,58.08) 275.93,57.54 CN2063.10 ; v4(194.36,159.49) 194.71,159.13 ; 194.71,159.13 194.71,159.13 v4(194.39,158.81) 194.39,158.81 U13138.B13 ; 194.71,159.13 U13138.B14 ; U41.AU8 252.74,108.97 v1(253.04,109.27) ; C94542.2 337.18,60.9 v1(337.33,61.05) ; U13114.BJ21 v2(157.61,115.26) 157.96,114.91 157.96,114.91 ; v1(229.48,124.08) 229.48,124.15 U41.G28 ; CN2062.69 261.19,75.91 v1(260.78,76.32) ; U41.R12 235.45,111.79 235.72,111.79 U41.T13 236.15,112.32 236.13,112.34 236.13,112.74 236.15,112.76 U41.T14 ; v4(146.06,134.51) 146.2,134.37 146.2,134.34 v4(146.41,134.13) 146.76,134.48 U13114.AB6 146.76,134.55 v4(147.11,134.9) 147.46,134.55 v4(147.46,134.51) 147.46,134.48 v4(147.81,134.13) 147.97,134.29 147.97,134.33 U13114.AB8 ; v2(153.51,116.58) 153.51,116.77 U13114.BG16 ; v1(224,64.53) 222.94,65.59 CN2062.214 ; U13142.A5 128.3,149.67 v4(127.97,149.35) ; v4(147.81,138.33) 147.46,138.68 v4(147.46,138.71) ; v4(147.81,138.33) 148.16,138.68 U13114.T8 ; U41.AU11 252.45,110.92 v1(252.15,110.62) 252.39,110.38 252.49,110.38 U41.AU10 ; v4(202.85,156.2) 203.17,156.51 U13138.R10 203.51,156.19 v4(203.51,156.19) ; v1(229.33,76.27) 229.18,76.12 CN2062.189 ; R129.2 273.61,123.76 273.73,123.64 R20814.1 273.96,124.04 274.09,124.17 v1(274.19,124.17) ; v4(134.15,174.49) U13139.E10 v4(134.81,173.83) ; C96153.2 146.58,173.86 ; v1(258.9,63.11) 259.18,62.82 CN2063.77 ; v2(305.21,60.82) 305.57,60.47 U13113.AJ17 ; v2(305.21,60.82) 305.61,61.22 U13113.AJ18 ; v1(257.6,65.27) 257.93,65.6 CN2062.82 ; v4(156.24,144.66) 156.21,144.66 U13114.H19 ; CN11.4 v1(75.05,27.65) ; v1(28.37,24.73) C94939.1 ; v2(143.35,113) 143.87,113.51 U13114.BM2 ; U41.BF34 259.68,128.76 v1(259.75,128.76) ; U41.AL10 246.78,110.6 v1(246.65,110.6) ; v1(376.63,11.88) 376.63,11.58 376.63,11.58 U13152.2 ; v4(134.14,177.1) U13139.A10 v4(134.81,176.43) ; v2(293.31,61.28) 293.31,61.35 293.11,61.56 U13113.D19 293.11,62.21 293.18,62.29 U13113.D21 ; v4(145.71,132.03) 145.36,132.38 U13114.AE4 145.36,132.45 v4(145.01,132.8) 144.66,132.45 v4(144.66,132.41) 144.66,132.38 v4(144.31,132.03) 143.96,132.38 U13114.AE2 143.93,132.39 139.86,132.39 v4(139.39,131.92) ; v4(145.71,132.03) 145.71,132.06 v4(146.06,132.41) ; v4(145.71,132.03) 146.02,131.71 U13114.AF5 ; v4(116.9,152.79) 117.25,152.44 U13142.V1 v4(116.92,151.95) U13142.V2 ; U13113.R29 298.7,66.17 v2(298.87,66) 298.98,65.89 U13113.U28 ; v4(177.56,124.01) 177.56,123.98 v4(177.21,123.63) 176.86,123.98 U13114.AU49 ; CN2069.51 v1(69.24,21.14) ; v4(166.74,145.36) 167.06,145.68 U13114.F35 ; v4(166.74,145.36) 166.39,145.71 U13114.F34 166.32,145.71 v4(165.97,145.36) 166.32,145.01 v4(166.36,145.01) ; v4(166.74,145.36) 166.39,145.01 v4(166.36,145.01) ; v1(266.54,109.92) 266.4,110.07 U41.BT9 ; 177.21,136.96 v4(177.56,136.61) 177.58,136.61 177.91,136.94 v4(177.91,137) 178.26,136.65 U13114.W51 178.35,136.52 179.07,136.52 v4(179.22,136.67) ; 177.21,136.96 U13114.W49 ; 177.21,136.96 v4(177.21,137) 176.89,137.31 U13114.V49 ; U41.AM3 248.45,105.68 248.13,105.37 v1(248.02,105.37) ; v4(202.19,137.6) U13135.G10 v4(201.54,136.95) ; U13114.Y9 148.89,135.91 v4(149.21,136.23) ; v1(228.83,109.12) 228.83,109.18 U41.G9 229.05,109.62 229.05,110.19 U41.G10 ; v1(228.83,109.12) 228.65,109.3 228.65,109.37 U41.F9 ; v1(228.83,109.12) 228.83,109.05 U41.F8 ; U13114.BE19 155.86,118.41 v2(155.51,118.06) U13114.BE18 ; U13114.BJ18 155.16,115.61 v2(155.62,116.07) 155.4,116.07 U13114.BH18 ; U13114.AE43 172.66,132.45 v4(173.01,132.8) ; v4(128.62,127.7) U13141.W5 ; U41.AC37 240.92,130.71 v1(240.86,130.71) ; v1(346.35,79.85) CN2042.15 ; v1(49.68,21.28) 49.24,20.84 CN2070.75 ; v4(204.14,122.45) U13136.T11 ; U13114.AV4 v2(145.71,122.96) U13114.AW5 146.06,122.61 v2(146.41,122.96) ; v1(227.12,77.69) 226.18,76.75 CN2062.201 ; v4(380.74,46.42) 380.79,46.42 381.09,46.13 CN18.B1 ; U13114.V52 179.22,137.05 v4(179.22,136.67) ; v4(201.53,134.04) 201.53,134.37 U13135.H14 ; v1(58.52,66.74) 58.52,66.87 58.97,67.33 59.38,67.33 59.46,67.25 CN2068.29 ; U41.BE1 258.51,104.4 258.81,104.7 v1(258.98,104.7) ; U41.AD12 241.48,111.57 v1(241.16,111.25) 240.84,111.57 U41.AC12 240.54,111.74 239.98,111.74 U41.AA12 ; v4(174.76,140.81) 174.76,140.78 v4(175.11,140.43) 175.46,140.78 U13114.N47 175.46,140.85 v4(175.81,141.2) 175.96,141.05 175.96,140.99 176.13,140.81 v4(176.16,140.81) ; v1(219.86,56.28) 219.31,55.73 219.31,55.45 218.94,55.08 CN2063.230 ; U13113.AA42 301.44,72.87 301.44,72.4 v2(301.27,72.23) ; U13114.AE49 177.02,132.25 177.4,132.25 v4(177.56,132.41) U13114.AE51 ; CN2062.180 231.44,65.52 v1(230.42,64.51) ; v4(144.66,128.16) 144.53,128.03 144.14,128.03 U13114.AL2 143.86,128.11 143.4,128.11 v4(142.91,128.6) ; v1(265.81,65.27) 265.44,65.64 CN2062.52 ; U41.G23 228.83,120.21 ; 228.83,120.21 U41.F23 ; 228.83,120.21 v1(228.83,120.14) ; v4(148.55,175.13) U13140.T11 ; v4(149.94,143.96) 149.59,144.31 U13114.H10 149.47,144.31 v4(149.15,144.64) 149.18,144.64 v4(149.56,145.01) 149.52,145.01 v4(149.17,145.36) 149.21,145.36 U13114.F10 ; U41.G20 228.84,118.49 v1(228.84,118.57) ; v4(177.32,121.61) 177.01,121.91 U13114.AY49 ; v1(262.61,77.23) 263.44,77.23 264.19,76.49 CN2062.57 ; U13114.D28 162.21,147.11 v4(162.54,147.45) ; U13140.L3 154.07,171.56 v4(153.75,171.23) U13140.K3 ; CN2068.63 59.58,58.75 59.46,58.63 58.35,58.63 v1(57.07,57.34) ; U41.AY14 254.76,112.54 v1(254.9,112.54) ; CN2062.176 232.44,65.49 v1(232.66,65.27) ; CN2063.26 271.93,54.64 271.65,54.93 271.65,56.43 v1(271.24,56.84) ; U13113.H17 295.21,60.61 v2(295.57,60.97) 295.57,61.32 U13113.H19 ; CN2063.60 263.44,55.27 263.11,55.6 v1(262.94,55.6) ; CN2062.244 215.43,65.5 215.64,65.29 v1(216.17,65.29) ; v4(120.15,128.3) 120.2,128.3 120.6,127.9 120.6,127.47 U13141.G5 v4(120.82,127.05) ; v1(40.46,21.17) 40.24,20.96 CN2070.39 ; CN2068.23 59.56,68.75 59.51,68.8 58.44,68.8 57.83,68.19 v1(57.83,67.96) ; U13113.B44 292.14,73.94 292.14,74.29 U13113.B45 U13113.A44 291.66,74.03 v1(291.28,74.41) ; U13138.L12 v4(200.24,157.51) ; v4(117.57,144.8) U13142.V13 v4(116.92,144.15) U13142.V14 117.25,143.82 v4(116.93,143.49) ; U13113.D30 293.09,67.16 U13113.D31 293.56,67.6 U13113.E31 293.62,67.31 v2(293.74,67.19) 293.62,67.07 U13113.D30 ; U13113.D30 293.11,66.99 U13113.D29 ; v1(344.85,79.77) CN2042.12 ; U41.BC14 257.32,112.87 v1(257.65,112.54) 257.33,112.22 U41.BC13 ; U13114.AH2 143.96,130.28 v4(143.61,129.93) ; U13113.U10 299.56,56.89 v2(299.94,56.51) 299.59,56.15 U13113.U8 ; CN2069.75 75.24,19.13 75.33,19.04 75.6,19.04 v1(76.06,19.5) ; v1(225.24,64.84) 224.94,65.14 CN2062.206 ; U41.BP24 264.26,120.76 v1(264.26,120.7) ; v4(159.67,147.46) 159.36,147.15 U13114.D24 ; v4(159.67,147.46) 160.02,147.11 U13114.D25 160.09,147.11 v4(160.44,147.46) 160.09,147.81 v4(160.06,147.81) ; v4(159.67,147.46) 160.02,147.81 v4(160.06,147.81) ; v4(141.64,143.3) 141.87,143.07 142.68,143.07 v4(142.91,143.3) 143.22,143.61 U13114.J1 ; C94821.1 317.94,54.79 316.96,55.77 v1(316.96,56.25) ; CN2062.93 255.18,75.83 255.56,76.21 v1(255.68,76.21) 255.88,76.21 256.18,75.91 CN2062.89 ; v4(154.4,175.78) 154.72,176.11 U13140.V2 ; U13114.B37 168.46,147.81 v4(168.46,147.81) 168.49,147.81 v4(168.84,147.46) 168.49,147.11 U13114.D37 ; U13140.L12 148.23,171.56 v4(148.55,171.23) ; U41.BL35 263.17,129.08 U41.BM35 263.61,128.64 v1(263.61,128.57) ; v1(232.69,76.22) CN2062.175 ; U13140.A5 152.45,164.74 v4(152.45,164.74) ; v4(198.29,134.35) U13135.M14 ; v1(264.91,115.97) 264.91,116.04 U41.BR18 U41.BT18 ; v1(291.15,64.81) 291.68,64.81 U13113.A25 U13113.B25 ; CN2070.45 v1(41.74,21.24) ; U13114.BJ7 v2(147.11,115.96) ; v4(179.31,141.2) 178.99,141.51 U13114.M52 ; v4(179.31,141.2) 179.31,141.13 v4(178.61,140.43) ; U41.AR2 251.31,104.7 v1(251.41,104.7) ; v4(119.52,144.15) U13142.P14 119.85,143.73 v4(119.54,143.42) ; CN2063.82 257.93,54.55 258.11,54.73 258.11,55.26 257.75,55.62 v1(257.6,55.62) 257.38,55.62 256.93,55.18 CN2063.86 ; U13113.L15 296.8,59.5 297.2,59.09 v2(297.2,59) ; v1(227.18,63.07) CN2063.197 ; PR9004.2 138.25,73.04 v1(137.92,73.37) ; v1(306.57,47.92) R21131.2 ; U13114.AB10 149.56,134.48 v4(149.21,134.13) 149.12,134.22 149.12,134.28 148.88,134.51 v4(148.86,134.51) ; v4(195.04,151.66) U13138.B2 v4(194.39,151.01) U13138.B1 194.39,150.36 v4(194.39,150.33) 194.68,150.05 v4(194.68,149.49) ; CN2063.61 263.19,63.32 v1(262.66,63.85) ; U13113.L8 296.2,56.41 U13113.K10 296.43,57.13 296.84,57.13 v2(296.89,57.19) ; v4(149.2,173.18) U13140.N10 ; v4(195.04,121.8) U13136.C10 ; v2(297.55,61.17) 297.55,61.41 297.94,61.8 U13113.P19 ; v1(250.33,113.32) U41.AR14 ; v1(261.01,57.19) 262.33,55.87 262.33,54.78 262.44,54.67 CN2063.64 ; CN2069.45 v1(67.74,21.15) ; U41.AK4 246.82,106.32 246.53,106.03 v1(246.36,106.03) 246.19,106.03 245.93,106.29 U41.AJ4 ; CN2069.33 v1(64.74,21.15) ; v2(154.1,119.44) 154.1,119.45 154.1,119.47 U13114.BC16 ; v4(146.06,145.01) 145.71,144.66 v4(145.71,144.63) 145.36,144.98 U13114.G4 ; CN2063.52 265.44,55.8 v1(264.57,56.67) ; CN2068.39 59.52,64.75 59.41,64.63 58.21,64.63 57.86,64.28 v1(57.86,64.1) ; U41.AG6 244.21,107.66 v1(243.87,108) ; U13155.A1 365.64,24.49 v1(365.4,24.25) ; U13114.M6 v4(147.09,141.18) ; v4(147.09,141.18) v4(147.46,140.81) 147.82,141.17 v4(147.82,141.18) 148.16,140.84 U13114.N8 ; v4(147.09,141.18) 146.76,140.85 U13114.N6 146.76,140.78 v4(146.41,140.43) 146.06,140.78 v4(146.06,140.81) ; U13113.AM22 306.87,63.11 v2(307.23,63.47) 307.64,63.06 U13113.AN22 ; U13114.BE36 167.76,118.41 v2(168.11,118.76) ; U13114.BE36 U13114.BD35 v2(166.71,119.46) U13114.BC34 ; U13114.K25 160.02,142.91 v4(159.67,143.26) 159.77,143.36 159.83,143.36 160.06,143.59 v4(160.06,143.61) 160.06,143.64 159.87,143.83 159.81,143.83 v4(159.67,143.96) 160.02,144.31 U13114.H25 160.09,144.31 v4(160.44,144.66) 160.09,145.01 v4(160.06,145.01) 160.02,145.01 v4(159.67,145.36) 160.02,145.71 U13114.F25 ; U41.BA8 255.03,109.29 v1(254.91,109.29) ; U41.AR3 251.32,105.35 v1(251.4,105.35) ; U41.BR14 265.24,113.29 v1(265.56,113.61) 265.89,113.29 U41.BT14 ; v2(295.95,54.54) 295.94,54.53 U13113.J5 ; U13114.AL6 146.76,128.18 v4(147.11,127.83) 147.3,128.02 147.3,128.05 v4(147.46,128.21) 147.64,128.03 147.98,128.03 U13114.AL8 148.16,128.18 v4(148.51,127.83) ; v1(228.18,122.5) 228.18,122.43 U41.F25 ; U13155.L1 371.12,24.31 v1(371.48,23.96) ; CN2062.99 253.69,73.85 v1(253.31,73.47) ; U13113.BB21 311.37,62.34 v2(311.27,62.44) ; CN2069.57 70.74,19.24 70.89,19.09 71.16,19.09 71.37,19.3 v1(71.37,21.12) ; v4(157.57,146.06) 157.63,146.06 157.96,146.39 v4(157.96,146.41) ; v4(157.57,146.06) 157.26,145.75 U13114.F21 ; v4(157.57,146.06) 157.92,145.71 U13114.F22 157.99,145.71 v4(158.34,145.36) 157.99,145.01 v4(157.96,145.01) 157.92,145.01 v4(157.57,144.66) 157.92,144.31 U13114.H22 ; v2(294.94,56.2) 295.37,55.77 U13113.J7 ; v2(294.94,56.2) 294.66,55.92 U13113.F8 ; v2(294.94,56.2) 294.57,56.57 U13113.G9 ; U41.BP12 264.47,111.76 264.05,111.76 U41.BN12 263.61,111.32 v1(263.61,111.25) 263.61,111.18 U41.BM11 263.28,110.79 v1(263.61,110.46) 263.61,110.39 U41.BM9 263.09,109.87 263.09,109.48 U41.BM8 ; U13135.K3 v4(199.59,141.5) U13135.L3 ; U13135.K3 v4(200.24,141.5) U13135.J3 v4(200.24,142.15) U13135.K3 ; U13114.BJ40 170.56,115.61 ; 170.56,115.61 169.86,115.61 U13114.BJ39 ; U41.AE33 243.15,127.46 v1(243.21,127.46) ; v4(193.74,156.86) 193.74,156.83 194.04,156.53 U13138.A10 ; U13114.BJ33 U13114.BJ32 164.96,115.61 v2(164.61,115.26) ; U13114.BJ33 U13114.BH33 ; U13114.BJ33 U13114.BJ34 v2(166.71,115.26) ; U41.E34 228.2,128.75 v1(228.25,128.75) ; v1(218.13,63.8) 218.69,63.24 CN2063.231 ; U13113.E33 293.75,68.49 v2(293.48,68.22) U13113.D33 293.11,69.26 U13113.D35 293.18,69.78 U13113.D36 ; CN2063.210 223.94,54.79 v1(224.12,54.98) ; U13138.F2 v4(196.99,151.01) U13138.F1 v4(196.99,150.36) 196.99,149.58 v4(197.08,149.49) ; U13113.AF25 v2(303.66,64.74) 303.28,64.35 U13113.AE25 ; U21.T9 v4(347.77,54.79) U21.T8 ; R21296.1 v1(316.53,63.21) ; v4(202.84,136.95) U13135.E10 v4(203.5,137.61) ; v4(202.19,151.66) U13138.P2 ; v1(257.39,128.1) 257.32,128.1 U41.BC33 ; U13141.A5 116.27,127.37 v4(116,127.64) ; U13113.AN11 307.82,57.53 U13113.AP11 308.19,57.39 v2(308.19,57.01) 307.55,57.01 U13113.AN10 ; U13113.N10 297.66,57.34 v2(297.91,57.34) ; CN2063.56 264.44,55.44 v1(262.94,56.94) ; C892.2 176.88,62.29 v1(176.93,62.24) ; CN2070.15 v1(34.24,21.15) ; v1(230.34,109.94) 230.67,109.62 U41.K9 230.68,109.56 230.68,109.03 U41.K8 230.65,108.88 230.65,108.5 230.81,108.34 U41.K7 ; U13113.AL38 306.2,71.36 v2(306.04,71.36) ; v4(129.61,173.83) U13139.F2 ; v2(303.75,71.1) 303.87,70.98 U13113.AG38 ; v4(134.16,173.18) U13139.G10 v4(134.81,172.53) ; U41.BT26 U41.BR26 265.24,122.74 v1(264.91,123.06) 264.91,122.99 U41.BP26 ; CN2063.39 268.69,62.97 v1(267.81,63.85) ; U13114.BJ39 U13114.BH39 ; U13113.AN39 307.45,71.56 v2(307.11,71.21) ; U13114.BC8 147.85,119.81 v2(147.66,120.01) 146.96,120.01 U13114.BC6 ; U41.BM8 263.39,109.28 263.65,109.54 263.65,109.78 U41.BN9 264.26,110.39 v1(264.26,110.46) ; U41.BM8 U41.BM7 U41.BN7 U41.BP7 264.58,108.56 v1(264.91,108.89) 265.24,108.56 U41.BR7 ; v1(257.39,128.76) 257.32,128.76 U41.BC34 ; v1(235.02,64.41) 234.89,64.41 234.44,64.86 CN2062.168 ; v2(154.11,115.96) U13114.BJ17 ; CN2070.3 31.24,20.99 v1(31.08,21.15) 30.74,20.81 CN2070.1 ; v4(201.89,160.66) v4(201.89,160.08) 201.89,159.81 v4(201.62,159.53) U13138.M14 ; v1(254.74,107.36) 254.86,107.36 U41.BA6 ; v1(325.24,57.7) 325.22,57.73 C94808.2 ; U13114.BG31 164.26,117.01 v2(164.61,117.36) v2(163.91,118.06) U13114.BE30 ; U13139.R10 v4(134.81,167.33) 135.14,167.01 U13139.T11 v4(135.46,166.68) ; CN2063.201 226.18,63.08 v1(225.22,64.05) ; v2(151.31,119.46) 151.66,119.81 U13114.BC13 ; U13114.BL34 166.36,114.91 v2(166.71,115.26) ; v2(162.51,115.26) 162.16,114.91 U13114.BL28 ; v2(162.51,115.26) 162.86,115.61 U13114.BJ29 U13114.BJ30 163.91,115.96 163.91,115.96 ; v4(201.45,114.37) 201.63,114.55 201.63,114.77 v4(201.32,115.08) 201.22,115.18 U13136.M1 ; U13114.C5 146.03,147.81 v4(145.71,148.14) 146.06,148.49 U13114.B5 ; v4(148.31,178.01) 148,177.71 v4(148,177.18) 148.23,176.96 U13140.W12 ; CN2062.72 260.44,65.41 259.48,64.46 v1(258.95,64.46) ; v1(235.07,124.55) 234.95,124.68 U41.R29 U41.R30 ; U41.K38 231.01,131.15 v1(230.63,131.53) ; v4(116.16,146.73) 116.47,146.42 U13142.W10 ; U13138.F13 v4(197.64,158.81) 197.32,159.13 U13138.F14 197.19,159.26 v4(197.19,159.61) ; C94649.2 334.05,79.08 v1(334.23,79.26) ; v1(45.36,19.52) 45.36,19.03 45.28,18.95 44.92,18.95 44.74,19.13 CN2070.57 ; U41.AC1 241.25,104.05 v1(241.36,104.05) ; CN18.B12 380.79,40.63 v4(380.74,40.58) 380.61,40.58 380.32,40.87 CN18.A1 ; CN2063.188 229.44,55.35 v1(230.37,56.28) ; U41.M6 232.53,107.66 v1(232.88,107.3) ; v1(260.8,64.89) 261.44,65.52 CN2062.68 ; U13113.AL19 306.32,61.59 v2(306.6,61.31) 306.87,61.58 U13113.AM19 ; v1(374.13,5.14) U13152.18 ; v4(193.42,121.73) 193.67,121.48 U13136.A10 ; v1(258.98,107.3) 258.85,107.17 258.68,107.17 258.51,107.01 U41.BE5 ; CN2070.27 v1(37.24,21.18) ; 149.61,147.9 149.61,148.46 U13114.B10 ; 149.61,147.9 v4(149.17,147.46) 149.52,147.11 U13114.D10 149.59,147.11 v4(149.94,147.46) 149.61,147.8 149.61,147.9 ; U41.BK18 262.37,115.98 262.95,115.98 v1(262.96,115.97) 262.96,116.04 U41.BM18 ; CN2068.69 v1(59.18,57.25) ; U13113.L12 296.76,58.3 U13113.L13 296.76,58.57 296.46,58.86 v2(296.46,58.99) ; v4(202.19,116.6) U13136.P2 v4(202.84,115.95) 202.52,115.63 U13136.P1 v4(202.52,115.15) ; U41.BA9 255.02,109.95 v1(254.93,109.95) ; v1(41.55,26.36) 41.03,26.36 C95943.1 41.01,25.67 v1(41.55,25.67) ; v2(166.71,115.26) 167.06,115.61 U13114.BJ35 U13114.BJ36 167.76,115.61 168.11,115.96 ; U13114.K34 166.39,142.91 v4(166.74,143.26) ; v4(170.56,146.41) 170.71,146.26 170.71,145.86 U13114.F40 170.59,145.71 170.87,145.43 v4(170.94,145.36) 170.59,145.01 v4(170.56,145.01) 170.52,145.01 v4(170.17,144.66) 170.52,144.31 U13114.H40 170.59,144.31 v4(170.94,143.96) 170.78,143.79 170.74,143.79 v4(170.56,143.61) 170.69,143.49 170.72,143.49 v4(170.94,143.26) 170.59,142.91 U13114.K40 ; CN2063.172 233.44,55.81 v1(232.58,56.66) ; v4(174.76,126.11) 174.76,126.06 v4(174.41,125.71) 174.06,126.06 U13114.AP45 ; v4(149.86,175.8) U13140.U10 ; U13136.B14 194.72,124.08 v4(194.39,123.75) U13136.B13 ; C802.1 268.5,131.79 268.12,132.17 v1(268.12,132.3) 268.37,132.55 R542.1 ; U13114.P51 178.29,140.11 v4(178.61,140.43) ; v2(293.92,63.74) 293.34,63.74 293.11,63.97 U13113.D24 293.11,64.72 U13113.D25 293.18,65.24 U13113.D27 293.09,65.51 292.78,65.82 U13113.C28 ; v4(148.86,128.21) 148.64,127.99 148.64,127.95 v4(148.51,127.83) ; v4(148.86,128.21) 149.21,128.56 v4(149.21,128.6) 149.56,128.25 U13114.AL10 149.56,128.18 v4(149.21,127.83) ; v4(148.86,128.21) 148.86,128.18 v4(149.21,127.83) ; U21.J5 v4(351.02,56.09) U21.L5 350.51,56.23 350.23,56.23 U21.M5 ; U13140.D14 146.93,167 v4(146.57,166.65) ; v1(243,111.28) 243.29,111.57 U41.AF12 ; U13114.AB2 v4(144.66,134.51) 144.8,134.65 144.8,134.69 v4(145.01,134.9) 145.18,134.72 145.18,134.69 U13114.AB4 ; U13138.E10 v4(196.34,156.86) 196.02,157.18 U13138.D11 v4(195.69,157.51) ; U41.BJ29 261.66,124.9 U41.BK29 ; v1(232.68,77.16) 233.69,76.16 CN2062.171 ; R22195.2 31.64,55.72 31.26,55.34 30.22,55.34 v1(30.09,55.46) ; U41.AH6 245.21,107.66 v1(245.53,107.34) ; U41.AH12 245.1,111.57 v1(244.83,111.29) ; v1(229.31,77.21) 228.18,76.09 CN2062.193 ; v1(222.17,57.73) 220.87,56.43 220.87,54.65 220.94,54.59 CN2063.222 ; v1(230.62,129.41) 230.55,129.41 U41.J36 ; U13113.T2 U13113.T1 298.69,52.43 v1(298.69,52.33) ; CN2063.98 253.93,55.28 253.49,55.72 v1(253.33,55.72) 253.19,55.72 252.8,55.34 252.8,54.8 252.93,54.67 CN2063.102 ; v1(336.64,79.42) 336.64,79.34 336.44,79.14 C94648.2 ; v1(253.45,130.71) 253.38,130.71 U41.AV37 ; v1(257.85,124.26) 258.23,124.26 258.57,124.6 U41.BE29 U41.BE30 ; U13114.AA8 148.19,135.21 v4(148.51,134.9) ; v4(195.04,156.86) U13138.C10 ; U41.AP12 250.01,111.42 250.13,111.42 v1(250.31,111.24) 250.2,111.24 249.88,110.92 U41.AP11 U41.AP10 250,110.13 250.17,110.13 v1(250.37,109.93) 250.18,109.93 U41.AP9 ; U13114.F31 164.22,145.71 v4(163.87,146.06) 164.05,146.24 164.09,146.24 v4(164.26,146.41) ; CN2063.36 v1(269.44,56) ; v1(277.52,64.96) 277.93,65.38 CN2062.2 ; R21120.2 v1(310.05,47.92) ; v2(311.33,58.01) 311.62,58.01 U13113.BB11 ; U13114.H28 162.19,144.31 v4(162.54,144.66) 162.19,145.01 v4(162.16,145.01) ; v1(263.61,118.34) 263.61,118.27 U41.BN20 264.26,117.62 v1(264.26,117.55) 264.09,117.38 264.09,117.35 263.93,117.19 U41.BN19 ; v1(263.61,118.34) 263.28,118.66 U41.BM21 ; v1(263.61,118.34) 263.93,118.66 U41.BN21 ; CN2063.31 270.69,62.94 v1(271.11,63.36) 271.69,62.79 CN2063.27 ; v2(310.01,69.13) 309.77,68.88 U13113.AV33 ; CN2063.214 222.94,55.51 v1(222.14,56.3) ; v4(147.46,130.31) 147.46,130.35 v4(147.11,130.7) 146.76,130.35 U13114.AH6 146.76,130.28 v4(146.41,129.93) 146.2,130.14 146.2,130.17 v4(146.06,130.31) ; C94956.2 22.23,15.03 v1(22.4,15.03) 22.86,15.49 R21469.2 ; 168.11,115.96 U13114.BH36 ; U41.D16 226.88,114.69 226.88,114.56 U41.C15 226.23,113.91 v1(226.23,113.84) ; v1(247.29,123.92) 246.76,124.45 U41.AK29 U41.AK30 ; U41.B37 225.81,130.46 U41.A37 v1(225.26,131.16) ; v1(251,123.89) 251.2,123.89 251.61,124.3 251.61,125.01 U41.AT29 U41.AT30 ; v4(175.81,126.52) 175.46,126.17 U13114.AP47 ; U13138.K14 200.16,159.37 v4(200.16,159.55) ; C94724.2 v1(259.96,170.43) ; v4(162.54,147.45) 162.86,147.76 U13114.C29 ; v4(160.06,147.81) U13114.B25 ; CN2062.102 252.93,65.44 v1(253.33,65.04) ; v4(178.61,140.43) 178.61,140.49 178.28,140.81 U13114.N51 ; U13114.A29 162.86,151.22 v4(162.2,151.88) ; R560.1 269.36,129.22 v1(269.36,129.23) 269.72,129.23 R564.1 ; v4(176.16,130.31) 176.16,130.35 v4(176.51,130.7) 176.86,130.35 U13114.AH49 176.86,130.28 v4(177.21,129.93) ; v4(118.87,151.3) U13142.T2 v4(118.22,151.95) U13142.T1 118.55,152.77 v4(118.5,152.82) ; U13113.V18 300.56,60.87 v2(300.56,60.86) ; Q42.1 174.41,69.75 v1(174.37,69.79) ; R20850.1 341.27,56.99 341.02,57.24 v1(340.63,57.24) ; v1(219.94,54.88) CN2063.226 ; U21.D11 v4(353.62,54.14) U21.E11 ; v1(229.48,120.14) 229.86,119.76 U41.H22 U41.J22 v1(231.08,119.75) ; v1(265.81,64.53) 266.44,65.16 CN2062.48 ; v4(134.81,166.03) U13139.U10 ; v1(274.16,77.11) 273.81,77.11 272.69,75.98 CN2062.23 ; v4(196.34,135.65) U13135.T13 ; v4(193.74,140.2) U13135.W5 v4(194.39,140.85) ; v4(149.21,129.93) 148.86,130.28 v4(148.86,130.31) ; v4(149.21,129.93) 149.56,130.28 U13114.AH10 149.56,130.35 v4(149.21,130.7) 149.21,130.64 148.88,130.31 v4(148.86,130.31) ; v4(149.21,129.93) 148.89,129.61 U13114.AJ9 ; v1(274.31,57.58) 274.93,56.96 CN2063.14 ; v1(289.53,73.3) 289.8,73.03 U13113.A42 ; U41.AW12 253.69,111.57 v1(253.98,111.28) 254.27,111.57 U41.AY12 ; CN2063.223 220.69,63.12 v1(219.93,63.87) ; v2(147.81,125.76) 148.16,126.11 U13114.AP8 U13114.AN8 ; v2(308.17,55.09) 308.28,55.09 U13113.AR5 ; v2(308.17,55.09) 308.1,55.03 U13113.AP4 308.01,54.15 U13113.AN4 307.31,54.4 v2(307.05,54.4) 306.81,54.4 U13113.AL4 306.24,54.16 306.16,54.24 U13113.AK4 ; v2(308.17,55.09) 308.17,55.21 308.53,55.57 U13113.AR7 v2(308.16,55.96) 308.59,56.38 U13113.AR9 ; Y1003.4 352.51,63.91 351.81,63.21 350.59,63.21 350.39,63.42 350.39,64.58 350.54,64.74 350.81,64.74 Y1003.2 ; U41.BN34 264.26,127.85 v1(264.26,127.78) 264.26,127.72 U41.BP33 264.58,127.25 U41.BN31 ; U13113.AE4 303.46,54.15 U13113.AD4 302.78,54.15 v2(302.53,54.39) ; v1(273.07,64.33) 273.93,65.19 CN2062.18 ; v2(294.73,59.04) 294.35,59.04 293.72,58.41 U13113.E13 293.32,58 293.21,58 U13113.D12 293.11,57.89 U13113.D10 293.14,57.23 v2(293.49,56.88) ; v1(219.94,65.27) CN2062.226 ; v1(353.16,65.85) 353.38,65.62 v1(353.38,64.35) ; v2(170.91,117.36) 170.56,117.01 U13114.BG40 ; U13135.F13 v4(202.84,135) U13135.F14 ; U21.T13 v4(347.77,52.19) U21.T15 ; U41.G8 229.16,108.21 v1(229.21,108.16) ; v4(200.07,144.08) 199.96,143.97 199.96,143.17 U13135.K1 ; U13135.K14 199.92,134.48 199.89,134.46 199.89,134.08 200.05,133.93 200.05,133.21 v4(199.8,132.96) ; v1(213.61,77.26) 214.69,76.18 CN2062.247 ; U13113.AV24 309.83,64.23 v2(309.31,64.75) ; v1(34.08,24.2) 34.08,24.3 34.47,24.69 C94938.1 ; v4(195.69,136.3) U13135.T11 v4(196.34,136.95) U13135.R10 ; v4(160.76,149.74) U13114.A26 ; U13114.N49 176.86,140.78 v4(177.21,140.43) ; v4(173.36,142.91) 173.01,142.56 v4(173.01,142.5) ; v4(173.36,142.91) 173.36,142.97 v4(173.7,143.31) 173.7,143.25 174.05,142.9 U13114.K45 174.25,143.1 174.25,143.17 v4(174.4,143.31) 174.76,142.95 v4(174.76,142.91) 174.76,142.88 v4(175.11,142.53) 175.46,142.88 U13114.K47 ; v4(173.36,142.91) v4(172.66,143.61) 172.79,143.74 172.79,144.18 U13114.H43 172.72,144.31 v4(173.06,144.65) 173,144.65 172.66,144.99 v4(172.66,145.01) ; v4(148.86,134.51) 148.74,134.39 148.74,134.35 v4(148.51,134.13) 148.36,134.27 148.36,134.31 U13114.AB8 ; v4(148.86,134.51) 148.86,134.55 v4(148.51,134.9) ; U13141.D11 v4(118.22,130.95) U13141.C10 ; U41.AW30 U41.AW29 253.85,124.67 v1(254.06,124.45) ; CN2062.1 278.19,75.78 277.87,76.09 277.21,76.09 v1(277.19,76.06) CN2062.5 ; v1(222.19,77.03) 223.18,76.04 CN2062.213 ; v4(149.21,136.23) 149.56,136.58 U13114.W10 149.56,136.65 v4(149.21,137) 148.86,136.65 v4(148.86,136.61) 148.86,136.58 v4(149.21,136.23) ; U41.BT3 266.25,105.7 v1(266.45,105.9) ; v4(149.21,127.83) 148.89,127.51 U13114.AM9 148.82,127.51 v4(148.51,127.83) ; v1(218.13,65.22) 217.94,65.41 CN2062.234 ; CN2063.196 227.43,54.87 v1(227.22,55.08) ; v1(236.13,128.76) 236.06,128.76 U41.T34 ; v2(157.61,116.66) 157.26,116.31 U13114.BH21 ; v4(201.32,150.13) 201.32,150.58 U13138.M1 ; v4(205.44,122.45) U13136.W12 205.79,122.78 206.14,123.12 v4(206.2,123.12) ; v4(200.24,122.45) U13136.L12 ; U13113.AB7 301.73,55.39 v2(301.39,55.74) ; v4(166.74,143.96) 166.39,144.31 U13114.H34 166.44,144.39 166.44,144.93 v4(166.36,145.01) ; v4(205.57,149.45) 205.57,150.23 v4(205.47,150.33) U13138.V1 v4(205.44,151.01) U13138.V2 v4(204.79,151.66) ; CN2062.205 225.18,75.79 v1(223.97,77) ; U13138.H14 198.31,159.44 v4(198.31,159.56) ; U13114.BE30 163.91,118.76 v2(163.91,118.76) U13114.BE31 ; U13114.BE30 U13114.BD29 v2(162.51,119.46) U13114.BC28 ; C94809.2 321.86,46.63 v1(322.07,46.83) ; CN2062.239 216.69,75.74 216.78,75.83 216.78,76.51 v1(216.26,77.03) ; U13113.AN8 307.11,55.93 v2(307.11,55.93) 307.49,55.54 U13113.AN7 ; v1(229.21,108.16) 229.34,108.3 U41.J7 ; v1(229.21,108.16) 229.2,108.16 U41.G6 U41.G5 229.2,106.97 229.12,106.89 229.12,106.44 U41.G4 229.52,106.04 v1(229.61,106.04) 229.69,106.04 U41.J4 ; U21.V9 v4(347.12,54.79) ; v4(204.79,156.86) U13138.U10 204.47,156.53 v4(204.81,156.19) ; U13114.BL22 157.96,114.91 ; 157.96,114.91 158.66,115.61 U13114.BJ23 U13114.BJ24 U13114.BH24 159.36,116.31 v2(159.71,116.66) ; U41.BP34 264.91,127.85 v1(264.91,127.78) 265.24,128.11 U41.BR34 ; U41.D22 226.92,120.03 226.87,120.03 226.56,120.34 U41.C23 226.23,120.86 v1(226.23,120.93) ; U13155.F7 U13155.F8 ; U13155.F7 U13155.G7 ; v1(255.02,128.76) 254.96,128.76 U41.AY34 ; v1(258.8,76.27) 259.18,75.88 CN2062.77 ; U21.N12 v4(349.72,53.49) U21.M12 ; U13140.J12 v4(148.55,170.58) ; R20925.2 334.32,68.38 334.84,67.86 v1(334.84,67.81) ; U21.V5 v4(347.77,56.09) U21.T5 ; U13140.D11 148.88,167.01 v4(149.2,167.33) U13140.E10 ; U41.BK29 262.2,125.03 U41.BL29 ; U41.BK29 261.99,125.35 U41.BJ30 261.72,125.89 U41.BJ31 261.79,126.48 v1(262.11,126.81) 262.05,126.81 U41.BJ32 ; CN2062.181 231.18,76.45 v1(230.53,77.11) ; 297.84,60.26 U13113.P17 ; CN2068.30 v1(51.41,67) ; U41.AL14 247.01,112.98 247.01,114.34 v1(247.29,114.62) ; U13114.T47 175.46,138.75 v4(175.81,139.1) 176.16,138.75 v4(176.16,138.71) ; U21.T16 348.1,51.22 v4(347.78,51.54) 347.45,51.86 U21.V15 ; v4(131.56,167.98) 131.24,167.66 U13139.R5 ; U13138.D14 196.01,159.14 ; 196.01,159.14 v4(196.01,159.59) ; 196.01,159.14 196.02,159.13 U13138.D13 v4(196.34,158.16) ; v4(204.79,116.6) U13136.V2 205.44,115.95 v4(205.44,115.95) U13136.V1 v4(205.47,115.28) 205.57,115.18 v4(205.57,114.4) ; v4(196.01,124.6) 196.02,124.58 U13136.D14 195.89,123.95 195.89,123.55 U13136.D13 v4(196.34,123.1) ; v1(241.36,104.7) 241.25,104.7 U41.AC2 ; v1(271.09,65.07) 270.93,65.22 CN2062.30 ; C94633.2 173.02,71.42 v1(173.12,71.52) ; v1(265.81,76.24) 265.69,76.12 CN2062.51 ; CN2063.69 261.19,63.03 v1(260.78,63.44) ; CN2069.73 74.74,20.9 v1(74.47,21.17) 74.24,20.95 CN2069.71 ; U13114.AB8 148.16,134.55 v4(148.51,134.9) ; C95834.1 129.78,115.09 129.97,115.28 R21573.1 ; v4(198.29,140.85) U13135.N5 ; U41.BN18 263.93,116.3 v1(264.26,115.97) 264.26,116.04 U41.BP18 ; R21121.2 309.16,47.97 v1(309.11,47.92) ; C94718.2 260.42,172.3 v1(260.75,172.64) ; v2(304.92,57.12) 305.02,57.02 U13113.AJ10 ; U13114.BF41 v2(170.91,118.06) U13114.BE40 ; CN2063.238 216.94,56.41 v1(216.35,56.99) 216.32,57.02 215.01,57.02 214.83,56.84 214.83,56.07 215.41,55.49 215.41,54.98 v1(215.38,54.96) 215.43,54.91 CN2063.244 ; U13114.AK1 143.22,128.91 v4(142.91,128.6) ; CN2069.21 v1(61.74,21.23) ; CN2062.61 263.19,75.97 v1(262.63,76.52) ; U13135.B13 v4(205.44,135) U13135.B14 205.32,134.48 v4(205.32,134.07) ; U13114.BM3 144.66,113 v2(144.42,112.76) ; U13138.P1 202.52,150.25 v4(202.55,150.22) 202.55,149.95 v4(203.04,149.45) ; 304.3,57.7 U13113.AG11 U13113.AG13 ; U13142.A10 v4(128.62,146.1) ; v4(179.22,136.67) 179.3,136.59 180.48,136.59 v4(180.91,137.02) 181.34,136.59 181.81,136.59 182.14,136.92 v4(182.14,137.02) ; v2(148.51,124.36) 148.16,124.01 U13114.AU8 ; v4(204.79,123.1) U13136.V13 v4(205.44,123.75) 205.12,124.08 U13136.V14 v4(205.44,124.4) 205.36,124.48 205.36,125 v4(205.85,125.49) ; CN2062.44 267.44,65.57 v1(267.76,65.24) ; v1(224.15,56.49) 224.15,56.38 224.94,55.6 CN2063.206 ; U41.G18 228.83,116.27 v1(228.83,116.21) 228.83,116.13 U41.F17 ; U41.G18 228.84,116.92 v1(228.84,116.99) 228.51,117.32 U41.F19 ; U41.AW2 253.58,104.94 253.69,104.94 v1(253.89,104.73) 253.56,104.4 U41.AW1 ; U41.BT4 v1(266.56,107.1) 266.43,107.22 U41.BT5 ; CN2062.218 221.94,65.48 v1(222.14,65.27) ; U13113.BB34 311.39,69.16 v2(311.3,69.25) ; v1(265.88,77.03) 266.69,76.23 CN2062.47 ; U13114.AT51 178.29,124.71 v4(178.61,124.4) ; U13138.L3 v4(200.24,152.31) U13138.K3 ; v4(175.11,128.6) 175.42,128.91 U13114.AK47 ; v4(175.11,128.6) 174.7,128.19 174.7,128.1 v4(174.41,127.81) 174.06,128.16 U13114.AL45 ; U41.N2 233.52,104.89 233.64,104.89 v1(233.83,104.7) 233.53,104.4 U41.N1 ; v2(145.01,124.36) U13114.AU4 ; v4(146.35,143.24) 146.68,142.91 U13114.K6 ; U41.BH4 261.16,106.21 261.24,106.21 v1(261.45,106) 261.28,105.83 261.15,105.83 U41.BH3 ; U41.AC38 240.92,131.36 v1(240.86,131.36) ; U13114.D19 155.89,147.11 v4(156.24,147.46) 156.01,147.7 155.97,147.7 v4(155.86,147.81) U13114.B19 ; v4(196.99,142.15) U13135.P2 v4(197.64,142.8) 197.32,143.13 U13135.P1 v4(196.99,143.45) ; v4(194.37,143.48) U13135.V1 ; U41.D14 227.21,113.31 U41.C13 226.23,112.33 v1(226.23,112.27) ; U41.F11 228.51,111.22 U41.G12 229.48,112.19 v1(229.48,112.26) ; U13142.L12 v4(122.12,145.45) ; U41.AB33 240.78,127.46 v1(240.85,127.46) ; U13140.B2 v4(155.05,165.38) U13140.B1 ; v4(146.42,176.45) 146.37,176.5 C96145.2 ; U13114.BC4 v2(145.01,120.16) 144.66,119.81 U13114.BC2 ; CN2063.167 234.69,62.73 233.78,63.64 232.89,63.64 v1(232.66,63.87) 233.44,64.65 CN2062.172 ; U13114.AU51 178.26,124.05 v4(178.61,124.4) ; U41.AG11 244.27,110.81 244.09,110.81 v1(243.93,110.65) 244.31,110.27 U41.AG10 ; v1(255.82,130.71) 255.49,130.38 U41.BA37 ; U13136.F2 v4(196.99,115.95) 197.32,115.63 U13136.F1 197.32,115.21 v4(197.13,115.02) 197.13,114.4 v4(197.12,114.39) ; U41.G16 228.79,114.65 228.79,114.51 U41.F15 ; U41.Y38 239.21,131.36 v1(239.28,131.36) ; v4(127.32,130.95) U13141.U10 ; v1(251.41,104.03) 251.32,104.03 250.96,104.39 U41.AR1 ; CN2062.86 256.93,65.2 v1(257.63,64.51) ; v4(204.14,142.15) 203.82,142.48 U13135.D2 v4(203.49,142.8) U13135.D1 203.82,143.57 v4(203.84,143.59) 203.84,144.05 v4(203.59,144.3) ; U13114.AH8 148.16,130.35 v4(148.51,130.7) 148.86,130.35 v4(148.86,130.31) ; v1(248.73,131.36) 248.66,131.36 U41.AM38 ; U41.AF4 243.09,106.68 v1(242.98,106.68) ; v4(178.66,148.86) 178.96,148.56 U13114.B52 ; v1(261.29,111.32) 261.04,111.07 260.91,111.07 260.84,110.99 U41.BH11 ; v1(261.29,111.32) 261.04,111.57 U41.BH12 ; v1(261.29,111.32) U41.BJ12 261.98,112.01 U41.BK13 262.51,112.3 U41.BL13 ; U41.BH10 260.82,110.24 260.82,109.73 260.84,109.7 U41.BH9 260.84,109.48 260.83,109.47 260.83,109.07 260.84,109.06 U41.BH8 260.79,108.92 260.79,108.36 U41.BH7 260.84,108.08 261.02,107.9 U41.BH6 260.95,107.66 v1(260.62,107.32) 260.28,107.66 U41.BG6 ; v4(196.99,140.2) U13135.R5 ; U13114.BE13 151.66,118.41 v2(151.31,118.06) ; CN2062.14 274.93,65.36 v1(274.34,64.76) ; U41.AV38 253.38,131.36 v1(253.45,131.36) ; v1(57.81,59.3) 57.81,59.38 58.68,60.25 CN2068.57 ; v4(196.99,134.35) U13135.P14 v4(196.99,135) U13135.P13 ; U13114.BG34 166.36,117.01 v2(166.71,117.36) v2(166.01,118.06) U13114.BE33 U13114.BD32 v2(164.61,119.46) U13114.BC31 ; U41.AU6 252.74,107.66 v1(253.09,108.01) 252.78,108.32 U41.AU7 252.46,108.32 v1(252.17,108.02) U41.AT6 ; v4(204.79,121.8) U13136.U10 v4(204.81,121.14) ; v1(242.09,110.61) 242.02,110.68 241.87,110.68 U41.AD11 ; v4(181.66,146.17) 181.66,146.35 181.02,146.98 180.23,146.98 U13114.F52 U13114.E51 178.58,146.73 v4(178.63,146.73) ; U41.U37 236.62,130.48 236.62,130.94 U41.U38 236.5,131.03 v1(236.08,131.45) ; v1(219.45,76.14) 219.69,75.9 CN2062.227 ; CN2063.5 277.19,63.06 v1(277.54,63.42) ; U41.N6 233.36,108.27 U41.N7 233.32,108.4 233.32,108.88 U41.N8 233.4,109.12 233.38,109.15 233.38,109.55 233.4,109.57 U41.N9 U41.N10 ; U41.N6 233.24,107.66 v1(232.88,107.3) ; v4(117.58,128.3) 117.73,128.15 117.73,127.54 U13141.C5 v4(117.57,127.05) ; v1(377.35,11.81) 377.13,11.58 U13152.1 ; v4(178.61,124.4) 178.92,124.71 U13114.AT52 ; v1(258.92,65.24) 258.93,65.26 CN2062.78 ; CN2063.247 214.69,63.51 214.35,63.85 v1(213.61,63.85) ; U13114.B2 143.91,148.51 v4(143.58,148.84) U13114.A2 ; U13140.D1 155.37,167.01 v4(155.05,166.68) U13140.D2 ; v1(43.38,21.15) 43.24,21.01 CN2070.51 ; v4(164.26,147.81) 164.29,147.81 v4(164.64,147.46) 164.29,147.11 U13114.D31 164.22,147.11 v4(163.87,147.46) 163.56,147.15 U13114.D30 ; v4(203.52,121.13) U13136.R10 v4(202.82,121.13) ; U41.BN30 264.26,125.49 v1(264.26,125.42) 264.26,125.35 U41.BN29 ; U13113.C4 292.12,54.45 292.12,55.03 U13113.B6 ; U13139.T1 v4(128.27,166.64) ; U21.Y9 346.15,54.46 v4(346.47,54.79) U21.W9 ; v4(152.4,167.98) 152.45,167.98 U13140.E5 ; U13114.D16 153.79,147.11 v4(154.14,147.46) 153.94,147.67 153.9,147.67 v4(153.76,147.81) U13114.B16 ; v1(250.3,128.76) 250.21,128.76 249.91,128.46 U41.AP34 ; v1(268.57,127.19) 268.96,126.81 C96031.2 ; v1(226.23,117.78) 226.23,117.71 U41.C19 226.56,117.14 227.1,116.6 U41.D18 ; v1(316.83,44.95) 316.95,45.06 U13098.3 ; U41.AP33 250.23,128.1 v1(250.3,128.1) ; U41.L33 232.12,128.1 v1(232.19,128.1) ; v1(226.23,115.42) 226.23,115.48 U41.C17 ; v4(197.64,136.95) U13135.N10 ; R67224.1 v1(316.73,61.69) ; v1(224.84,129.28) 225.23,129.68 U41.A36 ; v2(301.26,70.83) 301.37,70.93 301.79,70.93 U13113.AB38 ; v4(206.2,153.69) 206.15,153.64 206.13,153.64 U13138.W5 ; U13114.K16 153.79,142.91 v4(154.14,143.26) 154.46,143.58 U13114.J17 ; U41.BM25 263.64,121.52 263.64,121.38 U41.BN24 263.61,120.77 v1(263.61,120.7) 263.28,120.37 U41.BM23 ; U13114.BJ14 152.16,115.41 151.86,115.41 U13114.BJ13 v2(151.31,115.96) ; v1(229.04,128.76) 229.08,128.76 229.41,129.08 U41.H35 ; U13113.T42 299.05,72.76 v2(299.05,72.25) ; v1(259.75,128.1) 259.43,127.78 U41.BF33 ; v1(261.28,49.65) 260.9,50.03 U13093.7 ; v1(237.7,128.76) 237.77,128.76 U41.W34 ; CN2063.93 255.18,63.39 v1(255.7,63.9) ; C95529.1 v1(368.45,56.08) ; U41.BN4 263.47,106.93 U41.BM5 263.14,106.69 v1(263.14,106.47) 263.39,106.23 U41.BM3 263.31,105.94 U41.BM2 263.59,105.37 U41.BN2 ; v4(173.01,132.8) 173.32,133.11 U13114.AD44 173.39,133.11 v4(173.71,132.8) ; v2(149.17,118.1) 149.17,118.1 149.48,118.41 U13114.BE10 ; v4(204.79,137.6) U13135.C10 v4(204.14,136.95) U13135.D11 ; v1(251.09,130.71) 250.77,130.38 U41.AR37 ; U13114.B34 166.32,148.51 v4(165.97,148.16) 165.66,147.85 U13114.C33 ; CN2063.180 231.44,54.91 v1(231.41,54.93) ; R22194.2 31.8,54.55 32.23,54.12 v1(32.46,54.12) v1(33.12,54.12) ; U41.BH14 260.46,113.21 v1(260.37,113.21) 260.26,113.21 U41.BG14 ; v4(206.09,156.21) 205.77,156.53 U13138.W10 ; v4(142.91,128.6) 142.49,128.18 142.08,128.18 v4(141.64,128.62) 141.2,128.18 140.81,128.18 v4(140.37,128.62) 141.81,130.06 143.47,130.06 v4(143.61,129.93) ; U41.T33 236.06,128.1 v1(236.13,128.1) ; R21119.2 v1(310.99,47.92) ; CN2068.18 51.96,70 v1(51.66,70.3) ; v1(276.45,56.03) 276.93,55.54 CN2063.6 ; C94543.2 329.89,52.67 v1(329.71,52.49) ; CN2042.20 348.85,79.9 v1(348.82,79.87) ; U13113.AW19 310.53,61.8 310.05,61.31 v2(310.05,61.26) 310.05,60.74 U13113.AV17 ; U13141.V2 v4(127.97,125.1) U13141.V1 ; v4(168.84,144.66) 168.72,144.79 168.66,144.79 168.46,144.99 v4(168.46,145.01) ; v4(168.84,144.66) 169.16,144.98 U13114.G38 ; v2(300.15,54.56) 300.33,54.56 U13113.W4 301.19,54.15 U13113.AA4 ; CN2062.40 268.44,65.16 v1(267.79,64.51) ; v2(164.61,115.26) 164.26,114.91 U13114.BL31 ; v2(164.61,115.26) U13114.BJ31 163.91,115.96 ; U13142.F14 v4(125.37,143.5) ; U13136.K14 200.15,124.31 v4(200.15,124.59) ; CN2062.209 224.18,75.98 v1(224,76.17) ; v4(140.91,130.91) 140.5,130.49 140,130.49 139.68,130.81 v4(139.68,130.93) 139.68,130.96 140.43,131.71 U13114.AF1 ; v1(263.88,63.29) 264.19,62.98 CN2063.57 ; CN2062.10 275.93,65.63 v1(276.4,65.17) ; U13114.BC25 v2(160.41,119.46) U13114.BD26 ; U13114.AA49 176.89,135.21 v4(177.21,134.9) ; U13114.D43 172.68,147.11 v4(173.03,147.45) 172.67,147.81 v4(172.66,147.81) 172.66,147.81 U13114.B43 ; v2(309.42,59.02) 309.13,59.3 U13113.AT15 ; v4(197.64,117.9) U13136.G5 ; U13114.G49 176.86,144.97 v4(177.21,144.61) 177.39,144.79 177.39,144.85 v4(177.56,145.01) ; U41.BH5 261.35,107.34 v1(261.45,107.34) 261.77,107.66 U41.BK6 261.9,107.66 262,107.56 262.4,107.56 262.49,107.66 U41.BL6 263.41,107.66 U41.BM6 ; v1(251.35,76.17) 251.69,75.83 CN2062.107 ; v1(274.29,64) 273.69,63.4 CN2063.19 ; v1(268.42,123.33) 268.55,123.2 R20815.1 ; CN2062.192 228.43,65.1 v1(229.13,64.41) ; v1(262.63,64.51) 263.44,65.31 CN2062.60 ; U13140.T2 v4(155.05,175.13) U13140.T1 ; U13114.BJ19 155.86,115.59 v2(156.2,115.25) 156.56,115.6 U13114.BJ20 ; v1(260.71,119.52) U41.BJ22 U41.BK22 ; U41.AB34 240.79,128.1 v1(240.85,128.1) ; CN2063.103 252.69,62.82 v1(253.31,63.44) 253.69,63.06 CN2063.99 ; v4(148.53,164.65) 148.55,164.67 149.13,164.67 U13140.A10 ; U41.C9 U41.B9 ; U13114.BH15 153.07,116.31 v2(153.42,115.96) 153.76,115.62 U13114.BJ16 ; v4(194.39,118.55) U13136.A5 ; v4(146.57,169.25) 146.93,169.6 U13140.H14 ; U13114.BG10 v2(149.91,116.66) ; v4(198.94,116.6) U13136.J3 ; v2(306.6,60.11) 306.6,59.72 U13113.AM15 ; v1(16.12,48.35) 16.2,48.43 U13123.3 ; v4(118.87,149.35) 119.2,149.67 U13142.R5 ; v1(245.53,107.34) 245.74,107.13 245.81,107.13 U41.AJ5 ; v1(245.53,107.34) 245.85,107.66 U41.AJ6 ; v2(145.71,121.56) U13114.AY4 ; v2(151.31,116.66) 151.66,117.01 U13114.BG13 ; U41.W33 237.78,128.1 v1(237.7,128.1) ; U13127.9 v1(368.51,59.21) ; v2(306.06,57.4) 306.31,57.4 306.58,57.13 U13113.AL10 ; U13123.8 U13123.9 19.07,48.83 19.23,48.99 v1(19.45,48.99) ; v4(201.91,118.83) 201.87,118.78 U13136.N5 ; CN2062.98 253.93,68.28 253.49,68.72 v1(253.33,68.72) ; U13135.A5 206.21,140.53 v4(206.47,140.27) ; U41.AC4 241.06,106.2 241.16,106.2 v1(241.36,106) 241.19,105.83 241.03,105.83 U41.AC3 ; U21.W6 346.8,55.76 v4(347.12,56.09) U21.W5 ; v1(248.73,130.71) 248.66,130.71 U41.AM37 ; U13136.H1 198.51,115.52 198.51,115.04 198.53,115.02 v4(198.84,114.71) ; U13114.N45 174.06,140.85 v4(173.71,141.2) 173.36,140.85 v4(173.36,140.81) 173.01,141.16 v4(173.01,141.2) 172.66,140.85 U13114.N43 ; CN2068.24 v1(51.55,68.5) ; v2(296,71.87) 296.33,72.19 U13113.L41 296.48,72.45 U13113.M42 ; v1(332.3,79.53) 332.25,79.49 C94650.2 ; v1(273.07,65.14) 272.93,65.28 CN2062.22 ; v4(155.86,146.41) 155.69,146.24 155.65,146.24 v4(155.47,146.06) 155.82,145.71 U13114.F19 ; CN2068.33 59.53,66.25 59.49,66.21 58.59,66.21 57.86,65.47 v1(57.86,65.24) ; CN2069.27 v1(63.24,21.17) ; C95534.2 360.93,54.78 v1(360.95,54.8) ; U13114.BH30 163.91,115.96 ; U13142.L3 121.8,150.97 v4(122.12,150.65) U13142.K3 ; U41.BD37 257.46,130.71 v1(257.39,130.71) 257.71,131.03 U41.BD38 ; U41.D30 226.88,125.72 v1(226.88,125.65) 226.56,125.33 U41.C29 ; CN2063.235 217.69,62.72 v1(218.07,63.11) ; C95688.2 197.01,132.79 v4(196.82,132.97) ; U13114.BG19 155.86,117.01 v2(156.21,117.36) ; v1(230.44,65.26) CN2062.184 ; v1(226.23,124.08) 226.23,124.01 U41.C27 226.56,123.55 U41.D26 ; v4(195.69,134.35) U13135.T14 ; v4(142.91,148.16) U13114.B1 ; v4(142.91,148.16) U13114.C1 ; v1(259.75,130.71) 260.08,131.03 U41.BG38 ; v1(253.04,109.93) 252.92,109.93 U41.AU9 ; v1(235.25,56.94) 234.44,56.12 CN2063.168 ; v1(243.01,107.33) 242.68,107.66 U41.AE6 ; U13136.K1 199.87,115.58 199.87,115.33 199.81,115.28 v4(199.81,114.98) ; U13113.AF26 v2(304.44,64.73) ; v2(304.44,64.73) U13113.AH25 ; v1(219.44,76.95) 220.69,75.71 CN2062.223 ; v1(232.88,107.3) 233.03,107.15 233.21,107.15 U41.N5 ; v4(146.57,167.95) 146.93,168.3 U13140.F14 ; CN2063.227 219.69,62.99 v1(219.88,63.19) ; CN2063.81 258.18,62.81 257.83,63.16 v1(257.73,63.16) ; U21.R5 v4(349.07,56.09) U21.N5 ; U13113.AH23 U13113.AF23 v2(303.67,63.95) ; v1(266.34,130.04) 266.09,129.79 265.96,129.79 U41.BT36 265.77,129.6 U41.BR36 ; U13114.R52 179.07,139.41 v4(179.36,139.12) ; U13136.H14 198.31,124.38 v4(198.31,124.57) ; U13139.U5 v4(131.56,166.03) ; v4(122.77,145.45) U13142.J12 ; v4(198.49,143.59) 198.49,143.25 U13135.M1 ; U41.AF1 243.42,104.36 243.1,104.05 v1(242.99,104.05) ; U41.BE3 258.68,105.53 258.8,105.53 v1(258.97,105.35) 258.79,105.17 258.62,105.17 U41.BE2 ; v4(127.97,152.7) 127.97,152.6 U13142.B1 v4(127.97,151.95) U13142.B2 v4(127.32,151.3) ; U13114.W2 v4(144.66,136.61) 144.8,136.75 144.8,136.79 v4(145.01,137) 145.36,136.65 U13114.W4 ; v1(49.32,57.62) 48.81,57.12 v1(48.53,57.12) R22188.2 ; U41.Y13 U41.Y14 ; v1(267.96,157.27) 268.32,157.63 PC5588.2 ; U13136.E5 v4(196.99,117.9) ; U41.BT32 v1(266.43,127.33) ; U13114.BF4 145.19,117.54 144.83,117.54 v2(144.31,118.06) ; v1(219.44,77.72) 218.69,76.96 CN2062.231 ; v4(177.21,134.9) 176.86,134.55 U13114.AB49 176.86,134.48 v4(177.21,134.13) 177.56,134.48 v4(177.56,134.51) 177.56,134.55 v4(177.21,134.9) ; CN2068.45 58.53,63.25 57.68,62.4 v1(57.68,62.17) ; v1(226.23,119.35) 226.23,119.28 U41.C21 226.56,118.77 226.92,118.41 226.97,118.41 U41.D20 ; U13140.W10 v4(149.85,177.08) 149.85,177.95 v4(149.91,178.01) ; CN2063.72 260.44,54.54 260.24,54.73 260.24,55.11 260.76,55.62 v1(260.93,55.62) 261.18,55.62 261.44,55.37 CN2063.68 ; U13114.BE15 153.06,118.41 v2(153.41,118.76) 153.41,118.76 U13114.BE16 ; U13113.AA25 301.75,64.34 v2(302.13,64.72) U13113.AC25 ; CN2062.15 274.68,75.72 v1(274.16,76.24) 274.1,76.24 273.69,75.83 CN2062.19 ; v1(241.18,109.95) 241.3,109.95 U41.AD9 ; v4(176.5,128.59) 176.86,128.24 U13114.AL49 176.86,128.17 v4(177.22,127.82) 177.61,128.21 U13114.AL51 ; v2(159.71,119.46) U13114.BC24 ; v4(174.76,136.61) 174.76,136.65 v4(175.11,137) 175.46,136.65 U13114.W47 175.74,136.33 v4(175.94,136.33) ; U41.BP29 264.91,125.36 v1(264.91,125.42) 265.24,125.1 U41.BR29 ; U41.T9 236.07,109.53 236.07,109.05 U41.T8 236.08,108.9 236.08,108.38 U41.T7 236.15,108.22 U41.U6 U41.V6 237.6,107.66 v1(237.95,107.31) 238.13,107.31 238.39,107.05 U41.W5 ; v4(147.25,176.43) U13140.V13 v4(147.9,175.78) ; U13114.BD38 v2(168.81,119.46) U13114.BC37 ; v2(159.71,117.36) U13114.BG25 ; v1(304.74,79.34) 304.79,79.29 304.79,78.58 R21288.1 ; U41.AJ38 246.04,131.03 v1(246.37,130.71) 246.3,130.71 U41.AJ37 ; U21.N13 v4(349.07,52.19) U21.N15 ; U41.BM29 U41.BM28 262.96,123.91 v1(262.96,123.85) ; v4(148.51,142.53) 148.51,142.56 U13114.K8 148.43,143.19 v4(148.43,143.32) 148.43,144 v4(147.81,144.63) 147.81,144.66 v4(147.46,145.01) 147.11,144.66 v4(147.11,144.63) 146.76,144.98 U13114.G6 ; CN2062.90 255.93,65.51 v1(255.7,65.27) ; v1(259.75,130.06) 259.82,130.06 U41.BG37 ; v1(133.5,110.43) 133.28,110.64 U13115.3 ; CN2062.248 214.43,65.59 214.12,65.27 v1(213.61,65.27) 213.43,65.44 CN2062.252 ; CN2062.36 269.44,65.47 v1(269.11,65.14) ; C95148.1 125.09,120.11 124.99,120 v1(124.99,119.73) ; U13114.BE24 v2(159.71,118.06) 160.06,118.41 U13114.BE25 v2(159.71,118.76) U13114.BD24 ; CN2062.81 258.18,78.12 v1(258.85,78.78) ; v1(216.23,77.87) 217.69,76.41 CN2062.235 ; v4(131.56,174.48) U13139.E5 ; v1(213.66,55.96) 213.77,55.96 214.43,55.3 CN2063.248 ; CN2063.73 260.18,63.61 v1(260.78,64.2) ; U13135.D13 v4(204.14,135) 203.82,134.68 U13135.D14 204,134.49 v4(204,134.21) ; U41.BK14 U41.BK15 U41.BJ15 261.31,114 260.78,114.54 v1(260.78,114.8) ; CN2062.73 260.18,76.5 v1(258.9,77.79) ; v1(253.88,105.39) 253.79,105.39 U41.AW3 ; v4(124.72,150) U13142.G5 ; v1(273.12,63.19) 272.69,62.75 CN2063.23 ; U13138.T11 v4(204.14,157.51) ; v4(198.94,151.66) U13138.J3 ; v2(297.66,62.35) 297.64,62.33 297.64,62.05 U13113.N19 ; v4(127.32,127.7) 127,127.37 U13141.U5 v4(126.67,127.05) ; U41.BP14 264.58,113.29 v1(264.26,113.61) 264.26,113.54 U41.BN14 ; v4(195.7,115.29) 196.02,115.6 U13136.D1 196.02,115.63 v4(195.69,115.95) U13136.D2 ; v4(130.91,172.53) U13139.G5 ; U13114.BJ10 149.56,115.61 v2(149.91,115.96) ; U13139.D11 v4(134.81,175.13) U13139.C10 ; U13114.N4 v4(144.99,141.18) 144.62,140.81 U13114.N2 ; U13113.U11 299.62,57.68 v2(300.07,58.13) ; v4(199.59,157.51) 199.27,157.83 U13138.J12 ; U41.A30 225.14,126.13 224.58,126.13 224.18,125.72 v1(224.18,125.44) ; v1(267.69,76.06) CN2062.43 ; U41.A28 v1(224.86,124.07) ; v1(313.79,72.38) 313.55,72.14 313.43,72.14 U13113.BE40 ; v1(269.16,76.24) 269.69,75.72 CN2062.35 ; v2(151.31,115.26) U13114.BJ12 ; v2(295.9,65.9) 295.86,65.85 U13113.K27 ; v4(134.81,168.63) U13139.N10 ; v1(314.75,56.32) 315.26,55.81 315.26,55.49 316.24,54.51 316.24,54.38 v1(316.38,54.24) 317.01,53.6 317.01,53.33 317.26,53.08 317.47,53.08 318.32,52.23 C94819.1 ; v4(197.64,156.86) 197.82,156.68 U13138.G10 ; v1(235.1,123.89) 236.85,123.89 237.31,124.35 U41.V29 U41.V30 ; v1(341.85,79.8) CN2042.6 ; CN2062.106 251.93,64.89 250.82,63.77 v1(250.64,63.77) ; U21.J12 351.52,52.99 351.82,52.99 U21.H12 v4(352.32,53.49) ; v4(124.03,153) 123.75,152.71 U13142.H1 ; CN2063.78 v1(258.93,55.35) ; U13127.3 v1(371.96,59.61) ; U13138.N10 v4(202.19,156.86) ; v4(198.94,135.65) U13135.L12 ; v4(203.87,150.2) 203.82,150.25 U13138.T1 v4(204.14,151.01) U13138.T2 v4(203.49,151.66) ; v1(345.71,66.72) 345.71,67.66 346.04,67.98 C94985.2 C94983.1 ; v4(179.33,143.32) 179.03,143.61 U13114.J52 ; U13114.AW52 178.99,122.61 v4(179.31,122.3) ; v4(204.13,124.43) 204.13,124.39 U13136.T14 203.82,124.08 v4(204.14,123.75) U13136.T13 v4(203.49,123.1) ; CN2063.65 262.19,62.87 262.44,63.12 v1(262.64,63.12) ; v4(123.42,151.3) U13142.J3 ; v4(202.52,143.59) U13135.F1 ; U13138.N5 201.84,153.31 v4(201.84,153.87) ; v1(252.12,63.47) 251.69,63.04 CN2063.107 ; C95496.2 23.49,63.19 23.79,62.88 v1(23.79,62.63) ; U41.BF6 259.16,107.84 258.69,107.84 U41.BE6 258.38,107.66 v1(258.03,107.3) 257.67,107.66 U41.BD6 257.67,107.89 U41.BD7 258.09,108.34 258.01,108.42 258.01,108.89 U41.BD8 U41.BD9 258.09,109.69 258.08,109.7 258.08,110.1 258.09,110.11 U41.BD10 258.22,110.27 v1(258.54,110.59) 258.22,110.92 U41.BD11 ; U13113.D45 293.05,74.48 293.44,74.87 v1(293.44,75) ; v4(166.36,147.81) 166.49,147.68 166.49,147.25 U13114.D34 166.71,146.76 v4(166.74,146.76) 166.39,146.41 v4(166.36,146.41) ; v1(224.02,63.08) 224.18,62.92 CN2063.209 ; U13114.B22 v4(157.96,147.81) 158.12,147.65 158.16,147.65 v4(158.34,147.46) 157.99,147.11 U13114.D22 ; v1(146.58,112.64) 146.58,110.58 146.42,110.43 R21619.2 146.42,109.69 146.59,109.53 146.59,109.04 v1(146.58,109.03) 145.93,108.39 C95160.2 145.93,107.77 146.11,107.59 146.11,106.81 Y1004.2 145.04,106.46 144.77,106.19 144.77,104.11 145,103.88 146.88,103.88 147.86,104.86 Y1004.4 148.65,104.86 148.99,105.2 148.99,107.29 C95159.2 148.49,108.59 148.23,108.86 148.23,111.52 147.82,111.93 147.82,113.2 147.72,113.3 147.72,113.68 147.46,113.94 U13114.BL7 147.46,114.21 v2(147.11,114.56) ; U41.W3 238.13,105.45 238.05,105.45 v1(237.93,105.33) 238.1,105.15 238.24,105.15 238.34,105.05 U41.W2 ; v1(305.43,47.92) R21192.1 ; U13138.H1 198.55,150.61 v4(198.55,150.15) v4(198.55,149.58) ; U13114.K31 164.29,142.91 v4(164.64,143.26) 164.4,143.51 164.36,143.51 v4(164.26,143.61) ; v4(201.19,144.3) v4(201.19,143.61) 201.22,143.58 U13135.H1 ; v1(376.75,7.18) 376.63,7.05 U13152.23 ; v1(219.93,64.53) 220.94,65.53 CN2062.222 ; v4(206.17,158.14) 206.07,158.14 205.94,158 U13138.W12 205.77,157.83 v4(205.44,157.51) ; v4(202.19,123.1) U13136.P13 v4(202.84,123.75) 202.52,124.08 U13136.P14 ; U13142.H14 v4(124.07,143.5) ; v1(226.88,124.08) 226.88,124.14 U41.D28 ; CN2069.3 v1(57.24,21.25) ; CN2062.27 271.69,75.72 v1(271.19,76.22) 270.69,75.71 CN2062.31 ; v4(124.07,127.05) U13141.N5 ; U41.H32 228.81,127.13 U41.F31 228.51,126.9 v1(228.19,127.23) ; U13113.AW13 310.47,58.48 v2(310,58.01) ; U21.J8 v4(351.67,54.79) U21.H8 U21.F6 ; v1(265.83,63.85) 266.69,62.99 CN2063.47 ; v4(195.69,153.61) U13138.C5 v4(195.69,152.96) ; v1(264.9,131.51) 265.29,131.13 U41.BR38 ; CN2063.44 267.44,54.7 267.36,54.78 267.36,56.15 267.66,56.46 v1(267.89,56.46) 268.01,56.46 268.55,55.92 268.55,54.87 268.44,54.75 CN2063.40 ; v2(303.73,71.9) U13113.AE42 ; U13114.BL43 172.66,114.91 v2(172.31,115.26) 172.66,115.61 U13114.BJ43 ; v1(229.18,63.08) CN2063.189 ; U41.AG7 243.99,108.7 v1(243.9,108.7) ; v2(172.31,116.66) U13114.BG42 ; U13138.D2 v4(195.69,151.01) U13138.D1 196.02,150.67 v4(195.63,150.28) ; v4(144.6,149.67) 144.66,149.61 U13114.A3 ; CN2063.48 266.44,55.93 v1(265.96,56.4) ; U13136.N10 v4(202.19,121.8) ; v1(291.1,54.09) 290.22,54.09 v1(290.04,53.92) 289.35,53.92 v1(288.79,53.36) 288.63,53.2 288.63,52.74 288.22,52.33 C94822.1 286.29,52.33 285.63,52.99 Y1002.2 ; U13113.BD44 312.84,73.4 U13113.BD43 312.45,73.39 v2(312.32,73.26) ; CN11.7 v1(75.08,29.15) ; v4(194.39,142.8) U13135.V2 v4(195.04,142.15) ; v1(251.39,77.57) 252.69,76.27 CN2062.103 ; U13114.BE28 v2(161.81,118.76) 161.81,118.76 U13114.BE27 v2(161.81,118.06) 162.51,117.36 U13114.BG28 ; v1(261.45,103.85) 261.45,104.01 261.36,104.11 261.36,104.32 U41.BH1 261.27,104.8 U41.BH2 ; U13136.F13 v4(197.64,123.75) U13136.F14 197.19,124.2 v4(197.19,124.58) 197.19,125.75 v4(197.23,125.78) ; v2(157.61,115.96) U13114.BJ22 ; U13113.J39 295.91,71.1 v2(296,71.1) ; v2(148.51,125.76) U13114.AR9 U13114.AP10 ; v4(195.76,143.51) 195.76,143.39 U13135.T1 196.02,143.13 v4(196.34,142.8) U13135.T2 ; v1(351.91,62.37) 351.91,61.97 352.22,61.66 R396.1 ; v4(203.49,117.9) U13136.R5 203.36,118.42 203.36,119.21 v4(203.23,119.34) ; v1(226.23,122.5) 226.23,122.43 U41.C25 226.56,121.92 226.92,121.56 226.97,121.56 U41.D24 ; U13113.R10 298.1,56.63 v2(297.91,56.63) ; CN2063.202 225.94,55.62 v1(225.72,55.83) ; U13114.AH45 174.06,130.28 v4(174.41,129.93) 174.76,130.28 v4(174.76,130.31) 174.76,130.35 v4(175.11,130.7) 175.46,130.35 U13114.AH47 ; v1(230.43,106.65) 230.52,106.65 230.84,106.97 U41.K5 ; U13142.C10 v4(127.32,146.1) ; U13142.B13 v4(127.97,144.15) U13142.B14 ; U41.E35 228.19,129.41 v1(228.26,129.41) 228.58,129.73 U41.F36 ; v4(195.69,118.55) U13136.C5 v4(195.69,117.9) ; U13140.B13 v4(147.25,165.38) U13140.B14 ; v4(200.24,136.3) U13135.J12 ; U13142.N5 120.58,149.59 v4(120.58,149.08) ; U13113.AV6 309.9,55.58 309.9,56.1 v2(309.87,56.13) 310.15,56.13 310.46,56.43 U13113.AW9 ; v1(260.76,121.88) U41.BJ25 U41.BK25 ; v1(253.08,111.23) 252.74,111.57 U41.AU12 ; CN2062.6 276.93,64.94 v1(276.45,64.46) ; U13113.BB25 311.44,64.62 v2(311.32,64.73) ; v4(116.3,130.19) 116.3,130.33 U13141.A10 v4(116.92,130.95) ; U21.V6 v4(347.77,55.44) U21.T6 ; v4(137.41,165.38) U13139.V14 v4(136.76,165.38) ; v4(130.91,169.28) U13139.N5 ; U13114.AM4 145.39,127.51 v4(145.71,127.83) 145.71,127.89 145.38,128.21 U13114.AL4 ; CN2063.218 221.94,54.75 v1(222.07,54.88) ; C94979.1 346.34,65.13 347.11,64.35 R67045.2 ; U41.BR12 U41.BT12 266.06,111.82 266.57,111.82 v1(267.04,111.35) ; v2(145.71,114.56) U13114.BL5 ; v1(251.09,131.36) 251.02,131.36 U41.AR38 ; v4(177.56,126.11) 177.61,126.16 178.21,126.16 U13114.AP51 ; U41.F27 228.83,123.36 v1(228.83,123.29) 229.16,122.96 U41.G26 ; v1(348.15,81.93) 348.15,81.83 347.85,81.53 CN2042.18 v1(347.85,79.9) ; v4(199.59,122.45) U13136.J12 ; CN2063.181 231.18,63.01 v1(230.47,63.72) 230.18,63.43 CN2063.185 ; v4(125.38,127.72) 125.38,127.67 125.68,127.37 U13141.R5 ; v2(297.88,59.07) 297.48,59.46 U13113.N15 297.84,59.85 ; v4(351.67,56.09) U21.H5 ; v1(230.55,76.27) 230.18,75.9 CN2062.185 ; v1(216.2,64.58) 216.94,65.32 CN2062.238 ; v1(59.08,72.51) 59.32,72.75 CN2068.7 ; PC9101.2 v1(115.34,81.55) ; U41.AL34 247.61,128.43 v1(247.94,128.1) 247.87,128.1 U41.AL33 ; CN11.1 v1(75.03,26.15) ; U41.T4 236.06,106.17 236.1,106.17 v1(236.32,105.95) 236.07,105.7 U41.T3 235.87,105.66 235.91,105.62 235.91,105.22 235.87,105.18 U41.T2 235.92,105.01 235.92,104.45 U41.T1 ; U13113.AU7 309.22,55.91 v2(309.22,56.09) U13113.AT9 309.12,56.73 309.12,57.21 U13113.AT10 ; v1(284.83,54.19) 284.96,54.32 284.96,55.34 285.3,55.69 286.45,55.69 ; v1(351.85,79.89) CN2042.26 ; CN2070.21 v1(35.74,21.17) ; v4(124.72,146.1) U13142.G10 ; CN2069.9 v1(58.74,21.14) ; v4(116.92,145.45) U13142.W12 116.42,145.12 v4(116.12,144.82) ; v1(311.93,47.92) R21118.2 ; v4(195.04,136.95) U13135.U10 ; CN2063.217 222.18,63.53 v1(222.12,63.59) ; v4(128.62,130.95) U13141.W10 ; U13138.U5 204.52,153.33 204.52,153.48 204.54,153.5 204.54,153.84 204.35,154.02 204.35,154.52 v4(204.45,154.62) ; v1(343.35,79.77) CN2042.9 ; U13113.BD45 313.25,74.66 v1(313.65,74.66) 313.65,74.35 U13113.BE44 ; U13114.AU10 U13114.AV9 148.86,123.31 v2(148.51,122.96) ; CN2069.39 v1(66.24,21.15) ; U13114.BL13 151.66,114.67 v2(151.61,114.72) ; v4(116.5,123.96) 116.5,124 v4(116.92,124.42) 117.25,124.75 U13141.B1 v4(116.92,125.1) U13141.B2 ; v4(124.72,130.95) U13141.N10 ; v4(204.79,158.16) 205.12,158.48 U13138.V13 205.12,158.49 205.44,158.81 v4(205.44,158.81) U13138.V14 205.36,159.38 v4(205.36,159.65) 205.36,160.06 v4(205.85,160.54) ; v4(157.96,143.61) 158.31,143.26 v4(158.34,143.26) 157.99,142.91 U13114.K22 ; U13138.R5 v4(203.51,153.63) ; v4(201.94,125.59) 201.94,124.8 v4(201.54,124.4) U13136.M14 ; CN2068.1 v1(58.86,74.25) ; v2(147.81,122.96) U13114.AW8 ; v1(230.44,54.87) CN2063.184 ; v4(118.22,145.45) U13142.T11 ; U13136.W10 206.07,121.48 v4(206.28,121.27) 206.96,121.27 v4(207.02,121.33) ; U21.G22 352.35,48.96 ; U41.P37 234.49,130.71 v1(234.56,130.71) ; v2(145.71,124.36) U13114.AT4 ; v2(170.21,118.06) U13114.BE39 ; CN2070.9 v1(32.74,21.15) ; U13138.A5 v4(194.39,153.61) ; v4(197.64,121.8) U13136.G10 ; C95503.1 v1(17.55,63.16) ; v4(193.74,136.95) U13135.W10 ; v4(128.96,176.43) U13139.B2 ; C95533.1 v1(369.34,56.08) ; v1(222.18,76.19) CN2062.217 ; 149.56,132.45 v4(149.21,132.8) 148.86,132.45 v4(148.86,132.41) 148.86,132.38 v4(149.21,132.03) 149.56,132.38 U13114.AE10 149.56,132.45 ; 162.19,146.41 v4(162.54,146.06) 162.19,145.71 U13114.F28 162.12,145.71 v4(161.77,146.06) 162.12,146.41 v4(162.16,146.41) 162.19,146.41 ; 176.16,132.38 v4(175.81,132.03) 175.46,132.38 U13114.AE47 175.46,132.45 v4(175.81,132.8) 176.16,132.45 v4(176.16,132.41) 176.16,132.38 ; 149.56,140.78 v4(149.21,140.43) 148.86,140.78 v4(148.86,140.81) v4(149.22,141.17) 149.56,140.84 U13114.N10 149.56,140.78 ; 175.46,123.98 U13114.AU47 175.46,124.05 v4(175.81,124.4) 176.16,124.05 v4(176.16,124.01) 176.16,123.98 v4(175.81,123.63) 175.46,123.98
  TOP w0.279: U13093.18 v1(260.9,44.8) ; v1(57.68,62.17) 58.16,61.69 59.48,61.69 59.54,61.75 CN2068.51 ; CN2068.75 59.69,55.75 59.51,55.57 58.36,55.57 57.86,56.07 v1(57.86,56.2) ; U13093.23 263.4,45.21 263.16,44.97 262.22,44.97 v1(262.07,44.82) ; v1(122.5,112.87) 122.56,112.93 U13120.3
  TOP w0.28: v4(127.97,152.7) 127.97,153.18 v4(127.69,153.46) ; v4(124.72,125.1) U13141.P2 v4(125.37,125.75) ; U13140.K14 146.69,171.15 v4(146.51,171.15) ; v4(126.41,123.3) 126.62,123.51 126.62,124.03 v4(126.67,124.08) ; v4(116.93,143.49) 116.93,142.82 v4(116.52,142.41) ; v4(118.22,143.5) 118.22,142.41 v4(118.25,142.37) ; U13137.D1 171.6,174.81 v4(171.59,174.82) ; U13142.K14 122.2,143.57 v4(122.2,143.39) ; U13137.T13 v4(179.55,167.33) ; v4(128,124.05) 128,124 128.68,123.32 v4(128.73,123.32) ; v4(170.6,174.87) 170.65,174.82 ; v4(119.54,143.42) 119.54,143.04 120.36,142.23 v4(120.36,142.22) 120.75,142.61 120.75,143.42 v4(120.82,143.5) ; v4(118.4,153.5) 118.5,153.4 v4(118.5,152.82)
  TOP w0.3: 170.65,174.82 v4(171.59,174.82) ; v4(121.04,123.64) 121.04,124.11 v4(121.17,124.25) ; v4(196.01,124.6) 196.01,125.57 v4(195.96,125.61) ; v4(205.28,133.03) 205.28,133.88 205.32,133.92 v4(205.32,134.07) ; v4(178.9,171.23) U13137.J12 ; v4(149.2,168.63) U13140.G10 ; v4(204,134.21) 203.68,133.89 v4(203.68,133.03) ; v4(154.4,166.03) U13140.B2 ; v4(156.57,175.96) 156.22,175.96 v4(155.73,176.46) ; C95691.2 201.96,131.55 202.07,131.66 202.07,133.01 v4(202.05,133.03) 202.05,133.52 v4(201.53,134.04)
  TOP w0.305: v1(44.22,57.78) 43.87,57.43 U3.15 ; Q7923.4 364.3,38.69 v1(364.61,38.37) ; PR265.1 244.9,160.54 v1(244.93,160.52) 244.93,160.51 245.29,160.15 245.29,160.1 PR114.2 ; PU9011.4 131.41,95.01 131.34,94.94 PR9072.1 ; PU9012.4 129.06,82.92 128.92,82.78 128.73,82.78 v1(128.67,82.72) 128.43,82.72 PR66996.1 ; v1(41.52,59.86) 41.69,60.03 U3.19 ; v2(302.33,59) 302.12,59.2 U13113.AB14 ; C95078.2 124.76,105.02 v1(125.12,105.38) ; v1(363.62,40.73) 363.37,40.73 362.95,40.31 Q7923.1 ; v1(126.97,118.97) 127.05,118.89 127.22,118.89 127.57,118.54 U13118.3 ; CN2076.15 139.55,60.54 139.47,60.46 139.47,59.9 v1(138.84,59.27) ; U41.AJ2 245.95,105.05 246.1,105.2 246.17,105.2 v1(246.35,105.37) 246.17,105.55 246.08,105.55 U41.AJ3 ; U13113.U14 299.14,58.79 v2(298.85,58.79) ; v1(224.84,129.28) 225.25,128.86 U41.A34 ; CN2076.19 141.55,60.52 141.23,60.2 141.23,59.61 141.29,59.55 141.29,59.36 v1(141.35,59.3) 142.05,60 CN2076.20 ; PC9488.1 132.21,85.98 131.7,85.47 PU9012.28 131.7,84.65 PU9012.32 ; PR66998.1 153.62,68.71 PU9013.4 153.62,70.17 PU9013.32 151.88,71.9 PU9013.28 151.1,71.9 151.01,71.99 151.01,72.01 150.61,72.42 PC9489.1 ; U13114.AN5 146.06,126.11 v2(145.71,125.76) 145.36,125.41 U13114.AR4 ; v1(177.85,68.24) 176.88,68.24 176.68,68.04 C853.2 ; ESD7.3 v1(229.13,171.19) ; PU9011.32 134.47,96.74 PU9011.28 ; U13136.B14 194.72,124.23 v4(194.36,124.59) ; v1(89.94,79.09) 89.72,79.31 PR101.2 ; v1(122.56,118.31) U13119.3 ; v4(118.87,127.05) U13141.E5 ; v1(38.09,57.12) 37.78,57.43 U3.6 ; PU9014.28 163.62,71.93 PU9014.32 165.35,70.19 PU9014.4 165.35,68.64 PR67000.1
  TOP w0.356: v4(179.94,124.42) 179.94,124.99 179.41,125.52 v4(179.41,125.7) 179.25,125.7 U13114.AR52 ; v1(224.47,114.78) 224.71,115.02 U41.A16 ; v4(143.6,146.77) 143.6,146.75 143.93,146.41 U13114.E2 ; v1(267.01,129.97) 267.01,129.77 266.39,129.15 266.14,129.15 U41.BT35 ; v2(156.03,113.61) 156.03,113.86 155.86,114.03 U13114.BL19 ; U41.C37 227.35,131.01 U41.D38 227.35,131.08 v1(226.98,131.46) ; U13113.BB30 311.55,67.17 v2(311.4,67.17) ; v4(177.91,147.46) U13114.C51 178.26,147.81 v4(178.61,148.16) 178.96,147.81 U13114.C52 ; U13114.BK1 143.26,114.91 142.75,114.91 v2(142.51,114.67) ; U13114.AY47 v4(175.11,122.26) U13114.AW46 ; U13114.AY47 175.74,121.63 v4(175.89,121.63) 175.9,121.61 175.9,121.47 U13114.BA48 ; U13114.AY47 v4(175.81,122.26) ; U41.C2 227.17,105.1 v1(227.19,105.08) 227.19,105.53 U41.D3 ; v4(174.46,134.18) 174.39,134.18 U13114.AB45 ; v1(229.48,121.71) 229.86,122.09 U41.H25 U41.J25 ; U13114.B40 170.56,148.51 v4(170.56,147.89) 170.56,147.85 v4(170.94,147.46) 170.59,147.11 U13114.D40 ; v1(260.83,116.1) 261.06,116.1 U41.BJ18 ; v4(178.96,121.91) 178.96,121.95 v4(179.31,122.3) 179.94,121.66 v4(179.94,121.5) ; v4(177.56,134.51) U13114.AB51 ; U41.A14 224.73,113.45 v1(224.51,113.22) ; v2(143.61,124.36) U13114.AU2 ; U41.A18 224.71,116.6 v1(224.47,116.35) ; U41.A22 v1(224.56,119.75) ; U41.A24 224.71,121.32 224.66,121.37 v1(224.43,121.37) ; v1(224.51,110.61) 224.95,110.61 U41.A10 ; U41.A12 224.71,111.87 v1(224.47,111.63) ; U41.A3 225.48,105.66 225.61,105.79 U41.B3 ; U41.A3 225.05,105.45 225.05,104.91 v1(224.84,104.69) ; U41.A3 U41.A4 ; U13114.AY10 148.86,121.91 v2(148.51,121.56) 148.16,121.91 148.16,121.91 U13114.AY8 ; U41.E38 228.15,131.06 v1(228.53,131.44) ; v2(162.51,117.36) 162.51,117.36 ; U41.Y14 238.89,113.49 239.85,114.44 v1(240.3,114.44) ; U41.A26 224.82,122.9 v1(224.71,123) ; U13114.BB49 v4(176.5,120.15) ; U13114.AB43 173.01,134.86 v4(173.01,134.9) 173.17,134.73 173.17,134.7 v4(173.36,134.51) ; v4(145.01,146.76) U13114.E4 ; v1(224.47,109.46) 224.52,109.51 U41.A9 U41.B9 ; U13114.BD52 v4(179.93,120.09) ; U13114.BD52 U13114.BC51 v4(177.89,120.18) ; U13114.BD52 v4(179.34,118.73) ; v2(144.31,121.56) U13114.AY2 ; v4(175.81,146.06) U13114.E48 ; U13114.AY51 178.26,121.95 v4(177.91,122.3) ; v2(144.31,118.06) 143.96,117.71 U13114.BF2 ; U41.A20 224.71,118.17 v1(224.47,117.93) ; U41.AN30 U41.AN29 ; U41.F2 U41.F3 ; U13114.BG22 157.96,117.01 v2(157.61,116.66) ; v4(176.51,148.86) U13114.B48 ; U41.D33 227.21,127.55 v1(226.88,127.23) 226.56,126.9 U41.C31 ; v1(224.73,107.79) 224.89,107.95 U41.A6 ; U13114.AH51 v4(177.56,130.31) 177.53,130.31 177.37,130.14 177.37,130.08 v4(177.21,129.93) ; v4(145.71,146.76) U13114.E5 ; v4(177.21,147.46) U13114.D49 ; v2(147.11,121.56) U13114.AY6 ; v4(175.81,134.9) 176.16,134.55 v4(176.16,134.51) 176.16,134.48 v4(175.81,134.13) 175.46,134.48 U13114.AB47 175.46,134.55 v4(175.81,134.9)
  TOP w0.381: v1(215.54,172.43) 215.15,172.04 PC12.2 214.55,172.74 v1(214.93,173.12) ; v1(239.36,162.96) 239.69,163.29 PR268.1 ; v1(353.03,43.82) 353.03,44.49 353.2,44.66 C94581.1 353.2,45.65 353.46,45.91 v1(353.46,46.45) 353.27,46.64 v1(353.27,47.58) ; v1(353.03,43.82) Y3.2 ; v1(353.03,43.82) 353.03,42.16 353.82,41.37 v1(354.1,41.37) v1(354.93,41.37) 355.67,41.37 356.41,42.1 356.41,44.68 C13512.1 355.76,46.45 355.6,46.6 v1(355.24,46.6) 355.24,46.98 v1(354.88,47.34) 354.88,47.36 ; C94991.1 353.16,66.47 v1(353.16,65.85) ; U41.AR13 250.66,112.22 v1(250.33,111.89) ; v1(318.89,48.86) 318.89,49.13 R21112.2 ; v1(242.84,162.78) 243.09,163.03 Q7828.1 ; PC9070.2 105.68,73.38 v1(105.18,73.88) 104.68,73.38 PC9069.2 ; R184.2 212.75,137.76 v1(213.38,138.4) ; v1(121.43,72.1) 121.03,72.51 PC9129.2 ; v1(342.03,46.32) 341.62,46.74 C95893.2 ; v1(302.15,45.66) 302.53,46.04 R21087.2 ; v1(316.2,67.3) 316.2,67.43 316.35,67.58 317.13,67.58 R21225.2 ; v4(203.97,114.4) 203.97,113.49 203.59,113.11 C96071.2 ; v1(321.58,67.16) R21241.2 ; PR67232.2 104.01,61.72 PQ9084.1 ; v1(369.07,52.16) 369.44,52.53 C95528.2 ; C95896.2 33.37,50.26 v1(33.47,50.36) ; C94741.2 v1(249.19,166.07) ; R20865.2 R20868.2 341.11,61.21 v1(340.63,61.21) ; v1(245.59,162.53) 245.59,162.91 245.33,163.17 Q7827.1 ; Q7937.1 40.51,29.58 40.15,29.94 v1(40.08,29.94) ; C95530.2 366.26,55.23 365.78,54.76 v1(365.78,54.25) ; v1(38.83,30.22) 38.58,30.22 37.94,29.58 Q7938.1 ; C94819.1 318.6,52.23 v1(319.04,51.79) 319.04,51.48 319.38,51.14 321.44,51.14 321.75,51.45 v1(321.75,51.78) v1(321.75,53.08) v1(321.75,54.09) 321.75,55.04 321.47,55.31 319.32,55.31 319.08,55.07 v1(319.08,54.4) 318.69,54.79 C94821.1 ; v1(182.93,70.98) R20892.2 ; v1(101.62,78.45) 101.87,78.71 PQ9031.1 ; R21703.1 364.87,54.32 365.15,54.6 v1(365.15,54.7) ; R67126.2 372.16,20.66 372.52,20.29 v1(372.52,20) 372.52,19.59 372.73,19.38 C96012.1 ; C96226.1 39.31,44.7 v1(39.69,45.08) ; v1(323.87,60.8) 323.62,61.05 R67022.1 ; C94965.1 22.68,34.18 v1(22.25,33.75) ; R20838.2 330.75,52.04 v1(330.73,52.06) ; v1(72.36,48.84) 72.05,48.84 71.83,48.62 R21915.2 ; C94605.1 358.96,58.38 v1(359.3,58.03) ; Y1003.4 352.96,63.93 v1(353.38,64.35) ; PU9005.2 159.33,58.89 159.84,59.4 159.84,59.76 v1(160.09,60.01) ; v1(362.3,86.94) 360.68,86.94 360.28,86.54 359.32,86.54 359.05,86.81 PQ9080.1 ; v1(324.12,67.78) 324.05,67.78 323.69,68.14 R21247.2 ; v1(38.4,35.75) 37.74,35.09 C94968.2 ; v1(38.4,35.75) v1(37.84,36.31) 37.54,36.62 36.29,36.62 36.05,36.37 C96225.1 ; v1(38.4,35.75) 38.48,35.83 R21967.2 R21922.2 R21921.2 ; PQ6.1 115.01,65.04 v1(115.03,65.07) ; D13094.2 v1(24.51,79.06) ; C94804.2 v1(320.45,59.54) ; R20831.2 332.76,51.88 v1(332.94,52.06) ; C95687.2 203.86,131.53 203.68,131.71 v4(203.68,133.03) ; v4(139.06,165.42) 139.02,165.38 v4(137.41,165.38) ; C95557.2 v1(72.89,22.14) ; C94709.2 326.8,73.24 326.28,73.75 v1(325.52,73.75) ; v1(238.91,166.21) 238.91,165.32 239.29,164.94 PC223.2 ; PD4.2 73.74,57.58 v1(73.71,57.55) 73.19,57.03 73.19,56.22 PC172.2 ; v4(116.12,144.82) 115.53,144.82 v1(115.22,144.5) ; R20837.2 v1(331.74,52.06) ; v1(274.47,109.44) 273.96,109.95 R20767.2 273.82,110.07 273.31,110.57 R67188.2 ; CN2078.7 139,54.36 v1(139.36,54.73) ; v1(360.7,56.73) 360.07,56.11 R403.2 ; R20842.2 334.03,51.45 v1(333.98,51.5) ; v1(335.81,59.81) 335.61,60 R20828.2 ; v1(64.46,50.76) 64.46,50.38 64.11,50.03 PR67234.2 64.74,49.1 PQ9086.1 ; R67352.2 24.47,37.37 v1(24.4,37.3) ; v1(328.8,77.26) 328.57,77.03 C94707.1 ; C95902.1 36.47,31.26 36.55,31.18 v1(36.55,30.88) ; v1(16.58,36.97) 17.07,36.97 D8598.2 17.25,36.29 v1(16.58,36.29) ; PQ9032.1 109.41,77.52 v1(109.37,77.56) ; v1(361.49,55.21) 361.83,54.86 R21702.2 ; v4(127.98,133.6) 127.54,134.04 v1(127.54,135.09) ; v1(212.49,158.59) PQ9054.1 ; v1(299.92,45.64) 299.92,45.99 300.24,46.31 R21085.2 ; v1(163.69,64.89) 164.09,64.89 PC9074.2 ; v1(146.83,101.13) 145.77,102.2 145.19,102.2 PR9005.1 ; R20866.2 R20857.1 344.19,61.94 v1(343.68,62.45) 343.17,61.94 R20858.1 ; C96013.1 366.29,20.64 366.22,20.58 366.18,20.58 365.78,20.18 v1(365.78,20.13) ; D13053.2 379.7,9.34 v1(379.85,9.19) ; R20689.2 348.39,61.82 v1(348.89,62.32) ; C94993.1 350.51,66.26 350.91,65.85 v1(351.01,65.85) 351.01,65.14 Y1003.2 ; PR66875.1 272.74,167.05 v1(273.07,166.72) ; v1(262,159.88) 261.78,159.67 PR66842.1 ; v1(206.39,128.61) Q7876.1 ; R67054.2 350.62,62.03 v1(350.62,62.58) ; v1(361.67,42.16) 361.85,41.97 U13092.5 ; PR267.2 244.75,161.54 244.88,161.66 v1(244.88,162.09) ; D8558.2 v1(234.97,168.62) ; v1(333.9,70.02) 333.33,70.02 R20931.1 ; v1(373.22,19.92) 373.15,20 R67125.2 ; v1(74.39,38.95) 74.38,38.96 R21916.2 ; PC9071.2 v1(103.65,74.08) ; C94711.2 v1(238.4,168.62) ; v1(341.37,51.43) 341.37,51.15 341.14,50.92 C95894.2 ; ESD8.3 v1(251.61,165.75) ; v1(324,78.73) CN2045.4 ; C96069.2 201.81,114.01 v4(201.45,114.37) ; Y1002.4 286.68,55.08 286.45,55.31 286.45,56.35 287.02,56.92 C94820.1 289.51,56.92 v1(289.55,56.96) ; R67226.1 v1(323.9,63.08) ; PC7.2 v1(217.27,170.73) ; v1(48.15,45.3) R21948.2 R21930.2 R21928.2 v1(48.13,47.41) ; C94710.2 328.78,73.24 v1(328.98,73.04) ; PC51.2 111.52,67.03 v1(111.4,67.15) ; v1(37.89,33.75) C94967.2
  TOP w0.406: v4(156.57,174.16) 156.55,174.18 v4(156.55,174.81) v4(155.88,174.81) ; v4(116.8,153.5) 116.9,153.4 v4(116.9,152.79) ; v4(127.29,176.51) 128.11,176.51 v4(128.18,176.43) ; C95816.2 116.37,142.26 v4(116.52,142.41) ; v4(120.36,142.22) C95817.2
  TOP w0.508: v1(25.67,77.31) D8597.2 ; R22164.1 v1(34.25,62.96) ; v1(132.89,118.1) 132.6,118.1 132.32,117.82 Q7880.1 ; v1(63.56,58.84) 62.98,58.84 62.6,59.22 62.59,59.22 PQ9089.1 ; v1(54.17,35.12) 54.25,35.04 R21982.2 ; v1(342.95,89.27) 343.35,89.68 Q7824.1 ; U13076.4 340.56,61.39 340.51,61.33 v1(340.63,61.21) ; CN2074.6 32.17,90.64 v1(31.39,89.86) ; v1(25.67,72.51) D8596.2 ; v1(327.72,52.65) 327.23,52.16 327.05,52.16 JP1.1 ; v1(116.53,69.36) PQ9021.1 ; HOLE9.1 382,3.21 ; v1(62.25,42.21) 61.95,41.9 R21953.2 R21951.2 R21932.2 ; PC9419.2 v1(259.38,148.68) ; v1(255.77,47.92) 256.14,47.56 CN2075.16 ; PQ9081.1 v1(355.63,88.51) ; PR67173.2 353.42,89.42 354.53,89.42 v1(354.55,89.45) ; 190.55,170.65 190.55,170.35 191.05,169.84 191.05,168.29 192.08,167.27 PC5.2 ; C94531.2 205.51,85.06 v1(206.14,84.42) ; R21965.2 v1(43.25,30.78) ; PC9429.2 230.12,155.13 v1(230.37,154.88) ; v1(130.27,120.25) 130.27,119.55 130.16,119.44 Q7855.1 ; v1(354.65,66.74) 354.2,66.29 C94613.2 C94614.2 ; v1(23.16,14.77) 23.77,14.16 C94960.1 ; v1(142.05,100.69) C95081.1 ; D13040.2 D8556.2 350.57,77.41 v1(350.19,77.03) ; CN2077.6 80.78,74.15 80.27,74.65 v1(78.9,74.65) ; v1(152.14,106.11) 152.17,106.14 R21531.1 ; PR66875.1 PC5592.1 PR66891.1 ; PR9128.2 112.8,73.67 PC9126.2 v1(112.76,74.41) ; v1(133.49,120.61) R21566.2 ; CN2054.2 50.75,83.51 v1(51.18,83.94) v1(51.18,84.75) ; v1(185.14,46.6) 184.88,46.35 CN2071.9 ; R20762.2 R20766.2 273.84,112.95 v1(274.16,112.95) ; v3(181.02,75.84) 180.08,76.78 PC2024.2 ; v1(332,70.76) R20935.1 ; R21743.2 64.33,40.2 v1(64.1,40.43) ; v1(202.84,127.47) C95711.2 ; R21932.2 v1(62.43,43.93) ; R21932.2 R21950.2 R21935.2 ; C96020.2 v1(27.88,78.83) 27.5,78.45 C95527.1 v1(24.83,78.45) ; v1(35,59.27) 34.54,58.82 R22210.1 ; Q7852.1 135.22,116.05 v1(135.4,115.87) ; C96011.1 364.13,20.08 v1(364.23,19.98) ; v1(354.93,41.37) 354.93,41.83 355.35,42.25 Y3.4 ; Y1002.2 285.56,53.47 v1(284.83,54.19) ; PC9073.2 104.49,66.46 v1(104.03,66.01) 103.53,66.51 PC9067.2 ; v1(249.52,170.15) 250.02,169.65 R20986.2 ; PQ41.1 106.55,52.72 v1(106.78,52.95) ; C94788.2 135.31,66.4 v1(135.55,66.64) ; PC9121.2 PC9131.2 116.1,71.69 v1(116.46,71.32) ; v1(362.78,87.95) 362.98,88.15 PR9229.1 ; PC9186.2 117.59,69.47 v1(117.24,69.82) ; v1(307.79,79.24) 307.77,79.21 R21242.2 ; PQ9082.1 347.1,91.17 v1(347.1,90.44) ; v1(46.78,49.72) 46.24,50.27 C94921.1 ; v1(136.21,115.71) 136.53,115.71 R21509.1 ; C95504.2 16.93,66.9 v1(16.71,67.12) ; v1(327.48,56.04) 327,55.57 R67234.1 ; R21534.1 v1(152.33,105.16) 152.56,104.94 R21528.1 ; R21968.2 v1(49.14,43.4) ; PQ16.1 35.05,71.97 v1(35.63,72.56) ; v1(173.17,53.81) 173.17,53.48 171.45,51.76 PJ1.10 ; U13103.4 328.44,61.71 v1(327.6,60.88) ; v1(340.76,85.82) 341.53,85.05 CN2042.43 ; R67124.2 373.37,32.31 372.73,32.94 C96030.2 v1(372.73,34.33) ; v1(259.48,162.58) 259.85,162.2 PR66871.1 PC5587.1 ; U13161.2 24.68,16.21 25.18,15.71 v1(25.55,15.71) ; v1(149.96,104.94) 149.96,105.02 150.01,105.07 R21879.1 ; CN2062.261 278.61,85.21 278.79,85.39 279.72,85.39 v1(280.23,85.89) ; v1(32.68,79.85) D13065.2 ; C93696.2 v1(330.6,59.38) ; v1(153.26,58.44) 152.93,58.11 PQ9010.1 ; PC9467.2 157.18,67.46 v1(156.74,67.02) ; PC9381.2 87.32,82.01 86.99,82.34 86.3,82.34 v1(85.9,81.93) v1(84.96,81.93) ; C94604.1 v1(360.69,58.38) ; v1(330.73,70.87) R20938.1 ; v1(144.33,108.34) 144.33,108.2 143.73,107.61 143.73,107.4 143.05,106.72 R21554.1 ; R21745.2 v1(60.52,28.03) ; C95990.2 46.61,64.55 v1(46.91,64.25) ; PQ9050.1 111.37,52.77 v1(111.81,53.2) v1(112.47,53.86) ; v1(202.71,73.63) 203.21,74.13 C96162.2 C96165.2 ; v1(43.61,69.86) 43.07,69.32 PC137.2 ; v1(33.45,87.85) 32.5,88.8 CN2079.8 ; v1(236.37,49.8) 236.37,49.38 236.09,49.1 v1(234.79,49.1) 234.24,49.1 232.74,47.59 CN2048.28 ; v1(48.92,30.98) 48.8,30.86 C95623.2 ; v1(44.47,71.14) PC133.2 ; CN11.24 71.17,36.7 v1(70.73,36.26) ; PC138.2 40.97,65.56 v1(41.57,66.16) ; PR120.2 v1(36.47,72.25) ; CN2063.261 283.18,65.68 v1(284.25,64.61) ; PC143.2 42.68,70.29 v1(42.36,69.97) ; v1(52.47,35.35) 52.17,35.04 R21924.2 R21969.2 R21926.2 ; PJ9028.12 173.45,52.31 174.48,53.34 174.48,53.8 v1(174.49,53.81) ; CN2042.42 v1(361.35,80.47) ; v1(23.21,67.28) 22.76,67.28 C95505.1 22.45,66.31 v1(23.18,66.31) ; R22002.2 49.21,69.05 49.12,69.05 48.89,68.83 v1(48.79,68.83) ; C94658.2 335.81,81.07 v1(335.45,81.42) ; v1(76.8,47.64) 76.8,48.61 v1(76.42,48.99) 76.04,49.37 74.85,49.37 74.19,48.71 R21912.2 ; D8554.2 353.61,77.26 353.89,76.98 v1(354.5,76.98) ; U13125.2 26.46,84.21 26.46,85.74 v1(26.56,85.84) ; C95079.1 133.44,117.05 v1(132.99,116.6) R21882.2 ; 66.35,35.18 R21741.2 ; v1(145.59,50.89) 145.5,50.8 CN2078.12 ; v1(368.72,52.89) 368.07,53.54 C96263.2 ; v1(274.16,113.61) 274.16,113.94 R20768.2 R20764.2 ; PR9035.1 143.43,63.33 PC9011.2 143.66,62.81 v1(143.66,62.58) ; v1(207.06,67.42) CN2063.262 ; R20763.2 R20765.2 272.15,109.92 v1(273.09,109.92) ; CN11.22 75.95,37.57 v1(75.61,37.91) ; CN2068.76 58.59,75.35 58.01,74.77 v1(58.01,74.26) ; U13080.2 v1(325.01,76.17) 325.01,76.55 325.27,76.8 C216.2 ; v1(267.36,49.14) 267.08,48.86 R21057.2 ; v1(289.81,83.46) 289.25,84.01 PU3002.4 289.25,85.69 288.78,86.16 PC6228.2 ; R21614.1 126.6,111.99 126.89,111.7 v1(127.2,111.7) ; v1(353.56,67.43) 353.65,67.34 R21482.2 ; v1(52.45,33.16) 52.29,33.01 R21973.2 R21971.2 ; v1(265.78,51.86) 265.95,51.69 R21061.1 R21059.1 ; PC264.2 195.64,77.49 v3(196.36,77.49) ; v1(244.32,47.41) 245.28,46.45 CN2075.15 ; C96021.2 31.4,76.71 v1(31.19,76.5) ; v1(129.66,117.34) 129.16,117.84 Q7856.1 ; v1(19.96,43.07) 19.96,44.29 v1(21.15,44.29) ; v1(62.17,45.94) 62.15,45.97 R21935.2 ; PR67171.2 352.35,90.32 v1(352.04,90.01) ; v1(33.14,81.2) CN2079.7 ; v1(326.66,49.29) 326.66,49.11 325.64,48.09 Q7934.1 327.14,47.81 R21222.2 ; PC8100.2 v1(358.54,91.3) ; PD3.2 61.69,54.37 61.41,54.65 CN2068.77 59.68,54.29 58.92,53.53 v1(58.92,52.29) ; PQ9000.1 148.32,73.87 PC9002.2 v1(149.75,73.71) ; v1(194.97,70.88) 195.3,71.22 PC261.2 ; PC9382.2 94.13,76.98 v1(93.9,76.75) 93.57,76.75 93.48,76.84 PC9377.2 ; PC221.2 235.22,158.33 235.22,158.05 PC220.2 ; PQ9001.1 143.02,75.45 143.76,74.72 v1(143.83,74.72) ; R21556.1 144.67,106.95 144.67,107.22 145.01,107.56 v1(145.27,107.56) ; v1(167.41,104.41) v1(166.9,103.9) 166.9,103.06 C95048.1 ; v1(35.63,65.22) 35.05,65.22 PQ12.1 ; D8565.2 172.49,59.06 172.41,58.99 171.81,58.99 v1(171.62,59.17) ; CN11.23 71.95,24.89 v1(72.92,23.92) ; Q44.1 177.77,75.23 v1(177.54,75.45) ; v1(104.03,65.29) 104.46,65.29 105.46,66.29 PC9072.2 PC9066.2 ; v1(63.75,44.21) 64.45,44.21 R21893.2 ; D13055.2 180.1,47.1 D13056.2 180.1,48.91 D13054.2 179.53,48.93 179.37,49.09 v1(179.37,49.11) ; R21972.2 46.5,43.22 v1(46.3,43.43) ; v1(126.12,55.59) 126.34,55.37 CN2049.4 ; v3(183.84,85.31) 183.82,85.33 PC2039.2 ; C95161.2 178.08,108.43 v1(178.2,108.55) ; C95695.2 205.67,114.3 v4(205.57,114.4) ; CN2062.262 211.01,80.09 212.26,78.83 v1(213.58,78.83) ; v1(367.76,20.01) 367.76,20.45 C96010.1 ; R21229.2 v1(318.31,74.13) ; v1(56.23,52.29) 56.28,52.24 R21952.2 ; R67247.1 47.9,74.01 v1(47.42,74.49) ; v1(130.53,56.48) 130.53,57.22 130.85,57.54 130.85,58.4 CN2076.21 ; PC9468.2 160.62,67.46 v1(161.06,67.02) ; R21909.2 68.47,35.85 v1(68.53,35.79) ; v1(178.96,71.01) 178.71,70.76 C94646.2 ; v1(49.93,57.95) 50.03,57.85 50.03,57.35 C95545.2 ; v1(105.18,58.28) 105.55,58.66 PR67233.2 ; v1(289.83,80.23) 289.66,80.41 PR3021.2 288.17,80.82 288.3,80.96 PU3002.2 ; v1(110.08,75.58) 110.1,75.61 PC9112.2 ; U13081.2 v1(255.8,170.17) ; v1(143.26,108.68) 142.97,108.68 142.49,108.2 142.49,107.47 142.08,107.07 142.08,106.66 R21555.1 ; PC9405.2 266.77,149.17 266.95,148.99 v1(266.95,148.66) ; Q7854.1 139,111.08 v1(139.03,111.04) 139.03,110.35 R21568.2 ; v1(174.42,65.29) 174.33,65.21 174.33,64.63 Q32.1 ; v1(62.02,61.36) 62.49,61.82 PR67239.2 ; R21926.2 R21960.2 ; R21926.2 52.12,37.08 v1(52.45,36.75) ; R21553.1 v1(143.41,110.83) ; v1(37.57,70.41) PC144.2 ; v1(135.4,69.92) 135.45,69.87 PR9026.2 ; PC9376.2 v1(89.28,76.93) ; v1(26.55,87.23) C96022.2 ; PC8103.2 361.68,89.01 v1(361.92,88.76) ; C94764.2 v1(232.89,170.4) ; CN2039.5 82.05,46.89 v1(83.21,45.74) ; R21535.1 150.52,104.5 v1(151.02,104.99) R21880.1 ; PQ14.1 v1(31.52,73.68) ; R21959.2 v1(44.95,30.78) ; Q7933.1 323.38,48.82 323.9,48.31 v1(323.9,48.1) 323.67,47.87 323.27,47.87 R67245.1 ; CN2048.27 203.4,47.59 v1(204.29,48.48) ; v1(71.17,37.86) 70.32,37.02 R21903.2 ; v1(131.97,101.31) R21541.1 ; PC263.1 193.92,72 194.25,71.67 v1(194.25,70.88) ; v1(174.98,57.04) 174.98,57.47 175.03,57.52 C94778.2 ; C96016.2 369.68,20.66 v1(369.27,20.25) 368.86,20.66 R67128.2 ; Q7833.2 233.45,169.79 233.57,169.92 v1(233.57,170.37) ; PQ9034.1 145.59,58.72 v1(145.03,59.27) 144.17,59.27 143.7,58.81 CN2076.22 ; U13121.2 v1(20.62,63.72) ; v1(105.13,59.68) 105.21,59.77 PR67232.2 ; R21579.1 138.09,119.4 v1(138.04,119.35) ; v1(27.58,82.5) CN2079.1 ; R21506.1 174.41,107.09 174.26,106.95 v1(173.88,106.95) ; R20867.2 360.33,57.5 v1(360.7,57.5) ; R21995.1 v1(48.74,64.86) ; v1(152.44,50.89) 152.31,51.02 151.25,51.02 PJ1.9 ; R21939.2 55.14,39.96 v1(55.14,39.49) ; Q7831.1 245.75,166.16 v1(246.25,166.16) 246.31,166.09 C94739.2 ; v1(52.52,40.1) 52.74,40.32 R21945.2 ; R21935.2 R21941.2 ; R22166.2 44.93,59.15 v1(44.9,59.17) ; v1(106.57,70.45) 106.4,70.27 PU9004.15 ; PC129.2 v1(40.57,66.17) 40.12,66.63 PC132.2 ; v1(147.44,62.78) 147.44,64.13 146.96,64.61 PC9079.2 ; v1(51.18,78.73) CN2046.6 ; R21748.2 58.32,29.17 v1(57.96,29.53) ; CN2078.11 130.82,50.83 129.38,50.83 v1(129.1,51.11) ; PC9026.1 135.38,99.29 v1(135.53,99.44) ; C218.2 326.59,76.84 v1(326.59,76.39) ; v1(22.63,14.14) C94959.1 C94958.1 ; R22185.2 46.43,60.34 v1(47.09,60.34) ; PC9401.2 v1(251.84,151.32) ; CN2045.5 329.53,82.9 v1(328.29,84.14) ; R20961.1 322.73,72.36 v1(323.11,71.97) ; C96167.2 286.07,75.53 v1(285.62,75.99) ; C94701.2 v1(334.03,81.02) ; v1(60.03,78.92) CN2046.5 ; R21886.2 R21750.2 54.66,32.96 54.38,33.24 54.15,33.24 v1(54.12,33.27) ; PR118.2 v1(33.67,67.23) ; v1(352.6,76.85) D8553.2 D8555.2 ; v1(188.95,75.15) PR308.2 ; v1(335.68,83.1) 336.75,83.1 CN2042.41 336.29,82.44 v1(335.68,82.44) ; PC140.2 93.65,65.75 v1(93.91,66.01) ; v1(137.99,118.38) 138.29,118.38 138.34,118.43 138.67,118.43 R21577.1 ; v1(356.51,82.39) 356.51,84.29 355.75,85.05 CN2042.44 352.82,85.05 351.4,83.63 v1(351.4,82.54) ; v1(25.88,89.86) Q7924.2 ; v1(147.98,50.89) 148.11,51.02 PJ9028.11 ; C95834.1 v1(129.1,114.6) ; v1(190.5,47.51) CN2071.10 ; PR9232.1 364.24,82.73 v1(364.53,83.03) ; R21540.1 v1(127.88,94.68) ; v1(30.58,86.5) CN2079.5 ; PQ19.1 v1(29.51,68.75) ; v1(109.62,58.69) 109.29,58.36 PQ9083.1 ; R67270.2 v1(36.71,73.16) ; Q7846.1 42.21,45.71 v1(43.15,44.77) ; v1(243.38,166.46) 243.38,165.87 Q7832.1 ; v1(291.89,78.17) 291.59,77.87 C96168.2 ; v1(53.73,76.94) CN2046.4 ; v1(37.33,69.56) 37.72,69.17 PC134.2 ; v1(27.81,79.85) D13064.2 ; v1(48.94,72.41) 48.94,73.45 49.25,73.75 C95540.2 ; C95502.1 v1(18.44,63.06) ; U13116.4 v1(131.16,100.75) ; R21740.2 v1(62.43,40.03) ; v1(131.97,104.99) R21539.1 ; v1(23.77,15.23) v1(24.91,14.09) C94961.1 ; v1(63.8,43.25) R21894.2 ; PC9426.2 v1(225.87,147.32) ; v1(359.57,80.18) C94702.1 ; v3(194.13,75.15) PU19.2 ; PC9395.2 v1(244.55,151.3) ; v1(63.8,42.23) R21911.2 ; CN11.21 v1(75.95,24.02) ; D13041.2 v1(348.48,77.05) ; v1(322.47,53.69) R67232.1
  TOP w0.61: v3(94.91,76.33) 95.14,76.1 PC9374.2
  BOTTOM w0.14: C96253.1 v1(369.21,36.47) ; v1(13.56,61.05) 13.63,61.13 TP13170.1 ; v1(13.48,36.8) 13.69,37 TP13154.1 ; v1(13.53,42.89) 13.58,42.94 TP13177.1 ; TP13155.1 13.69,38.93 v1(13.58,39.03) ; v1(13,53.97) 13.18,54.14 13.18,55.36 13.1,55.44 TP13168.1 ; TP13169.1 13.63,62.91 v1(13.53,63.01) ; TP13166.1 13.1,56.58 13.28,56.76 13.28,58.11 v1(13.2,58.18) ; v1(13.61,44.87) 13.58,44.85 TP13171.1
  BOTTOM w0.178: PU5.11 v1(111.37,58.74) ; v1(73.71,57.55) 73.04,56.89 PU1.22 ; U13159.11 375.36,11.55 ; U13158.11 U13158.15
  BOTTOM w0.203: v1(56.81,36.54) 56.91,36.44 C95575.1 ; R20820.2 232.97,138.9 232.94,138.88 v1(232.94,138.6) 232.97,138.57 PR66896.2 ; PC9012.2 142.24,72.97 143.08,73.81 PR9039.2 143.2,73.88 143.83,74.51 v1(143.83,74.72) ; v1(147.8,70.98) 147.42,70.6 PC9017.2 ; v4(351.02,56.09) 350.84,56.27 C94585.1 ; C96009.2 370.07,26.16 v1(370.06,26.16) ; v1(26.56,85.84) 26.41,85.69 C95525.1 C95532.1 ; v4(124.07,127.05) 124.05,127.07 C95806.1 ; D13035.1 383.94,43.91 ; v1(180.97,82.77) 180.82,82.92 179.7,82.92 179.52,82.74 PU2001.14 ; v1(376.45,42.64) 376.58,42.76 D13034.1 ; PR181.2 76.85,70.62 76.17,69.94 v1(76.17,69.61) ; C95702.1 195.56,118.69 v4(195.69,118.55) ; C95763.1 133.88,172.9 v4(134.16,173.18) ; v4(134.81,168.63) 134.7,168.52 134.23,168.52 C95765.1 ; C95152.1 152.07,111.6 v1(152.34,111.32) ; D13029.1 v1(372.32,42.68) ; C721.1 348.07,52.49 v4(347.77,52.19) ; C96255.1 365.77,41.82 366.05,41.55 v1(366.05,41) ; C95802.1 v4(117.58,128.3) ; v1(31.64,32.91) 31.54,33.01 C95905.1 ; C95773.1 131.44,164.62 v4(131.56,164.73) ; v1(182.52,68.88) 182.39,69 R67365.1 ; C95577.1 62.17,30.18 v1(62.23,30.12) ; C94637.2 195.09,63.85 v1(195.22,63.72) ; v4(349.72,53.49) 349.72,53.11 350,52.83 C94584.1 ; C95704.1 197.47,121.63 v4(197.64,121.8) ; v1(46.99,33.03) 46.55,33.47 C95859.1 ; v1(271.67,169.38) 271.49,169.2 PC9383.2 ; v4(152.45,166.04) 152.33,165.92 C95785.1 ; C94845.2 302.05,59.27 v2(302.33,59) 302.41,59.08 C96035.2 ; PR23.2 65.35,56.15 65.09,56.41 v1(64.77,56.41) ; v1(72.39,38.88) 72.03,39.24 C95595.1 ; v4(149.21,127.83) 149.41,128.03 150.06,128.03 150.16,128.13 C95135.1 ; v4(351.67,50.24) 351.62,50.29 C94599.1 ; v1(154.07,163.62) 154.29,163.4 C95792.1 ; C95762.1 131.7,177.01 v4(131.5,177.2) ; v1(74.57,45.43) 74.19,45.05 C95594.1 ; PC5667.2 265.83,168.22 v1(266.31,167.73) ; C95863.1 47.98,38.27 v1(47.65,37.94) ; v4(149.86,175.8) 150.14,176.08 C95779.1 ; R21261.2 324.76,68.88 v1(325.22,68.42) ; v4(131.56,166.03) 131.57,166.04 C95764.1 ; C94594.1 348.99,52.11 v4(349.07,52.19) 349.14,52.26 C94596.1 ; D8599.1 372.16,40.57 v1(372.16,40.57) ; v1(371.98,14.44) 372.77,14.44 373.35,13.86 373.35,12.41 373.7,12.06 C96251.1 ; v1(340,55.34) 340.66,56 C94601.1 ; v3(252.27,139.67) R549.2 ; v4(152.31,174.59) 152.15,174.42 C95783.1 ; v4(118.87,149.35) 119.1,149.58 C96062.1 ; C94612.1 353.57,54.19 v4(353.62,54.14) ; v1(76.17,21.89) 76.06,21.78 C95556.2 C95559.2 v1(76.06,19.5) ; D13027.1 367.25,47.9 v1(367.02,47.67) ; C96260.2 368.96,36.72 v1(369.21,36.47) ; 374.09,38.88 374.38,38.59 D13061.1 ; 374.09,38.88 373.79,38.59 D13037.1 ; 374.09,38.88 v1(374.09,39.72) ; C95154.2 154.04,112.95 154.7,113.61 v2(156.03,113.61) ; C94639.2 C94638.2 186.1,53.25 v1(185.95,53.09) ; R20891.2 189.38,64 189.38,64.99 v1(189.63,65.24) 189.28,65.6 R20890.2 ; v1(139.11,71.26) 138.52,71.86 PR9019.2 ; C96250.1 375.13,12.33 375.13,11.77 375.36,11.55 ; C94617.2 351.33,51.88 v4(351.02,52.19) ; v1(299.79,74.85) 299.64,75 C96248.2 ; D13060.1 376.1,38.59 376.32,38.8 376.32,39.49 v1(376.55,39.72) ; 232.56,115.15 233.24,114.47 R20818.2 ; C94640.2 v1(177.06,55.46) ; v4(349.72,54.79) 349.77,54.83 C94582.1 ; v4(349.72,54.79) 349.32,55.19 C94598.1 ; v4(349.72,54.79) 349.58,54.65 C94595.1 ; v4(351.02,52.19) 350.95,52.26 C95993.1 ; v4(351.02,52.19) 351.28,52.45 C94618.2 ; v1(194.36,52.52) 194.36,52.72 194.87,53.23 C96221.2 ; v1(43.71,36.41) 43.07,35.78 C95858.1 ; R381.2 29.84,44.7 v1(30.04,44.9) ; C95804.1 127.43,127.81 v4(127.32,127.7) ; C94839.2 311.93,66.77 311.53,67.17 v2(311.4,67.17) ; C96249.2 304.91,54.25 v2(304.82,54.34) ; v1(67.11,44.89) 67.56,44.44 C95591.1 ; v4(127.32,146.1) 126.97,146.45 C95825.1 ; C94818.2 296.56,82.21 296.88,82.52 R21173.2 ; v4(195.04,121.8) 194.95,121.71 C95706.1 ; C95705.1 200.32,118.13 200.32,117.34 v4(200.24,117.25) ; v2(160.4,122.26) 160.33,122.19 C95070.1 ; C95501.1 16.28,40.18 v1(16.15,40.05) ; C96148.1 203.47,136.28 v4(204.14,136.95) ; C96247.2 303.16,75.41 v1(302.61,74.86) ; PU2001.1 179.92,79.79 v1(179.6,80.1) v1(179.12,80.59) ; v1(41.35,39.77) 41.3,39.77 40.96,40.1 C96229.2 ; v4(149.89,174.53) 150.12,174.3 C95780.1 ; v4(352.32,53.49) 352.35,53.46 C94610.1 ; C95574.1 63.19,35.32 v1(63.01,35.14) ; D13036.1 371.91,38.59 v1(371.77,38.73) ; C96227.2 42.99,42.71 v1(43.07,42.79) ; v1(37.58,53.08) R21478.2 36.81,53.08 36.47,52.74 36.18,52.74 35.99,52.54 R2709.1 ; C94812.2 324.33,55.01 324.43,55.11 C94811.2 ; C94588.1 344.22,53.05 v1(344.13,52.96) ; C95813.1 130.4,126.28 129.88,125.76 v4(129.54,125.76) ; C95766.1 130.96,169.33 v4(130.91,169.28) ; v4(136.76,175.13) 136.22,174.59 C96107.1 ; C94831.1 313.84,72.42 v1(313.79,72.38) ; C95759.1 131.12,172.01 130.91,172.22 v4(130.91,172.53) ; v4(197.64,152.96) 198.1,153.41 C95739.1 ; C94586.1 350.04,53.82 v4(349.72,54.14) ; v1(49.47,31.74) 49.27,31.94 C95867.1 ; v1(53.2,75.1) C95543.2 ; R67023.2 377.4,9.59 377.4,8.84 377.44,8.81 C96252.1 ; v1(175.92,176.5) 175.71,176.29 C96154.1 ; C96279.2 120.79,60.04 119.29,58.54 v1(119.12,58.54) ; C94044.1 350.41,50.31 v4(350.34,50.23) ; D13032.1 D13033.1 ; C95713.1 192.69,115.68 v4(193.18,116.16) ; v1(149.96,104.94) 149.37,105.53 R21620.2 ; v4(134.81,166.03) 134.67,165.89 C95761.1 ; v2(311.27,62.44) 311.57,62.14 C94853.1 ; C94593.1 347.52,51.02 347.78,51.28 v4(347.78,51.54) ; v1(69.11,41.75) 68.73,41.37 C95596.1 ; v1(57.47,30.67) 58.06,31.26 C95576.1 ; v1(344.43,51.67) 344.85,52.09 C94583.1 ; C96237.1 32.58,42.94 v1(32.86,42.66) ; v1(376.75,7.18) 376.88,7.05 377.26,7.05 C96254.1 ; C94652.2 332.73,72.07 v1(332.38,71.72) ; R21797.1 40.94,21.71 40.46,21.23 v1(40.46,21.17) ; D13030.1 v1(366.9,45.79) ; v1(60.52,28.03) 60.34,27.85 C95554.2 ; v4(202.82,121.13) 202.82,120.85 202.45,120.48 C95701.1 ; C94824.1 324.76,67.15 325.19,66.72 v1(325.19,66.64) ; v1(53.2,72.41) C95541.2 ; v1(323.9,48.1) 323.24,48.1 322.6,48.73 C94810.2 ; v3(252.29,138.9) PR66888.2 ; C95822.1 117.64,146.84 v4(117.56,146.76) ; v4(120.82,127.05) 120.84,127.05 C95800.1 ; PC2040.2 v1(180.36,84.75) ; R21393.1 212.36,53.28
  BOTTOM w0.229: C94834.1 299.87,74.77 v1(299.79,74.85)
  BOTTOM w0.254: v4(123.42,151.3) 123.25,151.12 C96067.1 ; R21734.1 72.18,21.89 72.34,21.72 v1(72.34,21.43) ; C96119.1 117.39,128.49 v4(117.58,128.3) ; v4(134.15,174.49) 134.09,174.44 C96082.1 ; C95500.2 18.23,43.25 v1(18.36,43.37) ; v1(206.95,118.2) 207.31,117.85 C95712.1 ; v4(133.61,170.72) 133.37,170.47 C96079.1 ; C96017.2 371.22,24.22 v1(371.48,23.96) ; C96049.1 120.01,130.13 v4(120.17,130.3) ; v4(200.24,142.15) 200.44,142.35 C96135.1 ; C96124.1 201.73,149.42 201.32,149.82 v4(201.32,150.13) ; C96093.1 149.31,168.52 v4(149.2,168.63) ; R21576.1 138.04,118.33 v1(137.99,118.38) ; C95752.1 192.57,152.1 192.35,151.88 v4(192.35,151.6) ; C95692.1 192.67,140.69 193.16,140.2 v4(193.74,140.2) ; v4(178.25,168.63) 178.2,168.58 177.63,168.58 C95723.1 ; v4(194.39,153.61) 194.17,153.82 C96133.1 ; C96122.1 204.65,149.16 204.35,149.45 v4(204.35,149.45) 204.35,149.72 v4(203.87,150.2) ; R67241.2 313.94,65.88 v1(314.09,66.03) ; v4(200.24,157.51) 200.48,157.75 C96130.1 ; v4(122.52,152.96) 122.17,153.31 122.17,153.87 122.35,154.05 R22024.2 ; v1(237.13,72.76) 237.84,73.47 C94893.2 ; C94909.2 276.23,65.34 v1(276.4,65.17) ; C96068.1 123.12,145.1 v4(122.77,145.45) ; C95805.1 124.81,130.86 124.72,130.95 v4(124.72,130.95) ; C96065.1 117.84,148.97 v4(118.19,148.62) ; C95119.2 144.16,136.11 v4(144.66,136.61) ; C95708.2 182.37,164.8 v4(182.31,164.74) 181.67,165.38 v4(180.85,165.38) ; v4(206.27,135.73) 206.51,135.48 C96086.2 ; v1(345.54,92.22) 345.78,92.46 Q35.4 345.71,92.86 R20967.2 ; C420.2 212.29,98.87 v1(212.44,98.72) ; R21419.1 210.51,69.31 210.74,69.54 211.65,69.54 v1(211.86,69.33) ; v4(149.85,177.08) 150,177.23 C96120.1 ; v4(124.72,150) 124.72,149.92 124.05,149.24 C95819.1 ; C95630.2 49.57,21.17 v1(49.68,21.28) ; C95812.1 115.34,123.44 v4(115.37,123.4) ; v4(177.56,175.76) 177.51,175.71 C96115.1 ; v2(309.31,64.75) 309.31,64.31 309.52,64.1 C94830.1 ; v1(69.89,46.72) 70.29,46.32 C96202.1 ; v4(194.36,159.49) 194.36,160.87 v1(194.08,161.15) 193.96,161.27 C95748.2 ; v1(304.74,79.34) 304.77,79.32 304.77,78.5 R21284.1 ; v4(153.75,171.23) 153.41,171.57 C96091.1 ; v4(148.55,171.23) 148.46,171.32 C96098.1 ; v1(367.15,27.88) 367.03,28 R67138.2 ; C95782.1 152.38,168.01 v4(152.4,167.98) ; v1(121.18,114.9) 121.59,114.49 C95158.1 ; 235.27,66.54 C94906.1 234.09,66.54 R21421.1 234.08,66.26 233.7,65.88 ; C95784.1 151.93,169.78 153.09,168.63 v4(153.1,168.63) ; C96045.1 134.02,176.98 v4(134.14,177.1) ; C96083.2 192.67,144.63 192.93,144.36 193.52,144.36 194.37,143.51 v4(194.37,143.48) ; R21290.1 305.99,74.74 v1(306.12,74.87) ; C96109.1 172.01,172.05 171.77,172.28 v4(171.59,172.28) ; C96060.1 120.9,123.5 v4(121.04,123.64) ; v4(200.24,152.31) 199.89,152.66 C96087.1 ; v1(233.86,111.88) 233.35,112.39 C94435.2 ; U13064.3 211.43,100.93 211,101.36 v1(209.72,101.36) ; C94182.1 338.78,68.67 v1(338.93,68.83) ; v1(302.61,74.86) 302.46,74.71 R21187.1 ; v1(23.62,48.43) 23.41,48.23 23.41,47.21 23.59,47.04 C95510.2 C95509.2 ; v4(134.81,167.33) 134.8,167.32 C96077.1 ; v4(175.58,173.17) 175.96,172.78 C96112.1 ; C95743.1 202.74,156.09 v4(202.85,156.2) ; R21300.1 v1(316.73,61.69) ; Q7879.1 v1(117.1,139.02) ; C95753.1 208.01,152.07 v1(207.79,151.86) ; R21188.1 303.88,72.05 v2(303.73,71.9) ; v4(198.94,151.66) 198.99,151.7 C96132.1 ; C96143.1 200.93,115.46 v4(201.32,115.08) ; v4(124.72,146.1) 124.61,146.21 C95826.1 ; v4(206.09,156.21) 205.99,156.1 C96157.1 ; C96095.1 155.39,171.8 v4(155.92,172.33) ; C96054.1 123.38,132.2 v4(123.42,132.25) ; R22022.2 122.48,122.99 122.22,123.25 v4(122.22,123.9) ; C96118.1 118.86,130.29 v4(118.86,130.29) ; v4(195.04,156.86) 195.09,156.81 C95742.1 ; v1(50.77,57.57) 51.07,57.27 C95546.1 ; C96047.1 116.16,130.04 v4(116.3,130.19) ; v1(263.88,64.99) 263.97,65.08 C94907.2 ; v1(320.82,64.23) 320.44,63.85 R21248.1 R67242.2 ; C96052.1 122.04,125.67 v4(122.12,125.75) ; C96080.1 130.29,171.26 v4(130.26,171.23) ; R22021.2 157.19,170.43 v4(156.5,169.73) ; v4(119.55,146.77) 119.68,146.91 C96066.1 ; v1(260.37,113.21) 260.47,113.21 260.84,112.84 C94536.1 C94537.1 ; v4(206.32,118.6) 206.1,118.82 C95740.1 ; v4(182.33,166.34) 181.99,166.68 v4(180.85,166.68) ; C94852.1 311.86,60.47 311.7,60.32 C94846.2 311.29,60.03 v2(311.04,59.78) ; v4(127.32,130.95) 127.22,130.85 C95803.1 ; C95869.1 55.79,42.34 56.21,41.92 v1(56.64,41.92) ; C96034.2 299.24,66.69 v2(298.9,67.02) ; v1(269.13,63.59) 269.33,63.4 C94915.2 ; R67122.2 370.85,25.75 370.73,25.87 C96009.2 ; R22015.2 168.32,170.78 v1(168.31,170.77) ; v4(149.2,167.33) 149.25,167.38 C95781.1 ; v4(146.57,165.35) 146.17,165.35 145.6,165.92 C95774.2 ; v1(242.39,60.19) 243.1,60.19 243.68,60.77 C94888.2 243.3,61.32 243.24,61.26 C94862.2 ; v1(50.92,47.44) 51.94,47.44 52.22,47.72 C95864.1 ; C96136.1 198.99,135.7 v4(198.94,135.65) ; C94636.2 C94635.2 185.82,68.11 185.36,68.57 185.36,68.85 v1(185.24,68.98) ; v1(180.56,70.43) 180.56,69.94 180.89,69.61 180.89,68.09 181.15,67.83 181.47,67.83 C94634.2 ; C273.1 227.24,127.23 v1(226.88,127.23) ; v4(152.39,177.17) 152.33,177.1 C96102.1 ; C95681.1 195,140.16 v4(195.04,140.2) ; v4(170.6,172.47) 170.4,172.66 C95724.1 ; R67084.1 369.43,24.83 369.77,25.16 v1(369.77,25.49) ; v4(173.7,170.58) 173.47,170.36 C96104.1 ; C95757.2 128.76,163 v4(128.19,163.57) ; v4(129.38,150.61) 129.67,150.9 C95833.1 ; R21134.1 314.21,56.86 v1(314.75,56.32) ; C95627.2 C95631.2 31.16,21.07 v1(31.08,21.15) ; C95745.1 202.16,152.34 v4(202.19,152.31) ; C94833.1 306.88,74.41 307.1,74.64 v1(307.1,74.91) ; C96152.1 194.05,118.9 v4(194.39,118.55) ; C95700.1 204.7,121.04 v4(204.81,121.14) ; v4(199.59,157.51) 199.56,157.47 C96084.1 ; v1(114.07,152.24) C95832.1 ; R21304.1 305.86,79.14 v1(305.68,79.32) ; C96058.2 171.15,168.36 v4(171.4,168.1) ; R21279.1 316,50.25 R67230.1 316.85,50.11 318.54,50.11 318.96,49.69 318.96,48.92 v1(318.89,48.86) 318.89,48.45 318.66,48.23 C94855.1 ; R67223.1 323.88,63.07 v1(323.9,63.08) ; C96076.1 135.69,171.46 v4(135.46,171.23) ; C95150.2 121.94,120.11 v1(122.07,120.23) ; C96096.1 150.2,171.44 v4(149.96,171.21) ; v1(249.17,68.65) 248.38,67.86 C94899.2 ; v1(200.42,113) 200.27,113.15 R22013.2 ; C95679.1 197.55,137.04 v4(197.64,136.95) ; v1(49.93,57.95) 50.19,57.7 C95547.1 ; v4(199.59,122.45) 199.5,122.55 C96146.1 ; v1(246.83,59.6) 248.58,59.6 248.97,59.99 C94877.2 ; v4(144.66,138.71) 144.47,138.52 C95109.2 ; PR138.2 134.12,68.98 134.74,68.98 v1(134.87,69.1) ; v2(307.23,63.47) 307.25,63.49 C94828.1 ; C95861.1 52.49,43.73 v1(51.63,42.87) ; C94883.2 245,59.36 244.24,58.6 v1(243.99,58.6) ; v4(126.71,143.46) 126.61,143.36 C96046.1 ; C95693.1 207.54,140.17 v1(207.16,139.79) ; v4(202.19,137.6) 202.08,137.71 C95685.1 ; v1(251.81,68.39) 251.3,67.89 C94861.2 ; C96070.1 122.04,145.53 v4(122.12,145.45) ; v2(308.17,55.09) 308.09,55.02 C94835.1 ; v4(177.58,174.47) 177.54,174.44 C96043.1 ; C95732.1 172.96,178.74 v1(172.61,178.4) ; v1(250.74,68.98) 250.59,68.98 250.08,68.47 C94895.2 ; C94969.2 C94970.1 ; C95823.1 121.81,147.41 122.14,147.08 v4(122.14,146.83) ; C94527.2 231.1,57.38 v1(231.06,57.43) ; C95719.1 175.11,165.92 v4(175,166.03) ; v1(246.93,57.04) 247.37,57.04 C94882.2 ; C95720.1 177.44,173.03 v4(177.6,173.18) ; C96081.1 131.61,174.44 v4(131.56,174.48) ; v4(205.57,149.45) 205.79,149.23 C96121.1 ; v4(177.56,177.05) 177.49,176.98 C95725.1 ; v1(326.79,71.24) 326.67,71.37 R21312.2 ; C94904.2 245.73,74.65 245.99,74.38 C94912.2 246.4,73.45 245.89,72.94 245.89,72.18 245.22,71.51 v1(245.1,71.51) ; v1(210.38,59.68) 210.03,60.04 210.03,60.31 210,60.33 C94876.2 210.24,60.57 C94873.1 ; C94811.2 323.77,55.49 v1(323.74,55.46) ; v4(122.17,130.24) 122.17,129.76 122.04,129.63 C95801.1 ; C96134.1 201.72,141.03 v4(201.54,140.85) 201.36,140.85 200.89,140.38 C95683.1 ; v1(59.2,48.1) 58.95,48.1 58.42,47.57 C95868.1 ; v4(178.9,171.23) 178.87,171.26 C96108.1 ; C94868.2 239.26,63.06 v1(239.44,63.24) ; C889.2 178.48,61.21 178.18,61.51 C891.2 177.66,61.51 v1(176.93,62.24) ; v4(200.24,117.25) 200.46,117.04 C96138.1 ; C95744.1 201.61,154.22 201.84,153.99 v4(201.84,153.87) ; v4(204.79,137.6) 204.77,137.62 C96150.1 ; v1(235.02,64.41) 235.15,64.28 C94879.2 ; v4(126.67,149.35) 126.8,149.23 C96063.1 ; C94981.1 352.25,73.86 v1(352.85,74.46) ; C95824.1 120.62,149.03 v4(120.58,149.08) ; v2(304.44,64.73) 304.46,64.71 C94841.1 ; v1(179.7,59.22) 179.34,59.22 178.93,59.63 C96220.2 ; C96144.1 200.67,122.27 200.48,122.45 v4(200.24,122.45) ; v1(300.32,79.09) 300.78,79.54 R21292.1 ; C96110.1 173.73,171.26 v4(173.7,171.23) ; C94870.2 232.79,63.75 v1(232.66,63.87) ; v4(202.99,140.09) 203.48,140.58 C96149.1 ; C96078.1 128.47,169.89 v4(128.16,169.58) ; v4(128.17,168.06) 127.95,168.29 v4(127.02,168.29) 127,168.27 C96090.1 ; v4(195.04,136.95) 195.15,137.06 C95682.1 ; v4(118.54,124.29) 118.67,124.16 C96059.1 ; v1(243.05,67.91) 243.05,66.94 C94901.2 ; v1(313.81,63.57) 313.42,63.97 C94850.1 C94851.1 ; C95684.1 203.49,137.63 v4(203.5,137.61) ; R22019.2 125.2,170.65 v1(125.19,170.64) ; C94647.2 336.5,71.92 v1(336.67,71.8) 337.8,71.8 338.08,72.07 R67396.2 ; v1(225.36,95.97) 226.07,95.27 R192.2 ; C94829.2 301.06,65.98 v2(300.59,65.5) ; v4(136.11,169.93) 136.11,170.54 C95791.2 ; C96036.2 304.09,59.66 v2(303.72,59.29) ; v4(180.85,167.98) 182.29,167.98 v4(182.32,167.95) 182.4,167.87 C96111.2 ; C96158.1 206.11,121.11 v4(206.28,121.27) ; C96073.1 121.9,150.87 v4(122.12,150.65) ; v4(200.24,136.3) 200.34,136.21 C96147.1 ; v1(241.62,69.56) 242.44,68.75 C94875.2 ; C96151.1 199.25,116.92 v4(198.94,116.6) ; v1(297.71,50.23) 297.48,50 C94838.2 ; v2(300.57,64.72) 299.97,65.33 C94840.2 ; v4(204.81,156.19) 204.72,156.11 C95746.1 ; v2(304.82,54.34) 304.62,54.14 C94854.1 ; C96057.2 115.9,127.74 v4(116,127.64) ; C95734.2 196.45,161.42 v4(196.72,161.16) 196.72,160.9 197.19,160.43 v4(197.19,159.61) ; C96131.2 139.22,168 v4(139.09,167.86) ; v4(149.2,166.03) 149.29,165.94 C95786.1 ; v4(146.57,167.95) 146.39,168.12 C95788.2 ; C96256.1 380.1,9.88 v1(380.39,9.59) ; v4(178.25,166.03) 178.13,165.92 C95721.1 ; C96258.1 v1(380.28,12.16) ; C95760.1 134.11,175.83 v4(134.14,175.8) ; C95799.1 117.57,130.26 v4(117.56,130.28) ; v1(251.93,54.88) 251.93,53.96 251.69,53.72 C94892.2 ; v4(203.04,149.45) 203.25,149.25 C96123.1 ; v4(122.77,126.4) 123,126.18 C96051.1 ; v4(153.11,177.09) 153.01,177.19 C95793.1 ; C95516.1 16.28,48.51 v1(16.12,48.35) ; v4(200.27,156.11) 200.78,156.11 201.09,155.79 C96106.1 ; R21256.1 316.55,67.66 v1(316.2,67.3) ; v4(197.64,117.9) 197.64,118.57 197.22,118.99 C95699.1 ; v4(175,164.73) 174.74,164.48 C96105.1 ; v4(127.97,149.35) 128,149.32 C95821.1 ; v4(174.35,169.28) 174.47,169.4 C95726.1 ; U53.3 207.29,100.16 207.03,100.42 207.03,100.79 206.63,101.18 R205.2 206.24,101.66 206.47,101.9 v1(207.26,101.9) ; v4(154.4,169.93) 154.35,169.98 C96094.1 ; C94832.2 310.38,65.88 309.81,65.88 v2(309.73,65.96) ; v1(228.19,127.23) 228.19,127.1 228.47,126.81 C260.2 ; v1(212.08,103.7) 212.01,103.63 C417.2 ; v1(214.88,102) 214.53,101.65 C812.2 ; D13033.1 v1(378.73,38.59) ; C96074.1 137.47,169.23 v4(137.41,169.28) ; v4(175.2,174.29) 175.33,174.42 C95722.1 ; C95629.2 49.75,19.78 v1(50.13,20.16) ; C95913.2 239.57,73.4 238.86,72.69 v1(238.78,72.69) ; v1(69.77,48.71) 69.77,48.86 69.64,48.99 PR40.2 ; C94872.2 221.94,54.75 v1(222.07,54.88) ; v4(146.57,169.25) 146.56,169.24 R21873.1 ; C95715.2 172.39,162.68 172.49,162.77 C95733.1 ; v1(127.25,63.34) PU12.3 ; v4(206.2,153.69) 205.99,153.91 C96129.1 ; C96140.1 199.54,115.25 v4(199.81,114.98) ; v4(116.06,149.28) 116.35,149.57 C96064.1 ; v4(199.59,141.5) 199.49,141.5 C96137.1 ; v1(258.9,63.11) 259.08,62.93 C94865.2 ; v4(197.64,156.86) 197.62,156.84 C95741.1 ; C94539.1 229.96,124.55 v1(229.48,124.08) ; C94897.2 C94905.2 248.46,73.55 247.7,72.79 v1(247.42,72.79) ; C94910.2 243.23,74.38 243.09,74.52 C94903.2 242.56,73.05 243.59,72.03 v1(243.81,72.03) ; R21860.1 v4(199.8,132.96) ; v4(203.51,153.63) 203.45,153.69 C96088.1 ; v4(195.69,153.61) 195.69,153.61 C95686.1 ; C96092.1 148.07,170.11 v4(148.55,170.58) ; C96101.1 151.87,172.66 v4(151.95,172.74) ; v4(206.47,140.27) 206.11,139.92 C96126.1 ; v2(300.07,58.13) 300.07,58.43 C94848.2 ; C95827.2 127.77,153.55 v4(127.69,153.46) ; v4(116.16,146.73) 116.38,146.96 C96116.1 ; C94913.2 212.37,60.31 212.11,60.57 C94911.1 211.73,60.09 v1(211.78,60.04) ; C95680.1 198.17,140.73 v4(198.29,140.85) ; v1(269.16,76.24) 269.22,76.18 C95914.2 ; v1(170.2,165.57) 169.83,165.2 C96061.2 ; R22011.2 199.96,145.48 v1(200.29,145.8) ; v1(134.89,123.28) C95134.2 ; v1(128.16,178.91) C95772.1 ; R22017.2 v1(199.41,146.5)
  BOTTOM w0.305: v4(191.91,123.65) C95698.2 ; v1(347.1,90.44) Q35.1 ; C96259.2 377.45,13.18 377.2,12.94 377.2,11.96 v1(377.35,11.81) ; v1(113.05,120.11) C95149.1 ; v1(209.7,67.02) R21420.1
  BOTTOM w0.356: v4(148.43,143.32) 148.43,143.92 v4(149.15,144.64)
  BOTTOM w0.381: v1(350.71,58.83) 350.71,58.48 R20864.2 ; v1(327.6,66.56) 327.17,67 R67240.2 ; v4(348.42,49.59) 348.45,49.61 R379.2 ; v1(115.34,131.03) 115.21,131.16 C96053.2 ; v1(314.75,56.32) 315.11,56.68 C94814.2 ; v4(128.27,166.64) 128.21,166.58 C95767.2 ; v1(33.47,50.36) 33.37,50.26 C95896.2 ; v4(140.23,145.69) 140.2,145.66 C95129.2 ; R21606.1 181.86,137.66 182.14,137.38 v4(182.14,137.02) ; D13050.2 D13051.2 372.52,20.74 v1(372.52,20) ; C95697.2 207.41,121.72 v4(207.02,121.33) ; v1(183.66,172.56) C95731.2 ; R67047.2 347.99,62.45 348.76,62.45 v1(348.89,62.32) ; C96128.2 v1(127.54,135.09) ; v1(135.91,63.49) 135.76,63.64 PR9028.1 ; C96203.1 48.92,41.11 v1(49.02,41.01) ; v1(225.45,98.19) 225.83,98.57 R195.2 ; C95728.2 170.45,175.01 v4(170.6,174.87) ; PC9080.2 160.72,59.99 v1(160.77,59.94) 160.74,59.91 PR9067.2 ; v1(348.47,58.76) 348.47,58.56 R20690.1 ; C96113.2 v1(175.42,178.44) ; R67046.2 344.82,56.73 343.56,56.73 343.17,56.35 R67048.2 343.17,55.59 v1(343.58,55.17) ; v1(253.89,167.1) 253.76,167.23 R20970.1 ; R397.2 344.44,55.46 v1(344.23,55.25) ; v1(97.86,55.85) 97.86,56.37 PC125.2 ; v1(371.48,23.96) 370.98,23.45 R67123.2 ; C95553.2 60.53,25.58 v1(60.17,25.21) ; C94626.2 381.53,46.07 381.17,46.42 v4(380.74,46.42) ; v1(124.24,140.15) C95829.2 ; v1(238.78,71.26) 239.41,71.26 R21436.1 ; C95820.1 148.56,161.19 C95789.2 ; R20844.2 349.91,58.66 v1(350.05,58.8) ; v1(140.79,57.8) 140.48,57.5 C94790.1 ; R21271.1 327.17,70.45 326.79,70.83 v1(326.79,71.24) ; C95117.2 139.95,148.58 v4(140.37,148.16) ; C95796.2 v4(119.4,134.59) ; v4(131.5,177.2) 131.6,177.3 C96127.2 ; v4(207.53,160.51) 207.54,160.52 208.15,160.52 208.35,160.31 C95738.2 ; v1(192.02,133.34) 192.15,133.21 C96099.2 ; C96085.2 206.88,137.64 v4(206.19,136.95) ; v4(195.76,143.51) 194.58,144.69 C96075.2 ; R21605.1 181.52,139.86 v4(180.76,139.1) ; v1(338.37,75.69) 338.01,75.34 R67248.2 ; R22060.2 19.82,33.5 v1(19.55,33.77) ; C96103.2 207.17,123.8 206.49,123.12 v4(206.2,123.12) ; C96257.2 380.14,8.9 v1(379.85,9.19) ; C95747.2 194.86,149.3 v4(194.68,149.49) ; v4(156.57,168.07) 156.86,168.36 C95787.2 ; R21173.2 297.2,82.9 296.84,83.25 v1(296.84,83.89) ; v1(22.25,33.75) 22,33.5 C94924.2 ; v1(160.09,60.01) 160.09,59.71 159.62,59.24 PC9082.2 ; PC10.2 152.78,57.89 153.33,58.44 ; PC4.1 72.83,62.31 72.92,62.22 PC6.1 73.52,62.64 73.92,63.04 v1(74.76,63.04) ; C95770.2 133.92,178.21 v4(133.79,178.08) ; v1(337.46,85.84) 337.46,86.53 Q7819.1 ; v1(325.24,57.7) 325.45,57.49 325.45,57.3 C94805.2 ; v1(68.4,50.54) 68.4,51.04 PR211.1 ; C96072.2 196.48,144.5 196.99,143.98 v4(196.99,143.45) ; v1(149.25,67.78) 148.87,67.41 PC9000.2 ; C96142.2 156.99,176.12 156.83,175.96 v4(156.57,175.96) ; PR9041.1 142.44,63.33 PC9014.2 ; C96155.2 207.4,156.17 v1(206.52,155.29) ; C94916.2 227.34,75.91 v1(227.18,76.06) ; R67023.2 377.93,10.12 v1(377.93,10.77) ; R21876.1 122.7,139.54 v1(123.34,140.17) 122.96,140.55 R67201.1 ; C95818.2 129.38,146.85 v4(128.62,146.1) ; v1(73.17,41.75) 73.55,41.37 R21896.2 73.8,41.34 R21914.2 ; C95778.2 v1(156.07,178.02) ; v1(123.46,70.32) 123.46,69.31 123.47,69.3 PR161.2 ; v4(380.74,40.58) 380.99,40.58 381.53,41.11 C94624.2 ; v4(180.72,164.17) 180.72,163.92 180.61,163.81 C95097.2 ; C95717.2 181.99,174.11 181.53,174.56 v4(180.93,174.56) ; C94498.2 245.44,111.91 v1(244.83,111.29) ; C95128.2 202.2,125.85 v4(201.94,125.59) ; C95831.2 v4(120.36,142.22) ; C95933.2 258.97,171.3 v1(258.97,170.78) ; v1(130.24,134.97) C95810.2 ; C95107.2 181.23,132.18 v4(180.06,131.01) ; C95716.2 176.73,163.88 176.3,163.44 176.3,157.93 175.65,157.28 C95111.2 C95113.2 173.11,157.27 172.38,157.27 172.06,156.95 C95127.2 C95093.2 ; v4(201.19,144.3) 201.1,144.4 C95089.2 ; v1(101.62,78.45) 101.87,78.2 PR9210.2 ; C94986.1 346.02,67.02 v1(345.71,66.72) ; PC11.2 153.81,57.96 153.33,58.44 ; v1(150.24,109.85) 150.85,110.46 C95153.2 ; C95715.2 170.63,162.68 v1(170.25,162.3) ; C94631.1 31.62,37.23 31.85,37.46 32.76,37.46 32.97,37.67 C94630.1 32.97,38.59 32.33,39.23 ; Q7878.1 143.67,178.54 v1(144.04,178.91) ; v4(128.27,165.34) 127.93,165.34 v4(127.02,164.43) ; R21234.1 323.62,61.05 v1(323.87,60.8) ; R67397.2 338.1,53.67 339.76,55.34 v1(340,55.34) ; R21470.2 16.92,7.33 v1(17.29,7.33) ; v1(64.74,21.15) 65.17,21.15 65.71,21.69 Q7874.1 ; v4(193.74,136.95) 193.74,137.41 193.65,137.51 C95674.2 ; v4(201.45,114.37) 201.43,114.36 C95707.2 ; Q7840.1 293.4,84.95 292.93,85.41 v1(292.93,85.82) ; v1(348.97,69.89) 348.76,69.69 348.31,69.69 ; C94947.2 32.04,33.31 v1(31.64,32.91) ; C95678.2 v1(194.17,132.91) ; v1(353.79,93.46) 353.27,93.99 Q7822.1 ; C96097.2 197,132.22 196.82,132.39 v4(196.82,132.97) ; v1(316.38,54.24) 315.87,54.24 315.69,54.06 C94807.2 ; v1(164.05,57.11) 163.77,57.11 163.48,56.82 PR10.2 ; C96245.2 v1(36.11,48.91) ; C95749.2 201.97,160.74 v4(201.89,160.66) ; PC36.1 71.8,49.39 v1(72.36,48.84) 73.15,49.62 PC35.2 ; R21913.2 R21898.2 73.45,43.37 v1(73.17,43.65) ; v1(64.46,50.76) PC20.1 65.67,50.76 66.45,51.54 PC37.1 ; R20826.2 330.68,57.12 330.91,56.89 332.89,56.89 U13025.43 ; C94914.2 235.95,74.28 v1(235.15,73.47) ; v1(186.25,146.7) 186.25,145.25 185.54,144.54 C95130.2 ; D13049.2 369.59,20.57 v1(369.27,20.25) ; C94885.2 217.17,63.15 216.42,63.91 v1(216.18,63.91) ; PR66887.2 v1(273.07,165.95) ; v1(139.36,54.73) 139.36,54.88 138.45,55.8 138.15,55.8 137.55,56.39 C94789.1 ; v1(54.27,49.95) 54.44,49.95 C96204.1 ; U13025.45 333.96,54.07 R20839.2 ; R21865.1 181.49,172.32 v4(180.99,172.32) ; v1(49.47,31.74) 49.87,32.14 C95865.1 ; R21904.2 74.8,45.2 v1(74.57,45.43) ; v1(200.35,162.93) C95751.2 ; PC100.2 113.48,58.56 v1(113.63,58.72) 113.63,59.06 PC101.2 ; v4(127.16,174.87) 126.6,174.3 C95755.2 ; v1(316.5,68.62) R21233.2 ; v1(143.48,101.44) 143.39,101.35 R21558.1 ; R20694.2 354.12,57.98 v1(356.38,60.24) ; v4(119.2,153.63) 118.53,153.63 v4(118.4,153.5) ; v1(63.93,37.61) 63.15,38.39 C96201.1 ; C95771.2 R21870.1 141.87,171.28 140.38,169.79 v4(139.06,169.79) ; R20931.1 333.33,70.02 v1(333.9,70.02) ; v4(138.17,176.39) 138.4,176.61 C95768.2 ; v1(227.18,63.07) 227.31,62.95 C94884.2 ; v4(207.25,143.71) 207.53,143.99 C95675.2 ; C96141.2 v1(156.75,178.03) ; C96244.2 v1(38.2,48.91) ; v1(376.63,11.88) 376.65,11.9 C95946.2 376.36,12.56 376.08,12.83 C96250.1 ; C95729.2 182.14,176.79 181.79,176.43 v4(180.85,176.43) ; 233.7,65.88 233.09,65.27 v1(232.66,65.27) ; 32.33,39.23 C94632.1 ; 32.33,39.23 32.74,39.64 32.74,40.68 v1(32.81,40.76) ; C96156.2 v1(206.65,154.41) ; C96100.2 207.79,125.95 v1(207.16,126.58) ; C95730.2 170.68,177.48 v4(171.72,176.43) ; R67185.1 363.76,33.88 363.22,33.35 v1(363.22,32.05) ; v4(136.99,178.08) 137.79,178.88 C95758.2 ; C96125.2 127.29,176.5 v4(127.29,176.51) ; v1(28.37,24.73) 28.88,24.21 C94945.1 ; R20863.2 352.19,58.39 v1(351.75,58.83) ; v1(115.2,146.91) C96042.2 ; v1(185.64,146.12) 185.57,146.19 C95103.2 ; C94051.1 v1(38.4,35.75) ; v4(116.52,142.41) 115.79,141.69 C96117.2 ; C96114.2 v1(115.22,144.5) ; 153.33,58.44 v1(153.26,58.44) ; C94918.2 222.15,65.28 v1(222.14,65.27) ; v4(181.65,171.05) 181.65,171.31 182.14,171.8 R21867.1 ; R21868.1 v1(199.34,162.93) ; v1(367.96,34.28) 368.23,34.28 R67144.2 ; D13047.2 376.55,19.52 376.73,19.7 v1(376.93,19.7) ; R21705.2 v1(362.33,49.63) ; C96243.2 v1(39.24,48.91) ; C96246.2 v1(37.15,48.91)
  BOTTOM w0.406: v4(119.2,153.63) 119.2,154.23 C95085.2 ; v4(139.06,165.42) 139.14,165.42 139.16,165.4 C95756.2 ; C95087.2 203.61,144.32 v4(203.59,144.3) ; v4(205.99,144.3) 206.1,144.4 C95676.2 ; C95769.2 138.49,174.11 v4(138.21,173.83) ; v4(156.57,174.16) 156.82,173.91 C95775.2 ; C95750.2 205.97,160.66 v4(205.85,160.54) ; C95809.2 130.56,123.49 v4(130.35,123.28) ; v1(120.78,136.74) R21875.1 C95811.2 ; v4(177.22,178.39) 176.77,178.84 C95718.2 ; C95710.2 197.71,126.44 197.23,125.95 v4(197.23,125.78) ; C95777.2 144.79,173.22 v4(145.25,172.76) ; v4(126.41,123.3) 126.55,123.16 C95808.2 ; C95714.2 181.27,178.57 v4(181.46,178.38) ; v4(129.8,132.01) 130.34,131.47 C95797.2 ; C95814.2 126.91,141.45 126.46,141.9 v4(126.46,142.03) ; v4(198.31,124.57) 198.68,124.93 R21863.1 ; v4(206.07,133.03) 205.85,132.81 C95677.2 ; v4(125.29,153.46) 125.13,153.62 C95815.2 ; R21861.1 202.46,132.62 v4(202.05,133.03) ; C95727.2 170.21,167.14 v4(170.3,167.23) ; v4(117.1,134.59) 116.7,134.99 C95807.2 ; C95798.2 130.07,134.28 v4(129.34,133.55) ; v4(145.73,175.13) 144.98,175.89 C95776.2 ; v4(197.12,114.39) 196.77,114.04 C95696.2 ; v4(138.26,173.04) 138.48,172.82 R67200.1 ; C95795.2 116.08,122.69 v4(115.37,123.4) ; C95828.2 128.15,142.74 128.02,142.88 v4(128.02,143.46) ; v4(146.88,163.6) 147.11,163.37 C95789.2 ; C95790.2 147.36,178.15 v4(147.51,178.01) ; v4(156.57,165.67) 157.09,165.67 157.37,165.95 C96089.2 ; v4(197.08,149.49) 196.91,149.32 C95736.2 ; v4(116.8,153.5) 117,153.7 C95830.2 ; C96139.2 149.91,178.89 v4(149.91,178.01) ; C95709.2 193.85,126.25 194.36,125.74 v4(194.36,125.5) ; v4(127.02,164.43) 126.62,164.03 C95754.2 ; C95737.2 192.37,149.4 v4(192.28,149.49) 191.74,150.03 C95735.2
  BOTTOM w0.508: v1(207.23,139.08) 207.41,139.08 208.5,140.17 C96211.2 ; v1(370.06,28.47) 370.29,28.47 370.61,28.15 C96018.2 ; C94526.2 232.96,111.43 v1(232.96,111.26) ; Q7901.1 216.05,167.19 216.05,166.95 v1(216.02,166.92) ; v1(132.56,113.1) 132.22,112.76 R21578.1 ; v1(268.09,101.29) 267.85,101.29 R181.2 ; v1(243,111.28) 243,111.43 243.42,111.84 C94524.2 ; v1(242.54,51.99) 242.44,52.09 R21409.2 ; v1(216.26,77.03) 216.25,77.04 216.11,77.04 215.82,77.33 C95911.2 ; C94765.2 231.03,169.46 v1(230.27,168.7) ; v1(163.24,60.28) 163.5,60.28 163.82,59.96 PC9081.2 ; C95524.1 25.67,81.7 24,80.03 v1(23.49,80.03) ; PC108.2 105.66,58.77 v1(105.18,58.28) 105.76,57.7 PC106.2 ; v1(41.65,77.39) PC147.2 ; v1(251.61,165.75) 251.48,165.88 v1(251.48,167.2) R20972.1 ; v1(129.1,114.6) 129.07,114.63 Q7864.1 ; C96219.1 189.96,61.36 189.55,61.76 v1(189.02,61.76) ; v2(297.25,67.07) 297.26,67.06 297.88,67.06 C94842.2 ; PC9403.2 256.44,148.1 v1(257.02,148.1) ; C94643.2 192.46,67.54 192.98,68.06 v1(192.98,68.44) ; R21685.2 27.63,48.4 v1(27.96,48.73) ; v1(67.11,44.89) 67.11,45.16 66.89,45.38 C95593.1 ; v1(313.65,74.66) 313.65,75.01 314.29,75.66 R21276.2 ; v1(133.71,64.78) PR124.2 ; C94992.2 v1(359.9,66.63) ; v1(185.91,64.69) C96218.2 ; v1(183.2,78.17) 183.01,77.98 PC2038.2 ; R20942.1 341.27,85.31 v1(340.76,85.82) 340.25,85.31 R20940.1 ; R21258.2 314.37,77.44 v1(314.52,77.28) ; R21679.2 26.45,45.92 26.31,46.07 v1(26.31,46.17) ; C887.2 192.08,60.98 191.66,61.39 v1(191.66,61.43) ; v3(94.91,76.33) PC9380.2 ; PR2031.2 v1(178.56,85.39) ; v1(139.01,66.54) 138.46,65.99 PR9021.2 ; R812.2 178.02,53.77 174.54,53.77 v1(174.49,53.81) ; v1(53.73,76.94) 53.73,76.7 53.46,76.44 C95935.2 ; Q7823.1 v1(356.15,93.99) ; C94886.2 265.87,56.31 v1(265.96,56.4) ; v1(67.74,21.15) 67.84,21.25 R21739.1 ; D8567.2 126.93,56.4 v1(126.12,55.59) ; v1(27.58,82.5) 27.99,82.91 C96023.1 ; v1(174.34,81.8) PC2021.2 ; C95573.1 56.68,36.68 v1(56.81,36.54) ; v1(262.94,56.94) 262.93,56.95 C95912.2 ; v1(145.05,62.78) 145.05,63.26 144.37,63.95 PR9023.2 PR9024.2 ; C94645.2 194.34,53.59 194.08,53.33 194.08,52.8 v1(194.36,52.52) ; R21533.2 150.73,109.35 v1(150.24,109.85) ; C94530.2 248.06,111.98 248.49,111.55 v1(248.49,111.25) ; R20915.1 331.95,77.28 v1(331.97,77.26) ; R67326.1 125.75,113.63 125.42,113.3 v1(125.19,113.3) ; v2(307.26,59.88) 307.26,60.43 C94836.2 ; PR207.2 67.17,58.38 v1(67.17,58.53) ; v1(192.02,133.34) C95689.2 ; D13042.2 v1(378.35,16.22) ; v1(58.92,52.29) R21949.2 ; R193.1 225.72,96.33 v1(225.36,95.97) 225.31,95.92 224.46,95.92 C94521.2 ; R21581.1 138.65,119.68 138.32,119.35 v1(138.04,119.35) ; v1(328.95,64.41) 328.19,65.17 R21277.2 ; C94529.2 225.62,94.05 v1(225.42,94.25) C94525.2 ; v1(30.09,55.46) 30.5,55.06 C95895.2 ; C95526.2 26.94,81.73 v1(27.68,80.99) ; Q7945.1 129.83,117.51 v1(129.66,117.34) ; R21557.1 146.32,100.55 146.83,101.06 v1(146.83,101.13) 146.41,101.56 R21529.1 R21530.1 ; v1(121.13,112.87) 121.43,112.56 121.56,112.56 Q7866.1 ; SW1.4 v1(28.97,56.99) ; C94784.1 255.38,51.05 255.65,51.32 v1(255.65,51.73) ; PC9397.2 244.38,149.03 v1(244.27,148.91) ; C94951.2 v1(15.67,30.17) ; v1(126.97,118.97) 127.43,118.51 127.43,117.87 Q7865.1 ; R22068.1 354.26,90.02 354.55,89.73 v1(354.55,89.45) ; C96215.2 127.9,178.65 v1(128.16,178.91) ; PR2033.2 174.31,77.89 v1(174.01,78.2) ; PR2019.1 v1(182.16,85.31) ; R21612.2 116.23,120.11 v1(116.73,119.6) ; SW1.3 v1(26.02,57.15) ; v1(372.07,34.26) 371.52,33.71 C96019.2 ; PR206.2 PC8.1 74.82,59.32 74.82,58.77 v1(74.68,58.63) ; v1(365.63,63.01) 365.91,62.72 SPAD13.1 ; v1(183.26,59.96) 183.61,59.96 184.05,60.4 C890.1 ; SPAD17.1 373.03,28.55 373.02,28.56 ; C95690.2 191.8,144.41 v1(191.96,144.25) ; v1(174.49,79.39) 174.98,79.87 PC2022.2 ; v1(207.79,151.86) 207.7,151.77 C96212.2 ; v1(273.04,165.29) 272.74,164.99 PC5590.1 ; C95934.2 56.84,74.77 v1(57.35,74.26) ; v3(189.5,170.91) 189,170.91 188.73,171.17 Q7877.1 ; v4(178.25,164.73) 177.88,164.37 C95716.2 ; v1(155.85,103.72) C95067.2 ; R20914.1 332.96,75.49 U13079.43 ; C94704.1 356.78,77.94 v1(356.97,78.12) ; R21465.2 24.66,39.32 24.66,39.74 v1(24.33,40.07) ; R21086.2 302.46,57.91 v2(302.48,57.9) ; Q7853.1 130.87,117.55 v1(130.63,117.31) 130.63,117.24 130.2,116.81 C95080.1 ; v1(352.06,82.39) C95899.2 ; v1(311.23,75.77) 310.53,75.77 R21259.2 ; v1(249.14,57.07) 250.02,57.07 C94887.2 ; PC107.2 105.56,60.09 105.51,60.04 105.48,60.04 v1(105.13,59.68) ; L14.1 190.43,58.03 190.47,58 v1(190.47,57.6) ; R67136.2 366.39,25.1 365.53,24.25 v1(365.4,24.25) ; R21171.2 v1(291.35,87.29) ; v1(172.61,178.4) 172.06,178.95 C96213.2 ; PC19.2 79.03,59.02 78.19,58.19 v1(77.28,58.19) 77.07,58.19 76.61,57.73 PC9.2 ; C94625.2 384.07,45.69 ; v1(217.42,165.62) 217.22,165.82 R22137.1 ; v1(340.13,87.19) 339.63,86.69 Q7820.1 ; v1(336.44,77.56) 336.16,77.28 335.27,77.28 334.84,77.72 R20917.1 ; C95694.2 205.84,125.5 v4(205.85,125.49) ; C96216.2 114.2,152.37 v1(114.07,152.24) ; R22070.1 355.11,80.56 354.76,80.2 v1(354.76,79.8) ; v1(196.62,50.66) 196.62,51.31 196.24,51.69 R67319.1 ; C94881.2 273.49,54.73 v1(272.93,55.29) ; v1(155.1,102.97) C95016.1 ; R21532.1 150.92,108.09 151.24,108.41 v1(151.68,108.41) ; C94644.1 183.35,68.01 D13087.2 182.8,68.6 v1(182.52,68.88) ; Q7867.1 122.84,116.44 123.64,117.24 123.64,117.64 124,118 v1(124.48,118) ; D13057.2 D13059.2 D13058.2 89.03,76.68 v1(89.28,76.93) ; C94791.2 v1(138.84,59.27) ; v4(130.35,123.28) 130.35,122.87 C95794.2 ; PC16.2 77.03,52.8 v1(77.66,53.43) ; v1(65.6,52.37) 65.4,52.57 PC18.1 ; v1(378.4,17.97) 378.68,18.25 378.68,18.69 D13048.2 D13046.2 ; v1(207.56,116.37) 206.97,115.78 C96210.2 ; v1(250.33,113.32) 250.28,113.27 C94522.2 ; PC2026.2 180.6,76.26 v3(181.02,75.84) ; v1(51.53,48.66) 51.22,48.97 C95862.1 ; v1(68.53,35.79) C689.2 ; v1(39.49,77.41) PC146.2 ; U13025.42 333.99,58.16 R20835.2 ; v1(40.58,77.36) PC145.2 ; v1(135.35,70.58) 135.78,70.58 136.19,70.17 PC9005.2 137.14,69.82 PC9004.2 ; HOLE10.1 5,4.63 ; v1(295.78,51.58) 295.78,51.3 295.58,51.11 C96166.2 ; v1(175.22,76.99) 175.27,76.94 PC2034.2 ; C94837.2 303.7,69.71 v2(303.7,69.71) ; C96214.2 152.5,178.81 v1(152.17,178.48) ; v1(359.57,80.18) 359.49,80.1 C94683.1 ; v1(179.7,59.22) 179.27,58.79 R815.1 ; C94528.2 252.56,111.75 v1(253.08,111.23) ; v1(141.5,63.67) PR9025.2 141.94,64.35 142.03,64.25 142.38,64.25 PC9014.2 ; v1(69.03,60.58) 68.63,60.58 PR205.2 ; 286.6,89.77 HOLE12.1 ; C96228.1 C96230.1 42.83,44.45 v1(43.15,44.77) ; v1(132.98,115.78) R21567.2 ; v1(196.03,57.5) 196.03,57.88 195.7,58.21 194.58,58.21 193.56,57.18 R20893.2 ; D8566.2 128.33,53.52 129.1,52.75 v1(129.1,51.11) ; C961.2 384.07,41.36 ; 103.07,89.96 HOLE2.1 ; v1(135.53,117.26) R21575.2 ; C96217.2 v1(114.37,124.27)
  BOTTOM w0.61: PC9375.2 92.72,81.77 v1(92.27,81.32)
  vias: v1(1.04,65.24) v1(1.04,52.04) v1(1.04,47.97) v1(1.04,35.91) v1(0.99,33.75) v1(1.04,4.41) v1(2.05,46.07) v1(2.31,53.94) v1(2.69,64.1) v1(3.07,66.13) v1(3.7,35.91) v1(4.59,46.07) v1(4.85,53.94) v1(5.23,64.1) v1(6.24,60.93) v1(6.24,58.39) v1(6.24,41.49) v1(6.24,38.95) v1(6.5,36.41) v1(6.62,44.16) v1(6.75,55.46) v1(7.26,66.13) v1(8.2,49.57) v1(9.29,89.37) v1(9.67,67.02) v1(10.05,69.82) v1(10.18,87.72) v1(10.43,0.98) v1(10.69,85.69) v1(12.34,95.47) v1(12.97,0.98) v1(13.08,51.78) v1(13.05,49.62) v1(13.69,67.45) v1(14.24,85.69) v1(14.35,4.23) v1(14.5,70.2) v1(14.83,86.66) v1(14.88,95.47) v1(15.06,67.81) v1(15.31,51.53) v1(15.26,49.34) v1(15.34,40.61) v1(15.64,36.8) v1(15.9,85.69) v1(16.02,4.28) v1(17.04,70.2) v1(17.42,95.47) v1(17.8,48.63) v1(17.8,40.12) v1(18.03,45.66) v1(18.44,85.69) v1(18.38,44.57) v1(19.4,40.68) v1(19.96,95.47) v1(20.09,84.29) v1(20.09,71.72) v1(22.5,95.47) v1(22.93,38.62) v1(22.96,40.86) v1(23.21,49.93) v1(25.04,95.47) v1(25.6,8.7) v1(26.44,11.52) v1(26.44,8.98) v1(26.44,6.93) v1(26.72,94.5) v1(27.33,46.68) v1(27.35,50.84) v1(27.58,95.47) v1(27.71,13.3) v1(27.96,33.11) v1(27.96,31.33) v1(27.96,29.56) v1(27.96,16.48) v1(28.6,50.84) v1(28.6,46.7) v1(29.13,30.29) v1(29.18,75.91) v1(29.31,20.44) v1(29.31,19.7) v1(29.74,33.37) v1(29.74,31.46) v1(29.81,91.46) v1(29.89,73.91) v1(29.87,29.56) v1(30.86,61.36) v1(30.88,59.3) v1(31.14,95.47) v1(31.64,31.46) v1(31.64,29.56) v1(32.79,24.35) v1(32.94,48.15) v1(32.86,45.05) v1(33.01,61.36) v1(33.04,59.38) v1(33.68,95.47) v1(33.93,47.08) v1(34.74,42.69) v1(34.82,41.16) v1(36.04,24.25) v1(36.22,95.47) v1(36.49,41.11) v1(37.84,24.88) v1(38.76,95.47) v1(39.52,24.22) v1(40.61,24.07) v1(40.69,69.91) v1(40.98,91.39) v1(42.21,33.52) v1(42.69,93.69) v1(42.79,24.27) v1(43.94,87.34) v1(43.94,25.32) v1(44.44,42.84) v1(44.47,91.91) v1(44.52,29.43) v1(44.88,25.39) v1(45.18,29.58) v1(45.74,36.92) v1(45.82,42.79) v1(46.3,57.65) v1(46.38,90.01) v1(46.58,25.59) v1(46.78,69.99) v1(46.91,24.93) v1(47.21,55.01) v1(47.24,25.57) v1(47.34,68.98) v1(47.7,32.27) v1(47.77,36.29) v1(48.28,88.48) v1(48.74,67.33) v1(48.71,66.39) v1(50.19,87.09) v1(50.16,20.82) v1(50.82,20.69) v1(51.71,15.71) v1(51.96,16.86) v1(52.22,85.82) v1(52.22,13.55) v1(52.52,40.94) v1(52.67,51.76) v1(53.49,47.08) v1(53.49,44.92) v1(53.74,13.55) v1(54.12,16.98) v1(54.22,51.73) v1(54.25,15.71) v1(54.5,84.67) v1(54.55,70.32) v1(55.21,69.05) v1(55.21,68.37) v1(55.52,45.94) v1(55.6,51.68) v1(55.93,21.17) v1(56,20.51) v1(56.28,83.91) v1(56.59,21.23) v1(56.84,41.29) v1(56.97,54.83) v1(57.55,47.08) v1(57.55,44.8) v1(57.7,69.33) v1(57.86,41.19) v1(58.31,83.02) v1(58.95,35.02) v1(58.95,33.11) v1(59.23,25.39) v1(60.37,41.27) v1(60.98,34.13) v1(61.59,25.01) v1(61.74,49.5) v1(62.22,58.03) v1(62.43,28.46) v1(62.58,29.51) v1(62.86,48.05) v1(63.01,33.11) v1(62.96,30.04) v1(63.09,28.57) v1(63.67,24.88) v1(64.51,28.64) v1(64.71,79.39) v1(65.15,24.73) v1(66.95,35.78) v1(67.2,29.81) v1(67.18,24.71) v1(67.25,79.47) v1(67.89,27.63) v1(68.04,29.94) v1(68.09,30.7) v1(68.63,27.07) v1(68.6,26.03) v1(68.78,29.94) v1(69.24,43.65) v1(69.16,30.85) v1(69.49,29.94) v1(69.51,23.41) v1(71.14,42.64) v1(71.06,31.79) v1(72.97,79.34) v1(73.12,59.78) v1(73.38,66.97) v1(74.29,32.02) v1(74.29,31.36) v1(74.98,32.02) v1(75,31.36) v1(75.13,78.07) v1(75.05,74.54) v1(75.61,59.61) v1(75.97,81.12) v1(76.98,72.86) v1(77.13,71.52) v1(77.49,34.51) v1(77.49,26.25) v1(77.49,23.71) v1(77.49,21.17) v1(77.49,19.9) v1(77.74,36.16) v1(79.01,81.63) v1(79.52,37.81) v1(81.43,66.18) v1(81.68,38.57) v1(82.16,78.99) v1(83.21,82.77) v1(83.59,39.34) v1(83.76,47.34) v1(84.25,81.59) v1(85.49,40.1) v1(85.62,83.53) v1(86.91,74.41) v1(87.52,40.99) v1(87.78,84.42) v1(89.43,41.75) v1(89.68,43.68) v1(89.81,85.44) v1(91.46,42.51) v1(91.97,86.58) v1(93.57,44.85) v1(93.75,43.27) v1(94,87.85) v1(94.23,44.85) v1(94.89,44.85) v1(95.55,44.85) v1(95.91,89.25) v1(96.21,44.85) v1(96.29,43.27) v1(96.9,44.85) v1(98.52,55.85) v1(98.83,43.27) v1(99.18,55.85) v1(99.36,53.15) v1(99.72,45.05) v1(101.42,46.12) v1(101.87,70.93) v1(103.91,96.87) v1(103.96,46.12) v1(104.9,66.79) v1(105.56,99.15) v1(106.5,46.12) v1(107.84,71.09) v1(108.35,70.65) v1(109.04,62.45) v1(109.04,55.24) v1(109.04,46.12) v1(109.11,61.69) v1(109.37,55.87) v1(110.05,55.85) v1(111.58,46.12) v1(113.05,119.12) v1(113.05,118.46) v1(113.05,117.14) v1(113.05,116.42) v1(113.05,115.1) v1(113.05,114.39) v1(113.05,113) v1(113.05,112.23) v1(113.05,111.09) v1(113.15,82.8) v1(113.43,167.73) v1(113.94,168.32) v1(114.12,46.12) v1(114.24,119.83) v1(114.62,167.73) v1(114.83,174.59) v1(114.9,76.24) v1(114.9,75.48) v1(115.29,168.34) v1(115.59,87.47) v1(115.67,76.24) v1(115.67,75.48) v1(115.77,170.35) v1(115.95,167.76) v1(116.48,168.34) v1(116.66,46.12) v1(117.16,81.42) v1(119.2,46.12) v1(120.64,58.56) v1(121.74,46.12) v1(122.58,182.21) v1(122.83,107.61) v1(124.1,60.67) v1(124.07,55.59) v1(124.2,70.32) v1(124.28,46.12) v1(124.86,70.32) v1(125.12,179.67) v1(126.82,46.12) v1(126.89,67.28) v1(126.89,65.75) v1(127.58,66.51) v1(127.96,89.32) v1(128.29,66.01) v1(128.42,67.28) v1(129.36,46.12) v1(130.75,83.74) v1(131.34,56.48) v1(131.9,46.12) v1(132.35,83.07) v1(132.35,82.41) v1(132.35,81.75) v1(132.35,81.09) v1(133.12,83.79) v1(133.12,83.13) v1(133.12,82.47) v1(133.12,81.8) v1(133.12,81.14) v1(133.12,80.43) v1(133.5,95.83) v1(134.61,73.19) v1(135.2,95.01) v1(135.2,94.25) v1(135.2,93.49) v1(135.2,92.73) v1(135.3,83.38) v1(135.35,54.78) v1(135.66,123.28) v1(135.96,95.77) v1(135.96,95.01) v1(135.96,94.25) v1(135.96,93.49) v1(135.96,92.73) v1(136.42,123.26) v1(137.28,93.84) v1(138.32,88.36) v1(138.53,125.57) v1(138.84,121.5) v1(139.59,121.23) v1(141.24,70.07) v1(141.24,69.05) v1(141.24,68.04) v1(142.26,70.07) v1(142.26,69.05) v1(142.26,68.04) v1(143.28,70.07) v1(143.28,69.05) v1(143.28,68.04) v1(148.56,60.75) v1(149.18,55.03) v1(150.48,55.06) v1(151.41,54.98) v1(151.56,107.26) v1(152.73,54.98) v1(152.88,70.98) v1(153.12,73.5) v1(153.49,72.88) v1(153.78,73.5) v1(153.79,72.25) v1(153.97,54.98) v1(154.15,72.88) v1(154.44,73.5) v1(154.45,72.25) v1(154.81,72.88) v1(155.1,73.5) v1(155.11,72.25) v1(155.21,112.01) v1(155.47,72.88) v1(155.54,59.17) v1(155.8,97.6) v1(155.77,73.5) v1(155.87,112.46) v1(156.13,72.88) v1(156.2,59.17) v1(156.26,54.98) v1(158.01,54.98) v1(158.8,107.89) v1(159.58,46.12) v1(160.8,106.11) v1(161.74,73.17) v1(162.12,46.12) v1(162.4,47.62) v1(162.5,111.4) v1(162.86,106.52) v1(162.86,104.51) v1(164.08,106.75) v1(164.08,104.74) v1(164.13,58.21) v1(164.4,73.5) v1(164.61,71.01) v1(164.66,46.12) v1(165.06,73.5) v1(165.11,72.63) v1(165.37,105.63) v1(165.37,103.6) v1(165.72,73.5) v1(165.77,72.63) v1(166.38,73.5) v1(166.43,72.63) v1(167.04,73.5) v1(167.13,111.38) v1(167.09,72.63) v1(167.2,46.12) v1(167.33,106.39) v1(167.7,73.5) v1(167.75,72.63) v1(169.31,66.39) v1(169.44,106.61) v1(169.44,104.61) v1(169.41,73.24) v1(169.64,74.16) v1(169.74,46.12) v1(169.82,111.22) v1(170.05,66.39) v1(170.73,106.44) v1(170.71,104.46) v1(170.71,66.39) v1(171.04,112.06) v1(172.23,46.32) v1(173.25,110.33) v1(174.01,101.87) v1(174.34,108.83) v1(174.39,111.75) v1(174.77,46.32) v1(177.31,46.32) v1(178.33,86.2) v1(178.58,81.12) v1(178.58,80.1) v1(178.76,105.15) v1(179.34,45.05) v1(179.6,81.12) v1(180.36,43.27) v1(182.65,83.71) v1(182.9,43.27) v1(185.44,43.27) v1(187.95,173.42) v1(187.98,43.27) v1(188.84,83.38) v1(190.52,43.27) v1(191.1,112.18) v1(193.06,43.27) v1(193.31,182.08) v1(193.85,109.97) v1(195.6,43.27) v1(195.85,182.08) v1(195.85,90.52) v1(196.62,91.18) v1(196.62,90.52) v1(198.14,43.27) v1(198.39,182.08) v1(200.38,53.81) v1(200.68,43.27) v1(200.93,182.08) v1(201.06,53.81) v1(201.75,53.81) v1(202.41,53.86) v1(202.79,52.49) v1(203.25,75.78) v1(203.22,43.27) v1(203.47,182.08) v1(205.76,43.27) v1(206.01,182.08) v1(206.27,172.66) v1(206.8,61.66) v1(206.88,62.65) v1(206.88,61) v1(206.9,60.34) v1(206.9,59.68) v1(206.85,57.55) v1(207.08,56.94) v1(207.16,103.78) v1(207.54,181.07) v1(208.71,101.95) v1(209.21,103.75) v1(209.52,164.13) v1(209.52,163.29) v1(210.13,107.18) v1(211.3,106.01) v1(211.81,77.26) v1(211.88,76.57) v1(211.86,72.1) v1(212.41,75.73) v1(213.2,126.28) v1(213.38,181.07) v1(213.63,146.4) v1(213.61,72.56) v1(213.61,68.72) v1(213.61,59.53) v1(213.68,145.74) v1(213.68,145.08) v1(214.04,116.3) v1(214.09,126.41) v1(214.14,123.38) v1(214.12,119.55) v1(214.24,124.71) v1(214.35,121.52) v1(214.4,118.3) v1(215.03,181.96) v1(215.13,180.13) v1(216.02,116.3) v1(216.17,126.28) v1(216.2,72.28) v1(216.2,69.94) v1(216.3,119.52) v1(216.4,118.3) v1(216.35,59.36) v1(217.22,124.73) v1(217.39,167.1) v1(217.55,136.44) v1(217.57,181.96) v1(218.18,71.7) v1(218.21,68.57) v1(218.45,59.39) v1(219.4,98.42) v1(219.53,167.1) v1(219.63,72.71) v1(219.6,70.07) v1(219.63,68.67) v1(219.83,165.62) v1(219.83,60.19) v1(219.83,57.6) v1(220.11,181.96) v1(221.69,152.39) v1(221.94,167.12) v1(221.94,165.65) v1(222.14,73.22) v1(222.14,71.87) v1(222.14,70.04) v1(222.14,68.65) v1(222.17,60.45) v1(222.17,59.1) v1(222.4,127.27) v1(222.73,139.28) v1(222.83,140.71) v1(222.75,138.5) v1(222.96,127.63) v1(223.31,139.59) v1(223.26,138.9) v1(223.26,138.09) v1(223.29,135.98) v1(223.29,135.22) v1(223.29,134.46) v1(223.95,72.43) v1(223.95,70.15) v1(223.92,68.77) v1(224.2,59.61) v1(224.58,167.2) v1(224.58,165.62) v1(225.27,71.19) v1(225.27,68.47) v1(225.52,58.51) v1(226.99,167.2) v1(227.02,165.6) v1(226.97,43.27) v1(227.12,69.64) v1(227.17,72.46) v1(227.17,59.46) v1(228.75,181.96) v1(228.95,59.51) v1(228.98,58.19) v1(229.13,43.27) v1(229.23,72.71) v1(229.33,143.78) v1(229.26,71.31) v1(230.02,143.78) v1(230.19,51.88) v1(230.32,57.67) v1(230.42,72.89) v1(230.45,70.22) v1(230.42,68.7) v1(230.63,60.19) v1(230.8,53.13) v1(230.91,51.88) v1(231.16,121.38) v1(231.29,181.96) v1(231.67,43.27) v1(231.92,121.84) v1(232.61,72.64) v1(232.61,71.31) v1(232.58,68.62) v1(232.63,58.26) v1(232.66,59.66) v1(233.19,162.14) v1(233.19,141.7) v1(233.37,143.45) v1(233.57,51.88) v1(233.83,181.96) v1(234.21,43.27) v1(235.05,121.81) v1(235.05,117.97) v1(235.04,116.57) v1(235.1,123.23) v1(235.07,121.15) v1(235.07,120.49) v1(235.07,118.63) v1(235.1,117.31) v1(235.15,72.05) v1(235.26,58.37) v1(235.58,177.23) v1(236.27,102.63) v1(236.37,181.96) v1(236.75,43.27) v1(237.05,58.39) v1(237.18,69.41) v1(237.71,56.56) v1(238.91,181.96) v1(239.29,43.27) v1(239.69,59.4) v1(239.82,160.87) v1(239.87,159.91) v1(240.1,167.35) v1(240.05,113.63) v1(240.23,123.08) v1(240.18,121.66) v1(240.21,121) v1(240.21,120.34) v1(240.23,118.49) v1(240.21,117.83) v1(240.23,117.16) v1(240.23,116.42) v1(240.28,115.77) v1(240.31,115.11) v1(240.94,160.87) v1(241.45,181.96) v1(241.52,73.55) v1(241.62,70.98) v1(241.83,43.27) v1(242.21,57.14) v1(242.59,57.67) v1(243.58,152.21) v1(243.63,57.42) v1(243.66,69.92) v1(243.73,55.97) v1(243.99,181.96) v1(244.14,122.96) v1(244.09,121.53) v1(244.12,120.87) v1(244.12,120.21) v1(244.14,118.36) v1(244.12,117.7) v1(244.09,117.04) v1(244.14,116.3) v1(244.09,115.64) v1(244.12,114.98) v1(244.11,114.32) v1(244.37,43.27) v1(245.16,70.17) v1(245.43,57.01) v1(246.93,166.84) v1(246.91,43.27) v1(247.34,167.38) v1(247.29,123.26) v1(247.29,121.71) v1(247.29,121.05) v1(247.29,120.39) v1(247.29,118.58) v1(247.29,117.92) v1(247.29,117.26) v1(247.29,116.6) v1(247.29,115.94) v1(247.29,115.28) v1(247.37,68.85) v1(249.19,71.16) v1(249.45,167.38) v1(250.01,59.43) v1(250.24,156.07) v1(250.24,155.41) v1(250.24,154.75) v1(250.24,154.09) v1(250.24,153.36) v1(250.62,152.09) v1(250.71,72.71) v1(250.9,156.07) v1(250.9,155.41) v1(250.9,154.75) v1(251.01,123.23) v1(251.1,125.8) v1(251.1,121.66) v1(251.1,120.97) v1(251.1,120.31) v1(251.1,118.76) v1(251.1,118.1) v1(251.1,117.44) v1(251.1,116.78) v1(251.1,116.12) v1(251.1,115.46) v1(251.61,181.96) v1(251.84,59.02) v1(252.62,141.75) v1(253.26,76.72) v1(254.15,181.96) v1(255.77,72.69) v1(255.77,68.6) v1(255.77,59.69) v1(256.69,181.96) v1(256.94,153.59) v1(256.94,123) v1(256.94,114.88) v1(256.97,121.76) v1(256.97,121.1) v1(256.97,118.86) v1(256.97,118.2) v1(256.97,117.54) v1(256.97,116.88) v1(256.97,116.2) v1(256.97,115.54) v1(257.22,119.8) v1(257.63,118.89) v1(257.63,118.23) v1(257.63,117.57) v1(257.63,116.91) v1(257.63,116.22) v1(257.63,115.56) v1(257.6,114.9) v1(257.65,72.79) v1(257.68,68.62) v1(257.65,59.79) v1(258.31,157.8) v1(258.9,71.14) v1(258.9,68.14) v1(258.92,58.24) v1(259.1,173.07) v1(260.65,47.06) v1(260.67,48.53) v1(260.75,72.76) v1(260.78,68.55) v1(260.75,59.76) v1(261.18,100.78) v1(261.39,43.15) v1(262.15,48.53) v1(262.17,49.67) v1(262.53,59.71) v1(262.61,72.71) v1(262.63,68.55) v1(262.81,103.69) v1(263.6,49.67) v1(263.62,48.56) v1(263.62,47.06) v1(263.72,165.8) v1(263.88,73.4) v1(263.9,70.78) v1(263.93,43.4) v1(263.98,59.12) v1(264.1,154.6) v1(264.41,165.57) v1(264.43,164.08) v1(264.43,161.43) v1(264.51,162.65) v1(264.82,173.57) v1(265.37,147.06) v1(265.73,165.52) v1(265.65,150.11) v1(265.75,164.02) v1(265.78,162.7) v1(265.86,161.38) v1(265.86,72.69) v1(265.86,68.52) v1(265.86,59.69) v1(266.34,172.18) v1(266.47,43.4) v1(267.08,165.55) v1(267.1,164.05) v1(267.2,162.68) v1(267.41,161.41) v1(267.91,72.79) v1(267.89,68.62) v1(267.91,59.79) v1(268.35,165.57) v1(268.35,162.73) v1(268.37,164.08) v1(268.5,171.92) v1(268.47,161.41) v1(269.01,43.4) v1(269.13,68.14) v1(269.16,70.78) v1(269.23,58.77) v1(271.04,171.92) v1(271.11,72.69) v1(271.11,68.7) v1(271.11,59.69) v1(271.5,154.25) v1(271.55,43.4) v1(272.05,45.43) v1(272.74,146.65) v1(272.99,68.85) v1(273.04,59.71) v1(273.07,72.71) v1(273.27,146.73) v1(273.45,142.03) v1(273.58,171.92) v1(274.11,141.6) v1(274.11,140.94) v1(274.24,73.17) v1(274.21,46.07) v1(274.31,70.58) v1(274.37,60.16) v1(275.48,170.53) v1(275.48,167.99) v1(275.48,165.45) v1(275.48,162.91) v1(275.48,160.37) v1(275.48,157.83) v1(275.48,155.29) v1(275.48,152.75) v1(275.48,150.21) v1(275.48,147.67) v1(275.48,145.13) v1(276.45,72.53) v1(276.4,68.67) v1(276.45,59.53) v1(276.63,107.53) v1(276.75,46.07) v1(277.52,105.38) v1(278.66,103.22) v1(279.29,46.07) v1(279.93,101.31) v1(281.2,99.41) v1(281.83,46.07) v1(282.09,54.47) v1(282.72,97.5) v1(283.36,54.3) v1(284.12,95.85) v1(284.37,46.07) v1(284.63,61.21) v1(286.28,53.36) v1(286.28,45.3) v1(286.35,68.22) v1(286.53,43.27) v1(286.58,70.73) v1(287.45,58.79) v1(288.18,68.19) v1(288.64,70.88) v1(288.69,43.27) v1(289.73,65.98) v1(289.71,59.61) v1(289.76,67.1) v1(289.81,55.77) v1(290.29,52.11) v1(291.23,43.27) v1(291.38,52.7) v1(291.41,45.64) v1(291.74,79.98) v1(291.66,52.09) v1(292.32,52.21) v1(293.57,45.64) v1(293.77,43.27) v1(295.73,45.64) v1(296.31,43.27) v1(297.91,45.61) v1(298.85,43.27) v1(299.16,50.23) v1(301.39,43.27) v1(303.93,43.27) v1(306.47,43.27) v1(309.01,43.27) v1(311.55,43.27) v1(312.16,52.05) v1(314.09,43.27) v1(315.26,48.25) v1(316.58,48.86) v1(316.63,43.27) v1(319.17,43.27) v1(320.06,53.2) v1(320.82,53.2) v1(321.71,43.27) v1(324.25,43.27) v1(324.63,45.18) v1(326.28,46.32) v1(327.71,54.98) v1(328.82,46.32) v1(328.95,74.67) v1(330.07,84.52) v1(331.36,46.32) v1(333.01,47.84) v1(333.9,46.32) v1(335.07,47.84) v1(336.44,46.32) v1(338.6,90.26) v1(338.6,45.94) v1(339.36,43.27) v1(339.59,76.93) v1(339.59,66.56) v1(340,91.28) v1(340.25,76.93) v1(340.33,66.51) v1(340.33,64.2) v1(340.38,71.72) v1(340.48,67.53) v1(341.12,73.32) v1(341.4,92.29) v1(341.85,81.9) v1(341.9,43.27) v1(342.49,83.63) v1(342.79,93.56) v1(343.02,66.54) v1(343.68,65.88) v1(343.71,45.69) v1(344.19,94.83) v1(344.44,43.27) v1(344.49,66.11) v1(344.65,46.35) v1(345.16,66.08) v1(345.55,76.71) v1(345.58,71.13) v1(345.66,95.7) v1(345.82,66.06) v1(346.07,81.88) v1(346.43,75.65) v1(346.7,46.57) v1(346.98,43.15) v1(347.13,76.65) v1(347.64,44.42) v1(347.69,95.71) v1(348.91,71.37) v1(348.99,72.76) v1(349.4,42.51) v1(349.49,43.9) v1(349.8,95.72) v1(349.83,73.75) v1(349.91,46.07) v1(350.39,72.76) v1(350.41,71.34) v1(350.39,69.87) v1(351.18,43.17) v1(351.33,64.05) v1(351.25,44.21) v1(351.56,41.37) v1(351.81,72.76) v1(351.84,69.89) v1(351.9,95.72) v1(351.89,71.37) v1(352.11,46.5) v1(352.45,42.38) v1(353.36,79.87) v1(353.46,39.72) v1(353.84,95.72) v1(354.5,43.73) v1(355.19,48.07) v1(355.24,37.94) v1(355.62,95.72) v1(356.76,36.41) v1(357.47,95.72) v1(357.88,57.4) v1(358.29,55.31) v1(358.29,34.89) v1(359.43,95.72) v1(359.81,88.71) v1(359.94,33.24) v1(360.24,62.2) v1(360.52,88.71) v1(360.73,52.39) v1(360.78,78.4) v1(360.95,61.61) v1(361.21,62.24) v1(361.59,61.41) v1(361.59,31.59) v1(361.72,95.47) v1(361.82,62.02) v1(362.07,33.75) v1(362.2,34.46) v1(362.44,78.38) v1(362.48,80.86) v1(362.48,80.05) v1(362.48,79.21) v1(362.45,33.21) v1(362.48,29.18) v1(362.48,26.64) v1(362.48,24.1) v1(362.48,21.56) v1(362.48,19.02) v1(362.58,94.63) v1(362.99,17.62) v1(363.11,78.64) v1(363.47,62.2) v1(363.52,56.4) v1(363.77,58.44) v1(364.1,62.55) v1(364.13,16.98) v1(364.26,95.47) v1(364.38,15.59) v1(364.46,60.44) v1(364.51,58.38) v1(365.53,15.13) v1(366.16,50.38) v1(366.8,95.47) v1(367.05,49.09) v1(367.05,15.08) v1(367.3,48.48) v1(367.87,33.63) v1(367.99,37.86) v1(367.96,32.96) v1(368.62,40.71) v1(368.57,15.08) v1(369.34,95.47) v1(369.84,17.7) v1(370.1,14.82) v1(370.18,59.41) v1(370.2,40.61) v1(370.89,13.3) v1(370.89,10.76) v1(370.89,8.22) v1(371.01,5.27) v1(371.47,39.95) v1(371.88,95.47) v1(372.51,4.28) v1(373.53,85.56) v1(373.53,83.91) v1(373.71,35.54) v1(373.91,87.21) v1(374.42,95.47) v1(374.72,9.72) v1(375.1,68.62) v1(375.05,4.28) v1(375.25,88.61) v1(375.38,9.72) v1(375.94,68.8) v1(376.07,87.47) v1(376.24,35.4) v1(376.24,9.69) v1(376.91,88.71) v1(377.08,3.39) v1(377.72,68.8) v1(377.69,4.13) v1(378.61,87.47) v1(378.66,66.56) v1(378.68,39.72) v1(378.68,22.7) v1(378.99,68.8) v1(380,36.54) v1(380.18,37.28) v1(380.51,64.99) v1(380.64,57.88) v1(380.77,62.96) v1(380.77,60.42) v1(380.77,55.72) v1(381.45,9.44) v1(381.78,19.4) v1(382.04,15.59) v1(382.04,12.28) v1(382.21,7.43) v1(382.21,5.78) v1(382.54,65.62) v1(382.93,55.46) v1(384.07,68.8) v1(384.2,87.47) v1(384.45,65.62) v1(385.47,55.46) v1(385.97,68.42) v1(385.97,66.51) v1(385.97,53.69) v1(386.1,88.74) v2(152.72,140.46) v2(152.71,139.06) v2(152.71,137.66) v2(152.71,136.26) v2(152.71,134.86) v2(152.71,133.46) v2(152.71,130.66) v2(152.71,129.26) v2(152.71,127.86) v2(152.71,126.46) v2(152.71,125.06) v2(152.71,123.66) v2(153.41,140.46) v2(153.41,139.06) v2(153.41,137.66) v2(153.41,136.26) v2(153.41,134.86) v2(153.41,133.46) v2(153.41,130.66) v2(153.41,129.26) v2(153.41,127.86) v2(153.41,126.46) v2(153.41,125.06) v2(154.1,137.66) v2(154.81,140.46) v2(154.81,139.06) v2(154.81,137.66) v2(154.81,136.26) v2(154.81,134.86) v2(154.81,133.46) v2(154.81,130.66) v2(154.81,129.26) v2(154.81,127.86) v2(154.81,126.46) v2(154.81,125.06) v2(154.81,123.66) v2(155.52,139.06) v2(155.52,137.66) v2(156.21,139.06) v2(156.21,137.66) v2(156.21,136.26) v2(156.21,133.46) v2(156.21,129.26) v2(156.21,127.86) v2(156.21,126.46) v2(156.21,125.06) v2(156.21,123.66) v2(156.21,122.26) v2(157.54,122.16) v2(157.61,140.46) v2(157.61,139.06) v2(157.61,137.66) v2(157.61,136.26) v2(157.61,133.46) v2(157.61,129.26) v2(157.61,127.86) v2(157.61,126.46) v2(157.61,125.06) v2(157.61,123.66) v2(158.31,136.26) v2(158.31,134.86) v2(158.31,133.46) v2(158.31,132.06) v2(159.01,140.46) v2(159.01,139.06) v2(159.01,137.66) v2(159.01,134.86) v2(159.01,133.46) v2(159.01,132.06) v2(159.01,129.26) v2(159.01,127.86) v2(159.01,126.46) v2(159.01,125.06) v2(159.01,123.66) v2(159.01,122.26) v2(159.71,140.46) v2(159.71,139.06) v2(159.71,137.66) v2(159.71,136.26) v2(159.71,134.86) v2(159.71,133.45) v2(159.71,130.66) v2(159.71,129.26) v2(159.71,127.86) v2(159.71,126.46) v2(159.71,125.06) v2(159.71,123.66) v2(160.41,138.36) v2(160.41,134.16) v2(160.4,123.67) v2(161.11,134.16) v2(161.11,130.66) v2(161.81,139.06) v2(161.81,127.16) v2(162.51,140.46) v2(162.51,139.06) v2(162.51,137.66) v2(162.51,136.26) v2(162.51,134.86) v2(162.51,133.46) v2(162.51,132.06) v2(162.51,129.26) v2(162.51,127.86) v2(162.51,125.06) v2(162.51,123.66) v2(162.51,122.26) v2(163.21,140.46) v2(163.21,139.06) v2(163.21,137.66) v2(163.21,136.26) v2(163.21,134.86) v2(163.21,133.46) v2(163.21,130.66) v2(163.21,129.26) v2(163.21,127.86) v2(163.21,125.06) v2(163.22,123.66) v2(163.91,136.26) v2(163.9,131.36) v2(163.9,123.66) v2(164.61,140.46) v2(164.61,139.06) v2(164.61,137.66) v2(164.61,136.26) v2(164.61,134.86) v2(164.61,133.46) v2(164.61,126.46) v2(164.61,125.06) v2(164.61,123.66) v2(165.32,136.26) v2(165.3,131.36) v2(165.31,129.96) v2(165.31,125.06) v2(165.37,140.58) v2(166.01,140.46) v2(166.01,139.06) v2(166.01,137.66) v2(166.01,136.26) v2(166.01,134.86) v2(166.01,133.46) v2(166.01,126.46) v2(166.01,125.06) v2(166.01,123.66) v2(166.72,139.06) v2(166.71,136.26) v2(166.71,131.36) v2(166.71,129.26) v2(166.71,127.86) v2(166.71,126.46) v2(167.41,140.46) v2(167.41,139.06) v2(167.41,137.66) v2(167.41,136.26) v2(167.41,134.86) v2(167.41,133.46) v2(167.41,132.06) v2(167.41,129.26) v2(167.41,127.86) v2(167.41,126.46) v2(167.41,125.06) v2(167.41,123.66) v2(167.41,122.26) v2(168.12,140.45) v2(168.1,132.06) v2(168.81,140.46) v2(168.81,139.06) v2(168.81,137.66) v2(168.81,136.26) v2(168.81,134.86) v2(168.81,133.46) v2(168.81,132.06) v2(168.81,131.36) v2(168.81,129.26) v2(168.81,127.86) v2(168.81,126.46) v2(168.81,125.06) v2(168.81,123.66) v2(168.81,122.26) v2(169.51,140.45) v2(169.51,132.07) v2(170.21,140.46) v2(170.21,139.06) v2(170.21,137.66) v2(170.21,136.26) v2(170.21,134.86) v2(170.2,133.46) v2(170.21,132.06) v2(170.21,128.56) v2(170.21,123.66) v2(170.21,122.26) v2(170.91,121.51) v2(292.63,72) v2(298.26,62.34) v2(298.83,67.71) v2(302.53,70.4) v2(303.73,68.11) v2(304.82,70.58) v2(304.89,68.62) v2(304.89,68.01) v2(304.95,56.48) v2(306.04,68.74) v2(305.96,68.13) v2(308.11,72.12) v2(308.12,69.43) v2(308.93,69.65) v2(309.08,70.69) v2(310.05,70.22) v3(71.01,75.28) v3(71.01,74.51) v3(71.78,75.28) v3(71.78,74.51) v3(72.12,66.01) v3(72.12,65.25) v3(72.54,75.28) v3(72.54,74.51) v3(72.89,66.01) v3(72.89,65.25) v3(73.3,75.28) v3(73.3,74.51) v3(73.65,66.01) v3(73.65,65.25) v3(74.06,75.28) v3(74.06,74.51) v3(74.57,73.24) v3(75.33,73.24) v3(76.42,59.29) v3(76.6,60.04) v3(77.27,60.42) v3(77.3,59.66) v3(77.29,58.9) v3(78.07,60.8) v3(81.22,78.43) v3(82.32,66.64) v3(82.32,65.88) v3(83.08,66.64) v3(83.08,65.88) v3(83.84,66.64) v3(83.84,65.88) v3(88.03,74.61) v3(88.03,73.83) v3(90.57,75.15) v3(90.57,74.39) v3(91.21,81.35) v3(91.33,75.15) v3(91.33,74.39) v3(92.1,75.15) v3(92.1,74.39) v3(92.86,75.15) v3(92.86,74.39) v3(93.62,75.15) v3(93.62,74.39) v3(94.38,74.9) v3(94.89,74.34) v3(107.64,84.07) v3(107.64,83.3) v3(107.64,82.54) v3(108.4,84.07) v3(108.4,83.3) v3(108.4,82.54) v3(108.4,81.78) v3(109.16,84.07) v3(109.16,83.3) v3(109.16,82.54) v3(109.16,81.78) v3(109.65,102.86) v3(109.65,102.1) v3(109.93,84.07) v3(109.93,83.3) v3(109.93,82.54) v3(109.93,81.78) v3(110.31,103.27) v3(110.31,102.51) v3(110.69,83.3) v3(110.69,82.54) v3(110.69,81.78) v3(110.81,81.02) v3(111.45,82.54) v3(111.45,81.78) v3(111.58,81.02) v3(114.5,84.24) v3(114.5,83.48) v3(114.5,82.72) v3(115.26,84.24) v3(115.26,83.48) v3(115.26,82.72) v3(116.02,84.24) v3(116.02,83.48) v3(116.02,82.72) v3(116.78,84.24) v3(116.78,83.48) v3(116.78,82.72) v3(118.77,83.99) v3(118.77,83.23) v3(118.77,82.47) v3(118.77,81.7) v3(119.53,83.99) v3(119.53,83.23) v3(119.53,82.47) v3(119.53,81.7) v3(123.97,106.72) v3(123.97,105.96) v3(123.97,105.2) v3(124,104.33) v3(124,103.57) v3(124,102.81) v3(125.93,93.41) v3(125.93,92.65) v3(125.93,91.89) v3(125.93,91.13) v3(126.69,93.41) v3(126.69,92.65) v3(126.69,91.89) v3(126.69,91.13) v3(127.38,92.96) v3(127.38,92.19) v3(127.38,91.43) v3(127.38,90.67) v3(134.39,78.55) v3(134.39,77.79) v3(134.39,77.03) v3(134.39,76.27) v3(134.39,75.51) v3(134.39,74.74) v3(134.77,74.08) v3(135.15,77.79) v3(135.15,77.03) v3(135.15,76.27) v3(135.15,75.51) v3(135.15,74.74) v3(136.06,91.53) v3(136.06,90.77) v3(136.06,90.01) v3(136.06,89.25) v3(136.06,88.48) v3(136.06,87.72) v3(136.82,89.25) v3(136.82,88.48) v3(136.82,87.72) v3(137.69,88.71) v3(137.69,87.95) v3(157.2,99.33) v3(157.55,73.78) v3(158.01,99) v3(158.11,98.24) v3(158.31,99.69) v3(158.31,74.54) v3(158.31,73.78) v3(158.87,99.18) v3(158.87,98.42) v3(158.87,97.65) v3(159.07,75.3) v3(159.07,74.54) v3(159.07,73.78) v3(159.61,99) v3(159.61,98.24) v3(159.61,97.48) v3(159.84,75.3) v3(159.84,74.54) v3(159.84,73.78) v3(160.6,75.3) v3(160.6,74.54) v3(160.6,73.78) v3(161.36,75.3) v3(161.36,74.54) v3(161.36,73.78) v3(162.12,75.3) v3(162.12,74.54) v3(162.12,73.78) v3(169.67,99.38) v3(170.33,75.38) v3(170.33,74.62) v3(170.33,73.85) v3(170.43,99.38) v3(171.09,75.38) v3(171.09,74.62) v3(171.09,73.85) v3(171.85,75.38) v3(171.85,74.62) v3(171.85,73.85) v3(172.61,75.38) v3(172.61,74.62) v3(172.61,73.85) v3(173.38,75.38) v3(173.38,74.62) v3(173.38,73.85) v3(174.77,104.21) v3(175.58,104.11) v3(175.66,103.24) v3(175.86,104.87) v3(176.42,105.38) v3(176.4,104.03) v3(176.88,104.72) v3(177.08,103.62) v3(177.21,105.48) v3(177.64,104.84) v3(177.72,104.08) v3(178.4,104.54) v3(178.51,103.72) v3(178.68,86.99) v3(179.09,87.67) v3(179.24,104.51) v3(179.27,103.7) v3(179.45,86.99) v3(179.85,87.67) v3(180.21,86.99) v3(180.61,87.67) v3(180.97,86.99) v3(181.25,119.47) v3(181.38,87.67) v3(181.63,118.46) v3(181.76,86.99) v3(182.16,87.67) v3(182.57,86.99) v3(182.93,87.67) v3(183.15,118.33) v3(183.69,87.67) v3(183.84,84.55) v3(183.84,83.79) v3(184.45,87.67) v3(184.6,85.31) v3(184.6,84.55) v3(184.6,83.79) v3(185.21,87.67) v3(185.36,85.31) v3(185.36,84.55) v3(185.36,83.79) v3(185.47,116.15) v3(185.97,87.67) v3(186.74,87.65) v3(187.5,87.65) v3(188.26,87.65) v3(189.5,171.67) v3(192.34,177.57) v3(192.38,176.78) v3(193.21,177.46) v3(193.21,176.68) v3(198.78,103.47) v3(199.41,104.28) v3(199.54,103.47) v3(199.92,75.2) v3(200.2,104.03) v3(200.58,75.61) v3(202.23,96.1) v3(202.99,96.13) v3(203.35,97.63) v3(204.11,97.63) v3(204.74,100.19) v3(204.74,99.13) v3(214.14,137.25) v3(214.78,137.76) v3(214.78,136.74) v3(214.9,159.22) v3(215.67,159.99) v3(215.67,159.22) v3(216.43,159.99) v3(216.43,159.22) v3(221.23,150.99) v3(221.61,150.23) v3(229.69,163.62) v3(229.69,162.86) v3(230.45,163.62) v3(230.45,162.86) v3(230.68,142.84) v3(230.8,143.63) v3(231.21,163.62) v3(231.21,162.86) v3(231.16,144.59) v3(231.44,142.87) v3(231.57,143.63) v3(231.97,163.62) v3(231.97,162.86) v3(232.2,142.87) v3(232.33,143.63) v3(232.73,163.62) v3(232.73,162.86) v3(232.96,142.87) v3(233.14,161.43) v3(233.5,163.62) v3(233.5,162.86) v3(233.73,142.84) v3(233.9,161.43) v3(242.44,138.9) v3(242.44,138.14) v3(242.46,137.38) v3(242.46,136.62) v3(242.64,151.3) v3(242.64,150.54) v3(242.64,149.78) v3(242.67,152.06) v3(242.84,158.11) v3(242.84,157.34) v3(242.84,156.38) v3(242.82,155.24) v3(242.82,154.45) v3(242.82,153.64) v3(242.82,152.85) v3(243.2,138.93) v3(243.23,138.17) v3(243.33,155.79) v3(243.33,149.44) v3(243.38,150.97) v3(243.35,150.21) v3(243.48,154.04) v3(243.61,158.11) v3(243.61,157.34) v3(243.61,156.58) v3(244.04,141.98) v3(244.01,141.22) v3(244.04,140.45) v3(243.99,139.69) v3(243.96,138.93) v3(243.99,138.17) v3(244.37,158.11) v3(244.37,157.34) v3(244.72,138.93) v3(244.75,138.17) v3(249.63,150.54) v3(249.6,149.78) v3(249.6,149.01) v3(249.68,152.82) v3(249.68,152.06) v3(249.68,151.3) v3(249.98,156.79) v3(250.11,158.31) v3(250.11,157.55) v3(250.31,150.84) v3(250.31,150.08) v3(250.31,149.32) v3(250.79,156.79) v3(250.87,158.31) v3(250.87,157.55) v3(251.63,158.31) v3(251.63,157.55) v3(252.29,140.43) v3(252.37,138.14) v3(252.98,140.94) v3(253,140.17) v3(252.98,139.41) v3(253,138.65) v3(253.74,141.44) v3(253.74,139.92) v3(253.77,140.68) v3(253.77,139.16) v3(256.99,156.89) v3(256.99,149.62) v3(256.99,148.86) v3(257.07,152.8) v3(257.07,152.04) v3(257.07,151.27) v3(257.07,150.51) v3(257.73,150.89) v3(257.65,150) v3(257.65,149.24) v3(257.78,157.09) v3(257.75,156.23) v3(257.75,155.46) v3(257.75,154.7) v3(257.75,153.94) v3(257.75,153.18) v3(257.75,152.42) v3(257.75,151.65) v3(258.44,156.63) v3(258.44,155.87) v3(258.44,155.08) v3(264.74,155.79) v3(264.71,155.03) v3(264.74,154.27) v3(264.74,153.48) v3(264.74,152.72) v3(264.74,151.96) v3(264.74,151.2) v3(264.71,150.44) v3(264.71,149.67) v3(264.71,148.91) v3(264.71,148.15) v3(264.71,147.39) v3(265.45,155.54) v3(265.42,154.78) v3(265.45,153.99) v3(265.45,153.23) v3(265.45,151.71) v3(265.45,150.94) v3(265.42,148.66) v3(267.76,134.54) v3(267.76,133.77) v3(268.52,134.54) v3(268.52,133.77) v3(269.29,134.54) v3(269.29,133.77) v3(271.52,150.23) v3(272.18,155.95) v3(272.18,155.19) v3(272.18,154.42) v3(272.18,153.66) v3(272.18,152.9) v3(272.18,152.14) v3(272.18,151.38) v3(272.18,150.61) v3(272.18,149.85) v3(272.18,149.09) v3(272.18,148.33) v3(272.18,147.57) v3(272.94,155.95) v3(272.94,155.19) v3(272.94,154.42) v3(272.94,153.66) v3(272.94,152.9) v3(272.94,152.14) v3(272.94,151.38) v3(272.94,150.61) v3(272.94,149.85) v3(272.94,149.09) v3(272.94,148.33) v3(272.94,147.57) v4(118.87,150) v4(123.51,141.9) v4(123.85,135.17) v4(125.45,141.95) v4(125.65,135.2) v4(142.16,130.93) v4(144.34,150.71) v4(145.21,170.58) v4(145.22,168.76) v4(145.71,149.59) v4(147.05,150.2) v4(147.87,150.18) v4(160.76,152.84) v4(160.76,151.57) v4(162.22,153) v4(162.2,149.92) v4(165.91,151.07) v4(175.01,175.78) v4(179.94,123.6) v4(180.32,143.32) v4(180.83,142.55) v4(180.99,145.1) v4(181.59,143.32) v4(182.27,169.89) v4(193.7,114.48) v4(194.41,114.48) v4(198.78,161.18) v4(198.83,132.91) v4(199.08,125.72) v4(347.11,52.19) v4(347.14,49.6) v4(347.77,49.62) v4(348.42,48.98) v4(349.72,48.98) v4(350.37,48.98) v4(351.02,52.82) v4(351.67,49.59) v4(352.32,51.54) v4(352.98,56.1) v4(352.97,51.54) v4(352.98,48.96) v4(353.61,56.07) v4(353.62,51.54) v4(353.62,50.24)
