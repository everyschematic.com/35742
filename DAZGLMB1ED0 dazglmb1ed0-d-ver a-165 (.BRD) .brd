# Allegro board DAZGLMB1ED0 dazglmb1ed0-d-ver a-165 (.BRD) .brd (continued)
## Nets (continued)
VCC0P9_CIO: C94595.2 C94596.2 C94598.2 U21.R8(VCC0P9_CIO#3) U21.R9(VCC0P9_CIO#4) U21.R11(VCC0P9_CIO#1) U21.R12(VCC0P9_CIO#2)
VCC0P9_DP: C721.2 C94582.2 C94583.2 C94584.2 C94585.2 C94586.2 C94588.2 U21.L6(VCC0P9_ANA_DPSRC#1) U21.L8(VCC0P9_DP#3) U21.L11(VCC0P9_DP#1) U21.L12(VCC0P9_DP#2) U21.M6(VCC0P9_ANA_DPSRC#2) U21.M8(VCC0P9_DP#4) U21.T11(VCC0P9_DP#5) U21.T12(VCC0P9_DP#6) U21.V11(VCC0P9_ANA_DPSNK#1) U21.V12(VCC0P9_ANA_DPSNK#2) U21.V13(VCC0P9_ANA_DPSNK#3)
VCC0P9_LVR: C94615.2 C94616.2 C94617.1 C94618.1 U21.F18(VCC0P9_LVR#1) U21.H11(VCC0P9_LVR_SENSE) U21.H18(VCC0P9_LVR#2) U21.J11(VCC0P9_LVR#3)
VCC0P9_PCIE: C94589.2 C94590.2 C94591.2 C94592.2 C95993.2 U21.L18(VCC0P9_ANA_PCIE_2#1) U21.L19(VCC0P9_ANA_PCIE_1#1) U21.M13(VCC0P9_PCIE#1) U21.M15(VCC0P9_PCIE#2) U21.M16(VCC0P9_PCIE#3) U21.M18(VCC0P9_ANA_PCIE_2#2) U21.N18(VCC0P9_ANA_PCIE_2#3) U21.N19(VCC0P9_ANA_PCIE_1#2)
VCC0P9_SVR: C13393.1 C94606.2 C94607.2 C94608.2 C94609.2 C94610.2 C94611.2 C94612.2 C94613.1 C94614.1 L12.2 U21.E12(VCC0P9_SVR_ANA#1) U21.E13(VCC0P9_SVR_ANA#2) U21.F11(VCC0P9_SVR_ANA#3) U21.F12(VCC0P9_SVR_ANA#4) U21.F13(VCC0P9_SVR_ANA#5) U21.F15(VCC0P9_SVR_ANA#6) U21.J9(VCC0P9_SVR_SENSE) U21.L9(VCC0P9_SVR#1) U21.M9(VCC0P9_SVR#2)
VCC0P9_SVR_IND: L12.1 U21.C1(SVR_IND#1) U21.C2(SVR_IND#2) U21.D1(SVR_IND#3)
VCC0P9_USB: C94593.2 C94594.2 U21.R15(VCC0P9_USB#1) U21.R16(VCC0P9_USB#2)
VCC1V8A_TBTA_LDO: C96012.2 U13155.K1(LDO_1V8A)
VCC1V8D_TBTA_LDO: C96011.2 U13155.A2(LDO_1V8D)
VCC3V3_FLASH: C94182.2 C96016.1 R20852.1 R20853.1 R20854.2 R20855.2 R67115.1 R67127.2 R67139.2 R67140.2 R67179.2 U13076.8(VCC) U13155.G1(LDO_3V3)
VCC3V3_TBTA_SX: C96017.1 U13155.H2(VOUT_3V3)
VCCGT_CS1: PR66845.2 PR66951.1
VCCGT_CS2: PR66846.2 PR66954.1
VCCGT_CSUMB: PR66852.1 PR66860.2 PR66879.1
VCCIO_VCCSENSE: R20816.1 U41.H14(VCCIO_SENSE)
VCCSA_CS1: PR66847.2 PR66957.1
VCCSA_CSUMC: PR66862.1 PR66881.1
VCCSA_PWM6: PR66839.2 PR66955.1
VCCSA_VCCSENSE: PR66890.1 PR66892.2 R20819.1 U41.M38(VCCSA_SENSE)
VCCSA_VSSSENSE: PR66894.2 PR66896.1 R20820.1 U41.M37(VSSSA_SENSE)
VCCSENSE: PR66868.1 PR66872.2 R552.1 R20812.2 U41.AG37(VCC_SENSE)
VCCST_PG: D13069.1(CATHODE) R202.1 R204.1 R21166.2 U53.2(INA)
VCCST_PWRGD: C417.1 R179.2 U41.H13(VCCST_PWRGD)
VCCST_PWRGD_EN_L: U53.4(OUT Y) U13064.2(A)
VCCST_PWRGD_R: D13069.2(ANODE) R178.2 R179.1 R20752.2 U13064.4(Y)
VDD1V8: C96231.2 L4272.2 U13157.13(DVDD)
VSS_GPU_SENSE: PR9008.2 U13114.BL45(GND_SENSE) U13114.BM44(GNDS_SENSE)
VSSIO_VSSSENSE: R20817.1 U41.J14(VSSIO_SENSE)
VSSSENSE: PR66874.2 PR66878.1 R547.2 R552.2 U41.AG38(VSS_SENSE)
1P35V_BOOT: PR2022.2 PU2001.18(BOOT)
1P35V_CS: PR2019.2 PU2001.13(CS)
1P35V_FB: PR2032.1 PR2033.1 PU2001.6(FB)
1P35V_LGATE: PQ9058.4(G) PU2001.15(LGATE)
1P35V_PGOOD: PR2017.1 PU2001.10(PGOOD)
1P35V_PHASE: PC2029.1 PL2001.1 PQ9057.1(S1) PQ9057.2(S2) PQ9057.3(S3) PQ9058.5(D) PR2025.1 PU2001.16(PHASE)
1P35V_S3: PC2022.1 PR2020.1 PR2027.2 PR2029.1 PU2001.7(S3)
1P35V_S5: PC2021.1 PR2018.1 PR2027.1 PR67229.1 PU2001.8(S5)
1P35V_TON: PR2021.2 PU2001.9(TON)
1P35V_UGATE: PQ9057.4(G) PU2001.17(UGATE)
1P35V_VDD: PC2040.1 PR2024.2 PU2001.12(VDD)
1P35V_VDDQ: PR2026.2 PR2032.2 PU2001.5(VDDQ)
1P35V_VID: PR2030.1 PR2031.1 PU2001.11(VID)
2ND_MBCLK: Q7909.3(D) Q7915.3(D) Q7930.3(D) Q7947.3(D) R20895.1 R67276.1 R67408.1 U49.115(SMCLK1/GPC1)
2ND_MBCLK_THM: Q7930.4(S) R22100.2 U13092.8(SMBCLK)
2ND_MBDATA: Q7909.6(D) Q7915.6(D) Q7930.6(D) Q7947.6(D) R20896.1 R67274.1 R67407.1 U49.116(SMDAT1/GPC2)
2ND_MBDATA_THM: Q7930.1(S) R22101.2 U13092.7(SMBDATA)
3ND_MBCLK: CN2074.3 CN2076.14 Q7896.3(D) Q7916.3(D) Q7926.6(D) R22155.1 R67266.1 U49.94(CRX1/SIN1/SMCLK3/GPH1/ID1)
3ND_MBCLK_P_KB: Q7896.4(S) R21053.1 U13093.25(SCL)
3ND_MBCLK_UIF: Q7916.4(S) R67027.1 R67266.2 U13152.25(SCL)
3ND_MBDATA: CN2074.4 CN2076.13 Q7896.6(D) Q7916.6(D) Q7926.3(D) R22156.1 R67265.1 U49.95(CTX1/SOUT1/GPH2/SMDAT3/ID2)
3ND_MBDATA_P_KB: Q7896.1(S) R21052.1 U13093.26(SDA)
3ND_MBDATA_UIF: Q7916.1(S) R67028.1 R67265.2 U13152.26(SDA)
700A_EN: R67341.1 R67342.1
1006_I2C_SCL: Q7947.1(S) R67374.1 U13108.7(I2C_CLK) U13157.4(SCL)
1006_I2C_SDA: Q7947.4(S) R67373.1 U13108.6(I2C_DATA) U13157.3(SDA)
1006_I2S_BCLK: R67378.1 U13108.10(I2S_BCLK)
1006_I2S_BCLK_R: C96244.1 R67378.2 U13157.6(BCLK)
1006_I2S_LRCK: R67377.1 U13108.12(I2S_LRCK)
1006_I2S_LRCK_R: C96245.1 R67377.2 U13157.7(LRCK)
1006_I2S_MCLK: R67379.1 U13108.11(I2S_MCLK)
1006_I2S_MCLK_R: C96243.1 R67379.2 U13157.5(MCLK)
1006_I2S_OUT: R67376.1 U13108.9(I2S_OUT)
1006_I2S_OUT_R: C96246.1 R67376.2 U13157.8(DACDAT)
1080Q_5VCC: PC9017.1 PR9053.2 PU9001.10(5VCC)
1080Q_8816ABOOT1: PC9109.2 PU9009.1(BOOT1)
1080Q_8816ABOOT2: PC9447.2 PU9009.15(BOOT2)
1080Q_8816AEN: PC9112.1 PQ9032.2(G) PR9123.1 PU9009.3(EN)
1080Q_8816ALGATE1: PQ9049.4(G) PU9009.19(LGATE1)
1080Q_8816ALGATE2: PQ9052.4(G) PU9009.17(LGATE2)
1080Q_8816APG: PR9121.1 PR9217.2 PU9009.13(PGOOD)
1080Q_8816APHASE1: PC9109.1 PL9017.1 PQ9013.1(S1) PQ9013.2(S2) PQ9013.3(S3) PQ9049.5(D) PR9122.2 PU9009.20(PHASE1)
1080Q_8816APHASE2: PC9447.1 PL9023.1 PQ9051.1(S1) PQ9051.2(S2) PQ9051.3(S3) PQ9052.5(D) PR66970.2 PU9009.16(PHASE2)
1080Q_8816APSI: PR9124.2 PR9126.2 PR9224.1 PR67009.1 PU9009.4(PSI)
1080Q_8816APVCC: PC9101.1 PR9215.2 PU9009.18(PVCC)
1080Q_8816AREFIN: PC9126.1 PR9128.1 PR9129.2 PR9131.2 PU9009.7(REFIN)
1080Q_8816ARGDN: PC9127.1 PC9128.1 PR9135.1 PU9009.10(RGND)
1080Q_8816ASS: PC9124.1 PR9147.1 PU9009.12(OCSET)
1080Q_8816ATON: PC9131.1 PR9145.1 PU9009.9(TON)
1080Q_8816AUGATE1: PR9119.1 PU9009.2(UGATE1)
1080Q_8816AUGATE1_1: PQ9013.4(G) PR9119.2
1080Q_8816AUGATE2: PR66971.1 PU9009.14(UGATE2)
1080Q_8816AUGATE2_1: PQ9051.4(G) PR66971.2
1080Q_8816AVREF: PC9121.1 PR9129.1 PU9009.8(VREF)
1080Q_8816AVSNS: PC9127.2 PC9129.1 PR9136.2 PR9138.1 PU9009.11(VSNS)
1080Q_9336ADJ: PR9066.2 PR9067.1 PU9005.5(ADJ)
1080Q_9336DRV: PD9003.1(CATHODE) PQ9009.4(G) PR9064.1 PU9005.6(DRV)
1080Q_COMP: PC9009.1 PR9034.1 PU9001.24(COMP)
1080Q_CSNSUM: PR9240.2 PU9001.15(CSNSUM)
1080Q_CSPSUM: PC9015.1 PC9016.1 PR9043.1 PR9045.1 PR9046.1 PR9048.1 PR9049.1 PR9050.1 PU9001.16(CSPSUM)
1080Q_EAP: PR9038.1 PU9001.23(EAP)
1080Q_EN: PQ9001.3(D) PR9001.2 PR9004.1 PU9001.30(EN)
1080Q_FB: PR9017.2 PR9020.1 PR9021.1 PR9027.2 PU9001.25(FB)
1080Q_FBRTN: PC9001.1 PC9003.2 PC9004.1 PC9007.2 PC9013.2 PR9005.2 PR9008.1 PR9036.2 PU9001.26(FBRTN)
1080Q_IMON: PC9014.1 PR9040.1 PU9001.19(IMON)
1080Q_ISEN1: PR9235.2 PU9001.14(ISEN1)
1080Q_ISEN2: PR9239.2 PU9001.13(ISEN2)
1080Q_ISEN3: PR9243.2 PU9001.12(ISEN3)
1080Q_ISEN4: PR9237.2 PR9245.2 PU9001.11(ISEN4)
1080Q_LPC: PR9016.2 PR9026.1 PU9001.29(LPC)
1080Q_PROG1: PR9013.2 PR9023.1 PU9001.18(PROG1)
1080Q_PROG2: PR9014.2 PR9024.1 PU9001.17(PROG2)
1080Q_PROG3: PR9015.2 PR9025.1 PU9001.20(PROG3)
1080Q_PSI: PR9010.2 PR9011.2 PR9019.1 PU9001.31(PSI)
1080Q_PWM1: PR9051.1 PU9001.9(PWM1)
1080Q_PWM2: PR9047.1 PU9001.8(PWM2)
1080Q_PWM3: PR9044.1 PU9001.7(PWM3)
1080Q_PWM4: PR9042.1 PU9001.6(PWM4)
1080Q_REFADJ: PR9029.2 PU9001.2(REFADJ)
1080Q_REFIN: PC9013.1 PR9031.2 PR9037.2 PU9001.3(REFIN)
1080Q_SS: PC9001.2 PC9010.2 PR9033.2 PU9001.22(SS)
1080Q_VID: PR9022.2 PU9001.1(VID)
1080Q_VINMON: PR9032.1 PR9035.2 PU9001.21(VINMON)
1080Q_VREF: PC9012.1 PR9030.2 PU9001.4(VREF)
8068EN_1.8V: PC9381.1 PR100.2 PU9010.5(EN)
8068FB_1.8V: PC9378.2 PR98.2 PR101.1 PU9010.6(FB)
8068FB_1.8V_S: PC9378.1 PR98.1 PR104.2
8068LX_1.8V: PL1.1 PR66969.1 PU9010.1(NC#1) PU9010.2(SW#1) PU9010.3(SW#2)
8068NC_1.8V: PC9376.1 PU9010.7(NC#2)
8068PG_1.8V: PR102.1 PU9010.4(POK)
8068SVIN_1.8V: PC9379.1 PR66968.2 PU9010.8(VCC)
9511_OUT1: PR9075.2 PR9238.2
9511_OUT2: PR9058.2 PR66976.2
9511_OUT3: PR9242.2 PR66978.2
9511_OUT4: PR9060.2 PR66980.2
9511_PWM1_S: PR9051.2 PR9069.1
9511_PWM2_S: PR9047.2 PR66991.1
9511_PWM3_S: PR9044.2 PR66993.1
9511_PWM4_S: PR9042.2 PR66995.1
9511_SWN1: PR9043.2 PR9074.2
9511_SWN2: PR9046.2 PR66975.2
9511_SWN3: PR9049.2 PR66977.2
9511_SWN4: PR9050.2 PR66979.2
24780_ACDET: PR31.2 PR211.2 PU1.6(ACDET)
24780_ACDRV: PR29.2 PU1.4(ACDRV)
24780_ACN: PC25.2 PC35.1 PR2.2 PU1.1(ACN)
24780_ACP: PC25.1 PC36.2 PR1.2 PU1.2(ACP)
24780_BATDRV: PR4.2 PU1.18(BATDRV)
24780_BATSRC: PR7.2 PU1.17(BATSRC)
24780_BM#: PR9.1 PU1.16(T\B\_\S\T\A\T\)
24780_BST: PR11.2 PU1.25(BTST)
24780_CMPIN: PR207.1 PR67220.1 PU1.13(CMPIN)
24780_CMPOUT: PR15.1 PU1.14(CMPOUT)
24780_CMSRC: PR28.2 PU1.3(CMSRC)
24780_DH: PQ30.4(G) PU1.26(HIDRV)
24780_DL: PQ29.4(G) PU1.23(LODRV)
24780_ILIM: PC8.2 PR204.1 PR206.1 PU1.21(ILIM)
24780_LX: PC15.1 PL5.1 PQ29.5(D) PQ30.1(S1) PQ30.2(S2) PQ30.3(S3) PR33.1 PU1.27(PHASE)
24780_SRN: PC3.1 PC4.2 PR6.2 PR208.2
24780_SRP: PC3.2 PC6.2 PR5.2 PR210.2
24780_VCC: PC16.1 PR16.1 PU1.28(VCC)
51225_CS1: PR182.1 PU9.1(CS1)
51225_CS2: PR190.1 PU9.5(CS2)
51225_DH1: PQ21.1(G1) PU9.16(DRVH1)
51225_DH2: PQ22.1(G1) PU9.10(DRVH2)
51225_DL1: PQ21.8(G2) PU9.15(DRVL1)
51225_DL2: PQ22.8(G2) PU9.11(DRVL2)
51225_EN1: PR179.2 PU9.20(EN1)
51225_FB1: PR184.1 PR185.1 PU9.2(VFB1)
51225_FB2: PR188.2 PR189.1 PU9.4(VFB2)
51225_SW1: PC148.1 PL2.1 PQ21.9(S1/D2) PR167.1 PU9.18(SW1)
51225_SW2: PC149.1 PL3.1 PQ22.9(S1/D2) PR168.1 PU9.8(SW2)
51225_VBST1: PR177.2 PU9.17(VBST1)
51225_VBST2: PR178.1 PU9.9(VBST2)
51225_VIN: PC142.1 PR171.2 PU9.12(VIN)
61087COMP: PR9233.2 PU8006.1(COMP)
61087EN: PC8102.2 PR9230.2 PU8006.3(EN)
61087FB: PR9231.1 PR9232.2 PU8006.2(FB)
61087FREQ: PR9229.2 PR9234.1 PU8006.9(FREQ)
61087SS: PC8104.2 PU8006.10(SS)
61087SW: PD40.2(ANODE) PL9.2 PU8006.6(SW#1) PU8006.7(SW#2)
+601_VCC: C95573.2 C95574.2 C95575.2 C95576.2 C95577.2 R21742.1 R21744.1 R21746.1 R21747.2 R21749.1 R21751.1 R21753.1 R21755.1 R21885.1 R21887.1 R21889.1 R21891.1 R21979.2 R21984.2 R21986.2 R21988.2 U13146.8(VDD#1) U13146.28(VDD#3) U13146.35(VDD#4)
+602_VCC: C95591.2 C95593.2 C95594.2 C95595.2 C95596.2 R21769.2 R21892.1 R21895.1 R21897.1 R21899.1 R21900.2 R21901.2 R21902.2 R21905.1 R21906.1 R21907.1 R21908.2 R21910.1 R21917.1 R21918.1 R21919.1 U13147.8(VDD#1) U13147.28(VDD#3) U13147.35(VDD#4)
+603_VCC: C95858.2 C95859.2 C95863.2 C95865.2 C95867.2 R21920.1 R21923.1 R21925.1 R21927.1 R21947.2 R21957.2 R21958.2 R21961.1 R21962.1 R21963.1 R21964.2 R21966.1 R21974.1 R21975.1 R21976.1 R21977.2 U13149.8(VDD#1) U13149.28(VDD#3) U13149.35(VDD#4)
+604_VCC: C95861.2 C95862.2 C95864.2 C95868.2 C95869.2 R21929.1 R21931.1 R21933.1 R21934.1 R21936.2 R21937.2 R21938.2 R21940.1 R21942.1 R21943.1 R21944.2 R21946.1 R21954.1 R21955.1 R21956.1 R21970.2 U13148.8(VDD#1) U13148.28(VDD#3) U13148.35(VDD#4)
+PWR_SRC_GPU_SENSE1_IN_N: PR146.2 PR67196.2
+PWR_SRC_GPU_SENSE1_IN_P: PR139.2 PR67195.2
+TPVDD: C94786.1 C94787.1 CN2076.1 CN2078.10 Q7838.3(D) Q7843.2(G) Q7892.2(G) Q7892.5(G) R21063.1 R21064.1 R21067.2 R21068.2 R22154.2 R67257.2
+WL_VDD: C95540.1 C95541.1 C95542.1 C95543.1 C95544.1 C95545.1 C95546.2 C95547.2 C95548.2 CN2068.2(3.3V#1) CN2068.4(3.3V#2) CN2068.72(3.3V#3) CN2068.74(3.3V#4) Q7888.2(G) Q7889.2(G) Q7890.2(G) Q7891.2(G) R21709.2 R21710.2 R21720.1 R22003.2 R22005.2
A0_EDP: R20912.2 R20914.2 U13079.11(SSEQ0/A0)
A0_TBT: R20835.1 R20840.1 U13025.11(SSEQ0/A0)
A_DE0: R21750.1 R21751.2 U13146.26(A_DE0)
A_DE0_1: R21911.1 R21917.2 U13147.26(A_DE0)
A_DE0_2: R21967.1 R21974.2 U13149.26(A_DE0)
A_DE0_3: R21948.1 R21954.2 U13148.26(A_DE0)
A_DE0_5: R21691.2 U13124.29(ADE0)
A_DE1: R21752.1 R21753.2 U13146.2(A_DE1)
A_DE1_1: R21914.1 R21919.2 U13147.2(A_DE1)
A_DE1_2: R21971.1 R21976.2 U13149.2(A_DE1)
A_DE1_3: R21951.1 R21956.2 U13148.2(A_DE1)
A_DE1_5: R21692.2 U13124.28(ADE1)
A_EQ0: R21888.1 R21889.2 U13146.3(A_EQ0)
A_EQ0_1: R21896.1 R21897.2 U13147.3(A_EQ0)
A_EQ0_2: R21924.1 R21925.2 U13149.3(A_EQ0)
A_EQ0_3: R21932.1 R21933.2 U13148.3(A_EQ0)
A_EQ0_5: R21686.2 U13124.32(AEQ0)
A_EQ1: R21754.1 R21755.2 U13146.4(A_EQ1)
A_EQ1_1: R21907.2 R21913.1 U13147.4(A_EQ1)
A_EQ1_2: R21963.2 R21969.1 U13149.4(A_EQ1)
A_EQ1_3: R21942.2 R21950.1 U13148.4(A_EQ1)
A_EQ1_5: R21687.2 U13124.31(AEQ1)
A_EQ2: R21890.1 R21891.2 U13146.5(A_EQ2)
A_EQ2_1: R21898.1 R21899.2 U13147.5(A_EQ2)
A_EQ2_2: R21926.1 R21927.2 U13149.5(A_EQ2)
A_EQ2_3: R21934.2 R21935.1 U13148.5(A_EQ2)
ACE_I2C_SCL2: Q7926.1(S) Q7949.1(S) R67134.1 U13155.B5(I2C_SCL2)
ACE_I2C_SDA2: Q7926.4(S) Q7949.4(S) R67112.1 U13155.A5(I2C_SDA2)
ACIN: PR30.1 PR39.2 PR40.1 U49.72(ADC6/DSR1#/GPI6(3))
ACPRESENT: R21128.2 U49.84(EGCLK/GPE3) U13113.BB15(GPD1/ACPRESENT)
ACZ_BCLK: R21100.2 U13113.BA9(HDA_BCLK)
ACZ_RST#: R21102.2 U13113.BD8(HDA_RST#)
ACZ_SDOUT: R21098.2 R21103.2 R21105.2 U13113.BB7(HDA_SDO)
ACZ_SPKR: D13039.2(ANODE) R21235.2 R21241.1 U13113.BD26(GPP_B14/SPKR)
ACZ_SYNC: R21104.2 R21112.1 U13113.BD9(HDA_SYNC)
ADOGND: C94922.1 C94925.2 C94926.1 C94927.1 C94928.1 C94930.1 C94931.2 C94932.2 C94933.2 C94942.2 C94943.2 C94951.1 C94952.2 C94953.2 C94956.1 C94962.1 C94963.1 C95962.2 C95973.1 C95974.1 C95975.2 C95977.2 C95978.2 C95979.2 C95980.1 C95981.2 C95984.1 C95985.1 C96222.2 C96223.2 C96224.2 C96232.1 C96233.1 C96234.2 C96235.1 C96236.1 CN2058.3(G/M) CN2058.4(M/G) CN2058.5 CN2059.3(G/M) CN2059.4(M/G) CN2059.5 D8569.2 D8570.2 D8571.2 D8575.2 D8576.2 D8577.2 R21446.1 R21449.2 R21450.2 R21462.1 R21465.1 R21466.1 R21468.1 R21469.1 R21470.1 R67013.2 R67014.2 R67015.2 R67202.2 R67203.2 R67260.2 R67261.2 R67352.1 U13108.22(AVSS2) U13108.37(AVSS1) U13150.10(PGND) U13150.15(SGND) U13150.17(THERMAL PAD) U13151.17(THERMAL PAD) U13156.2(GND#2) U13157.16(AGND#1) U13157.20(AGND#2)
AMP_EN: C96222.1 R67012.2 R67338.2 R67342.2 U13151.5(EN)
AMP_MUTE#: D8587.1(CATHODE) D13066.1(CATHODE) R2708.1 U49.108(RXD/SIN0/GPB0) U13156.6(RFOUT)
AMP_PD: D13066.2(ANODE) D13067.2(ANODE) R2708.2 R2709.2 R20881.1 R22089.2 U13157.11(PDB_JD)
AN_DPSRC_RBIAS_1: R20690.2 U21.N6(DPSRC_RBIAS)
ASEL: R381.1 R67351.1 U13157.14(ASEL)
AUD_AZACPU_SCLK: R21116.1 U41.G27(PROC_AUDIO_CLK)
AUD_AZACPU_SCLK_R: R21116.2 U13113.AM2(DISPA_BCLK)
AUD_AZACPU_SDI: R126.2 U13113.AN2(DISPA_SDI)
AUD_AZACPU_SDI_L: R126.1 U41.G29(PROC_AUDIO_SDO)
AUD_AZACPU_SDO: R21114.1 U41.G25(PROC_AUDIO_SDI)
AUD_AZACPU_SDO_R: R21114.2 U13113.AM1(DISPA_SDO)
AUX_SRCN_TBT_C: C94567.1 U21.W11(DPSNK0_AUX_N)
AUX_SRCP_TBT_C: C94566.1 U21.Y11(DPSNK0_AUX_P)
B_DE0: R21741.1 R21742.2 U13146.6(B_DE0)
B_DE0_1: R21904.1 R21910.2 U13147.6(B_DE0)
B_DE0_2: R21960.1 R21966.2 U13149.6(B_DE0)
B_DE0_3: R21941.1 R21946.2 U13148.6(B_DE0)
B_DE0_5: R21693.2 U13124.15(BDE0)
B_DE1: R21743.1 R21744.2 U13146.11(B_DE1)
B_DE1_1: R21912.1 R21918.2 U13147.11(B_DE1)
B_DE1_2: R21968.1 R21975.2 U13149.11(B_DE1)
B_DE1_3: R21949.1 R21955.2 U13148.11(B_DE1)
B_DE1_5: R21694.2 U13124.16(BDE1)
B_EQ0: R21745.1 R21746.2 U13146.34(B_EQ0)
B_EQ0_1: R21903.1 R21905.2 U13147.34(B_EQ0)
B_EQ0_2: R21959.1 R21961.2 U13149.34(B_EQ0)
B_EQ0_3: R21939.1 R21940.2 U13148.34(B_EQ0)
B_EQ0_5: R21689.2 U13124.13(BEQ0)
B_EQ1: R21885.2 R21982.1 U13146.24(B_EQ1)
B_EQ1_1: R21892.2 R21893.1 U13147.24(B_EQ1)
B_EQ1_2: R21920.2 R21921.1 U13149.24(B_EQ1)
B_EQ1_3: R21928.1 R21929.2 U13148.24(B_EQ1)
B_EQ1_5: R21690.2 U13124.14(BEQ1)
B_EQ2: R21886.1 R21887.2 U13146.25(B_EQ2)
B_EQ2_1: R21894.1 R21895.2 U13147.25(B_EQ2)
B_EQ2_2: R21922.1 R21923.2 U13149.25(B_EQ2)
B_EQ2_3: R21930.1 R21931.2 U13148.25(B_EQ2)
BAT-V: PC164.1 PC165.1 PC166.1 PC167.1 PC168.1 PC9494.1 PC9495.1 PJ1.7 PJ1.8 PJ9028.8 PJ9028.9 PJ9028.10 PR208.1 PR209.2
BATLOW#: R21149.2 R67157.2 U13113.BD13(GPD0/BATLOW#)
BBS_BIT1: R21251.2 R21258.1 U13113.BA41(GPP_C8/UART0_RXD)
BEEP1: D13038.1(CATHODE) D13039.1(CATHODE) R21441.2
BEEP2: C94923.1 C94924.1 R21441.1 R22060.1
BEEP3: C94923.2 U13108.34(PCBEEP)
BI: PJ1.6 PJ9028.7 PR10.1 Q44.3(D)
BI_GATE: C853.1 Q42.5(G) Q44.2(G) R618.2 R67293.2 R67295.1 SW1.1 SW1.2
BL#: Q35.2(G) Q35.3(D) R20963.1
BL_ON: D8557.2(ANODE) Q35.6(D) Q7824.3(COLLECTOR) R20964.1 R22069.1
BLON_EN: Q35.5(G) Q7822.3(D) R20951.2 R20956.2 R20965.2 R20967.1
BLONCON: CN2042.32 R22068.2 R22069.2
BOARD_ID0: R21304.2 R21305.1 U13113.AL36(GPP_D10)
BOARD_ID1: R21284.2 R21285.1 U13113.AL35(GPP_D11)
BOARD_ID2: R21286.2 R21287.1 U13113.AJ39(GPP_D12)
BOARD_ID3: R21288.2 R21289.1 U13113.AJ43(GPP_D16/ISH_UART0_CTS#)
BOARD_ID4: R21290.2 R21291.1 U13113.AL43(GPP_D15/ISH_UART0_RTS#)
BOARD_ID5: R21292.2 R21293.1 U13113.AK44(GPP_D14/ISH_UART0_TXD/SML0BCLK/)
BOARD_ID6: R21294.2 R21295.1 U13113.AK45(GPP_D13/ISH_UART0_RXD/SML0BDATA)
BOARD_ID7: R21296.2 R21297.1 U13113.BC22(GPP_A23/ISH_GP5)
BOARD_ID8: R21298.1 R67022.2 U13113.BD18(GPP_A22/ISH_GP4)
BOARD_ID9: R21300.2 R21301.1 U13113.BE21(GPP_A21/ISH_GP3)
BOARD_ID11: R67221.1 R67226.2 U13113.BD21(GPP_A19/ISH_GP1)
BOARD_ID12: R67223.2 R67225.1 U13113.BB22(GPP_A18/ISH_GP0)
BOARD_ID13: R67224.2 R67227.1 U13113.BC19(GPP_A17/ISH_GP7)
BT_POWERON: CN2068.54(W_DISABLE2#) R67312.1
BUFRST: TP13106.1 U13114.BF9(BUFRST_N)
C_GPU_TBT_AUXN: C94556.2 R20841.2 U13025.25(AUXN)
C_GPU_TBT_AUXP: C94555.2 R20842.1 U13025.24(AUXP)
C_GPU_TBT_D0: C93687.2 U13025.9(DP0P)
C_GPU_TBT_D0#: C94548.2 U13025.10(DP0N)
C_GPU_TBT_D1: C94553.2 U13025.12(DP1P)
C_GPU_TBT_D1#: C94554.2 U13025.13(DP1N)
C_GPU_TBT_D2: C94551.2 U13025.15(DP2P)
C_GPU_TBT_D2#: C94552.2 U13025.16(DP2N)
C_GPU_TBT_D3: C94549.2 U13025.18(DP3P)
C_GPU_TBT_D3#: C94550.2 U13025.19(DP3N)
C_INT_DP_AUXN: C94740.1 CN2043.17(AUX_CH-) ESD8.2(LINE-2) ESD8.9(NC#3) Q7903.3(D) R20985.2
C_INT_DP_AUXP: C94742.1 CN2043.15(AUX_CH+) ESD8.1(LINE-1) ESD8.10(NC#4) Q7904.3(D) R20986.1
C_OUT_DP_TXN0: C94719.1 CN2043.3(ML_LANE0-) D13080.2
C_OUT_DP_TXN1: C94738.1 CN2043.6(ML_LANE1-) D13082.2
C_OUT_DP_TXN2: C94736.1 CN2043.9(ML_LANE2-) D13084.2
C_OUT_DP_TXN3: C94721.2 CN2043.12(ML_LANE3-) D13086.2
C_OUT_DP_TXP0: C94726.1 CN2043.1(ML_LANE0+) D13079.2
C_OUT_DP_TXP1: C94737.1 CN2043.4(ML_LANE1+) D13081.2
C_OUT_DP_TXP2: C94735.1 CN2043.7(ML_LANE2+) D13083.2
C_OUT_DP_TXP3: C94720.2 CN2043.10(ML_LANE3+) D13085.2
C_OUT_EDP_TXN0: C94677.1 U13079.39(RX2N)
C_OUT_EDP_TXN1: C94688.1 U13079.36(TX2N)
C_OUT_EDP_TXN2: C94690.1 U13079.34(TX1N)
C_OUT_EDP_TXN3: C94694.1 U13079.31(RX1N)
C_OUT_EDP_TXP0: C94676.1 U13079.40(RX2P)
C_OUT_EDP_TXP1: C94684.1 U13079.37(TX2P)
C_OUT_EDP_TXP2: C94689.1 U13079.33(TX1P)
C_OUT_EDP_TXP3: C94693.1 U13079.30(RX1P)
C_PCIE_RXN3_C: C94577.1 U21.K22(PCIE_TX2_N)
C_PCIE_RXN4_C: C94579.1 U21.F22(PCIE_TX3_N)
C_PCIE_RXP3_C: C94578.1 U21.K23(PCIE_TX2_P)
C_PCIE_RXP4_C: C94580.1 U21.F23(PCIE_TX3_P)
C_PEG_TX0: C94277.2 U41.C10(PEG_TXP[15])
C_PEG_TX1: C94275.2 U41.A11(PEG_TXP[14])
C_PEG_TX2: C94273.2 U41.C12(PEG_TXP[13])
C_PEG_TX3: C94271.2 U41.A13(PEG_TXP[12])
C_PEG_TX4: C94269.2 U41.C14(PEG_TXP[11])
C_PEG_TX5: C94267.2 U41.A15(PEG_TXP[10])
C_PEG_TX6: C94265.2 U41.C16(PEG_TXP[9])
C_PEG_TX7: C94263.2 U41.A17(PEG_TXP[8])
C_PEG_TX8: C94261.2 U41.B18(PEG_TXP[7])
C_PEG_TX9: C94259.2 U41.B19(PEG_TXP[6])
C_PEG_TX10: C94257.2 U41.B20(PEG_TXP[5])
C_PEG_TX11: C94255.2 U41.B21(PEG_TXP[4])
C_PEG_TX12: C94253.2 U41.B22(PEG_TXP[3])
C_PEG_TX13: C94251.2 U41.B23(PEG_TXP[2])
C_PEG_TX14: C94249.2 U41.B24(PEG_TXP[1])
C_PEG_TX15: C1194.2 U41.B25(PEG_TXP[0])
C_PEG_TX#0: C94278.2 U41.B10(PEG_TXN[15])
C_PEG_TX#1: C94276.2 U41.B11(PEG_TXN[14])
C_PEG_TX#2: C94274.2 U41.B12(PEG_TXN[13])
C_PEG_TX#3: C94272.2 U41.B13(PEG_TXN[12])
C_PEG_TX#4: C94270.2 U41.B14(PEG_TXN[11])
C_PEG_TX#5: C94268.2 U41.B15(PEG_TXN[10])
C_PEG_TX#6: C94266.2 U41.B16(PEG_TXN[9])
C_PEG_TX#7: C94264.2 U41.B17(PEG_TXN[8])
C_PEG_TX#8: C94262.2 U41.C18(PEG_TXN[7])
C_PEG_TX#9: C94260.2 U41.A19(PEG_TXN[6])
C_PEG_TX#10: C94258.2 U41.C20(PEG_TXN[5])
C_PEG_TX#11: C94256.2 U41.A21(PEG_TXN[4])
C_PEG_TX#12: C94254.2 U41.C22(PEG_TXN[3])
C_PEG_TX#13: C94252.2 U41.A23(PEG_TXN[2])
C_PEG_TX#14: C94250.2 U41.C24(PEG_TXN[1])
C_PEG_TX#15: C94248.2 U41.A25(PEG_TXN[0])
CAD_SNK: CN2043.13(CONFIG1) ESD8.5(LINE-4) Q7832.2(G) R20970.2
CAD_SNK_R_EDP: R67381.1 R67396.1 U13079.29(CAD_SNK/DCI_DAT)
CAP+: C94929.2 U13108.23(CBP)
CAP-: C94929.1 U13108.24(CBN)
CATERR#: R571.1 U41.BM30(CATERR#)
CCD_PWR: C94682.2 C94683.2 CN2042.36 R20955.2
CFG2: R20767.1 U41.BN26(CFG[2])
CFG3: R124.1 U41.BN28(CFG[3])
CFG4: R20768.1 U41.BR20(CFG[4])
CFG5: R20765.1 U41.BM20(CFG[5])
CFG6: R20766.1 U41.BT20(CFG[6])
CFG7: R67188.1 U41.BP20(CFG[7])
CFG10: R20764.1 U41.BT23(CFG[10])
CFG12: R20763.1 U41.BM19(CFG[12])
CFG13: R20762.1 U41.BR19(CFG[13])
CFG_RCOMP: R129.1 U41.BT25(CFG_RCOMP)
CHA_SA0: CN2063.256(SA0) R21389.1 R21392.2
CHA_SA1: CN2063.260(SA1) R21390.1 R21393.2
CHA_SA2: CN2063.166(SA2) R21391.1 R21394.2
CHB_SA0: CN2062.256(SA0) R21416.1 R21419.2
CHB_SA1: CN2062.260(SA1) R21417.1 R21420.2
CHB_SA2: CN2062.166(SA2) R21418.1 R21421.2
CLK_CPU_BCLKN: U41.A32(BCLKN) U13113.H2(C\L\K\O\U\T\_\C\P\U\B\C\L\K\)
CLK_CPU_BCLKP: U41.B31(BCLKP) U13113.G2(CLKOUT_CPUBCLK_P)
CLK_DPLL_NSCCLKN: U41.D31(CLK24N) U13113.F1(C\L\K\O\U\T\_\C\P\U\N\S\S\C\)
CLK_DPLL_NSCCLKP: U41.E31(CLK24P) U13113.G1(CLKOUT_CPUNSSC_P)
CLK_PCI_EC: C94804.1 R817.2 R21095.2 U49.13(LPCCLK/GPM4(3))
CLK_PCI_EC_R: R21095.1 U13113.BC17(GPP_A9/CLKOUT_LPC0/ESPI_CLK)
CLK_PCI_LPC: C94805.1 R21096.2 R21718.2
CLK_PCI_LPC_R: R21096.1 U13113.AV19(GPP_A10/CLKOUT_LPC1)
CLK_PCIE_LANN: U13113.E5(CLKOUT_PCIE_N3) U13143.32(REFCLK_N)
CLK_PCIE_LANP: U13113.G4(CLKOUT_PCIE_P3) U13143.33(REFCLK_P)
CLK_PCIE_NGFF1_N: R22206.1 R22209.2 U13113.U5(CLKOUT_PCIE_N7)
CLK_PCIE_NGFF1_N_Q: R22204.1 R22206.2
CLK_PCIE_NGFF1_N_R: CN2069.53 R22202.1 R22204.2
CLK_PCIE_NGFF1_N_RE: R22170.1 R22187.1 R22202.2
CLK_PCIE_NGFF1_P: R22207.1 R22208.2 U13113.U7(CLKOUT_PCIE_P7)
CLK_PCIE_NGFF1_P_Q: R22205.1 R22207.2
CLK_PCIE_NGFF1_P_R: CN2069.55 R22203.1 R22205.2
CLK_PCIE_NGFF1_P_RE: R22169.1 R22188.1 R22203.2
CLK_PCIE_NGFF2_N: R22200.1 U13113.W10(CLKOUT_PCIE_N8)
CLK_PCIE_NGFF2_N_R: CN2070.53 R22198.1 R22200.2
CLK_PCIE_NGFF2_N_RE: R22193.1 R22194.1 R22198.2
CLK_PCIE_NGFF2_P: R22201.1 U13113.W11(CLKOUT_PCIE_P8)
CLK_PCIE_NGFF2_P_R: CN2070.55 R22199.1 R22201.2
CLK_PCIE_NGFF2_P_RE: R22192.1 R22195.1 R22199.2
CLK_PCIE_TBTN: U21.T19(PCIE_REFCLK_100_IN_N) U13113.N7(CLKOUT_PCIE_N0)
CLK_PCIE_TBTP: U21.V19(PCIE_REFCLK_100_IN_P) U13113.N8(CLKOUT_PCIE_P0)
CLK_PCIE_WIGIGN: R21994.2 U13113.L7(CLKOUT_PCIE_N1)
CLK_PCIE_WIGIGN_C: CN2068.73(REFCLKN1) R21719.1 R21994.1
CLK_PCIE_WIGIGP: R21993.2 U13113.L5(CLKOUT_PCIE_P1)
CLK_PCIE_WIGIGP_C: CN2068.71(REFCLKP1) R21718.1 R21993.1
CLK_PCIE_WLANN: CN2068.49(REFCLKN0) U13113.D3(CLKOUT_PCIE_N2)
CLK_PCIE_WLANP: CN2068.47(REFCLKP0) U13113.F2(CLKOUT_PCIE_P2)
CLK_VDD: C95987.1 C95991.1 C95992.2 R22191.2 U3.5(VDD#1) U3.9(VDD#2) U3.12(VDD#3) U3.16(VDD#4)
CLK_VGA_N: U13113.D5(CLKOUT_PCIE_N4) U13114.BM27(PEX_REFCLK_N)
CLK_VGA_P: U13113.E6(CLKOUT_PCIE_P4) U13114.BM26(PEX_REFCLK)
CLKRUN#: R21130.2 R21132.2 U49.93(CLKRUN#/ID0/GPH0) U13113.AW22(GPP_A8/CLKRUN#)
CLR_CMOS: Q7933.2(G) Q7934.2(G) R67245.2 U49.19(L80HLAT/BAO/GPE0)
CORE_PLLVDD: C95065.2 C95070.2 C95151.2 C95152.2 C95153.1 C95154.1 C95155.1 C95156.1 C95157.1 L4246.2 U13114.AF11(GPCPLL_AVDD1) U13114.BB24(XS_PLLVDD) U13114.BC12(VID_PLLVDD) U13114.BD12(SP_PLLVDD) U13114.BD15(IFPEF_PLLVDD) U13114.BD18(IFPCD_PLLVDD) U13114.U42(GPCPLL_AVDD0)
CPU_2_PCH_TRIG: R20811.2 U13113.AK1(PCH_TRIGIN)
CPU_2_PCH_TRIG_R: R20811.1 U41.J23(PROC_TRIGOUT)
CPU_EDP_AUXN: C94699.1 U41.B26(EDP_AUXN)
CPU_EDP_AUXP: C94700.1 U41.C26(EDP_AUXP)
CPU_EDP_TXN0: C94679.1 U41.E29(EDP_TXN[0])
CPU_EDP_TXN1: C94686.1 U41.E28(EDP_TXN[1])
CPU_EDP_TXN2: C94692.1 U41.B29(EDP_TXN[2])
CPU_EDP_TXN3: C94696.1 U41.B28(EDP_TXN[3])
CPU_EDP_TXP0: C94678.1 U41.D29(EDP_TXP[0])
CPU_EDP_TXP1: C94685.1 U41.F28(EDP_TXP[1])
CPU_EDP_TXP2: C94691.1 U41.A29(EDP_TXP[2])
CPU_EDP_TXP3: C94695.1 U41.C28(EDP_TXP[3])
CPU_OPC_COMP: R20813.2 U41.BT29(OPC_RCOMP)
CPU_OPCE_COMP: R20814.2 U41.BR25(OPCE_RCOMP)
CPU_OPCE_COMP2: R20815.2 U41.BP25(OPCE_RCOMP2)
CPU_PCI_BCLKN: U41.C36(PCI_BCLKN) U13113.J1(C\L\K\O\U\T\_\C\P\U\P\C\I\B\C\L)
CPU_PCI_BCLKP: U41.D35(PCI_BCLKP) U13113.J2(CLKOUT_CPUPCIBCLK_P)
CPU_PLTRST#R: R541.2 R542.2 R21191.2 U41.BP35(RESET#)
CPU_THERMDA: C94774.1 Q7834.2(BASE) Q7834.3(COLLECTOR) U13092.2(DXP)
CPU_THERMDC: C94774.2 Q7834.1(EMITTER) U13092.3(DXN)
CPU_WIGIG_DP_AUXN: C95888.1 U41.E27(DDI1_AUXN)
CPU_WIGIG_DP_AUXP: C95889.1 U41.D27(DDI1_AUXP)
CPU_WIGIG_DP_HPD: R22000.2 R22050.1
CPU_WIGIG_DP_ML0N: C95880.1 U41.K37(DDI1_TXN[0])
CPU_WIGIG_DP_ML0P: C95881.1 U41.K36(DDI1_TXP[0])
CPU_WIGIG_DP_ML1N: C95882.1 U41.J34(DDI1_TXN[1])
CPU_WIGIG_DP_ML1P: C95883.1 U41.J35(DDI1_TXP[1])
CPU_WIGIG_DP_ML2N: C95884.1 U41.H36(DDI1_TXN[2])
CPU_WIGIG_DP_ML2P: C95908.1 U41.H37(DDI1_TXP[2])
CPU_WIGIG_DP_ML3N: C95886.1 U41.J38(DDI1_TXN[3])
CPU_WIGIG_DP_ML3P: C95887.1 U41.J37(DDI1_TXP[3])
CPU_WIGIG_MLDIR: R22097.2 R67238.2
CPU_WIGIG_PCIE_RXN1: R21999.2 U13113.E17(PCIE2_RXN/USB3_8_RXN)
CPU_WIGIG_PCIE_RXP1: R21998.2 U13113.G17(PCIE2_RXP/USB3_8_RXP)
CPU_WIGIG_PCIE_TXN1: C95897.2 CN2068.61(PETN1)
CPU_WIGIG_PCIE_TXP1: C95898.2 CN2068.59(PETP1)
CTL0_EDP: R20934.2 R20935.2 U13079.22(CTL0/SDA)
CTL0_TBT_SDA: C95998.2 R20837.1 U13025.22(CTL0/SDA)
CTL1_EDP: R20918.1 R20929.2 R20931.2 U13079.23(CTL1/HPDIN)
CTL1_TBT_HPDIN: R20829.2 R20831.1 R20836.1 U13025.23(CTL1/HPDIN)
CTL2: R21707.2 U13128.7(CTL2)
CTL3: R21708.2 U13128.8(CTL3)
D/C#: PC20.2 PR26.1 TP1.1
DC-DET: R21440.1 R22087.2 R22088.1 U13108.13(DC-DET/EAPD)
DCPRTC: C94839.1 U13113.BA26(DCPRTC)
DDI1_TX0_DN: C94559.2 U13025.39(RX2N)
DDI1_TX0_DN_C: C94559.1 U21.AC7(DPSNK0_ML0_N)
DDI1_TX0_DP: C13548.2 U13025.40(RX2P)
DDI1_TX0_DP_C: C13548.1 U21.AB7(DPSNK0_ML0_P)
DDI1_TX1_DN: C94561.2 U13025.36(TX2N)
DDI1_TX1_DN_C: C94561.1 U21.AC9(DPSNK0_ML1_N)
DDI1_TX1_DP: C94560.2 U13025.37(TX2P)
DDI1_TX1_DP_C: C94560.1 U21.AB9(DPSNK0_ML1_P)
DDI1_TX2_DN: C94563.2 U13025.34(TX1N)
DDI1_TX2_DN_C: C94563.1 U21.AC11(DPSNK0_ML2_N)
DDI1_TX2_DP: C94562.2 U13025.33(TX1P)
DDI1_TX2_DP_C: C94562.1 U21.AB11(DPSNK0_ML2_P)
DDI1_TX3_DN: C94565.2 U13025.31(RX1N)
DDI1_TX3_DN_C: C94565.1 U21.AC13(DPSNK0_ML3_N)
DDI1_TX3_DP: C94564.2 U13025.30(RX1P)
DDI1_TX3_DP_C: C94564.1 U21.AB13(DPSNK0_ML3_P)
DDPB_CLK: R67229.1 U13113.BA5(GPP_I5/DDPB_CTRLCLK)
DDPB_DATA: R67228.1 U13113.BC4(GPP_I6/DDPB_CTRLDATA)
DDPC_CLK: R21318.1 U13113.BB3(GPP_I7/DDPC_CTRLCLK)
DDPC_DATA: R21319.1 U13113.BD6(GPP_I8/DDPC_CTRLDATA)
DDR4_DRAMRST#: C94808.1 C94861.1 C94892.1 CN2062.108(RESET#) CN2063.108(RESET#) R21113.2
DDR4_SUSON_2V5: PR305.2 R67314.1
DDR_VTT: C94864.1 C94867.1 C94869.1 C94871.1 C94874.1 C94894.1 C94896.1 C94898.1 C94900.1 C94902.1 C96160.1 C96163.1 CN2062.258(VTT) CN2063.258(VTT) PC2026.1 PU2001.2(VTTSNS) PU2001.20(VTT)
DDR_VTT_CNTL: Q7844.1(EMITTER) R21410.2 U41.BT13(DDR_VTT_CNTL)
DDR_VTTT_PG_CTRL: PR2029.2 Q7844.3(COLLECTOR) R21412.2
DEVSLP0: R21092.1 R21733.2 R67358.2 U13113.AG42(GPP_E4/DEVSLP0)
DEVSLP0_R: CN11.20 R67358.1
DEVSLP3: R21093.1 R21796.2 U13113.AB41(GPP_F5/DEVSLP3)
DEVSLP_N1: CN2069.38 R21733.1 R21734.2
DEVSLP_N2: CN2070.38 R21796.1 R21797.2
DG_ACE_A_I2C_ADDR: R67084.2 U13155.F1(I2C_ADDR)
DG_RTD3_CIO_PWR_EN: R67054.1 R67158.1 U21.F1(POC_GPIO_6)
DG_RTD3_USB_PWR_EN: R20694.1 R67154.1 U21.D4(POC_GPIO_2)
DGPU_HOLD_RST#: R21256.2 R21313.2 R67241.1 U13113.AW27(GPP_B16/GSPI0_CLK) U13115.1(INB)
DGPU_OPP#: C96221.1 Q7941.2(G) R67319.2 R67322.1 U49.71(ADC5/DCD1#/GPI5(3))
DGPU_OPP#_PROCHOT#: Q7859.3(D) Q7941.3(D) R67308.1 R67322.2
DGPU_OVT#_EC: Q7943.3(D) R20889.1 U49.68(ADC2/GPI2(3))
DGPU_PWR_EN: R21271.2 R21309.2 R67240.1 U13113.BD27(GPP_B17/GSPI0_MISO) U13119.2(A) U13120.2(INA)
DGPU_PWROK: Q7851.2(G) Q7857.1(S) Q7866.3(D) R21617.2
DGPU_PWROK_Q: Q7857.3(D) R21244.1 R21248.2 R21316.1 R67242.1 U13113.BC27(GPP_B19/GSPI1_CS#)
DGPU_THER_ALERT#: Q7944.3(D) R67366.1 R67367.1
DMI_RXN0: U41.E8(DMI_RXN[0]) U13113.C27(DMI_TXN0)
DMI_RXN1: U41.F6(DMI_RXN[1]) U13113.B28(DMI_TXN1)
DMI_RXN2: U41.E5(DMI_RXN[2]) U13113.B29(DMI_TXN2)
DMI_RXN3: U41.J9(DMI_RXN[3]) U13113.B30(DMI_TXN3)
DMI_RXP0: U41.D8(DMI_RXP[0]) U13113.B27(DMI_TXP0)
DMI_RXP1: U41.E6(DMI_RXP[1]) U13113.A28(DMI_TXP1)
DMI_RXP2: U41.D5(DMI_RXP[2]) U13113.C29(DMI_TXP2)
DMI_RXP3: U41.J8(DMI_RXP[3]) U13113.A30(DMI_TXP3)
DMI_TXN0: U41.A8(DMI_TXN[0]) U13113.L27(DMI_RXN0)
DMI_TXN1: U41.B6(DMI_TXN[1]) U13113.E24(DMI_RXN1)
DMI_TXN2: U41.A5(DMI_TXN[2]) U13113.G27(DMI_RXN2)
DMI_TXN3: U41.B4(DMI_TXN[3]) U13113.L29(DMI_RXN3)
DMI_TXP0: U41.B8(DMI_TXP[0]) U13113.N27(DMI_RXP0)
DMI_TXP1: U41.C6(DMI_TXP[1]) U13113.G24(DMI_RXP1)
DMI_TXP2: U41.B5(DMI_TXP[2]) U13113.E26(DMI_RXP2)
DMI_TXP3: U41.D4(DMI_TXP[3]) U13113.K29(DMI_RXP3)
DMIC_CLK: C94968.1 R20952.1 R22083.1
DMIC_CLK_C: CN2042.25 D8555.1 R20952.2
DMIC_DAT: C94967.1 R20950.1 R22084.2
DMIC_DATA_C: CN2042.24 D8556.1 R20950.2
DNBSWON#: U49.123(CTX0/TMA0/GPB2(3)) U13113.AT13(GPD3/PWRBTN#)
DP_D0: C94726.2 U13114.BH17(IFPE_L0)
DP_D0#: C94719.2 U13114.BG17(IFPE_L0_N)
DP_D1: C94737.2 U13114.BG15(IFPE_L1)
DP_D1#: C94738.2 U13114.BF15(IFPE_L1_N)
DP_D2: C94735.2 U13114.BE14(IFPE_L2)
DP_D2#: C94736.2 U13114.BF14(IFPE_L2_N)
DP_D3: C94720.1 U13114.BH14(IFPE_L3)
DP_D3#: C94721.1 U13114.BG14(IFPE_L3_N)
DP_HPD: C95933.1 CN2043.18(HPD) ESD8.4(LINE-3) ESD8.7(NC#2) R22136.2
DP_HPD_PCH: C95079.2 Q7932.3(D) R21563.2 R22136.1 R67234.2
DP_HPD_PCH_R: Q7932.1(S) R67235.1 U13113.AY2(GPP_I1/DDPC_HPD1)
DPEQ0_A1_EDP: R20913.2 R20915.2 U13079.14(DPEQ0/A1)
DPEQ0_A1_TBT: R20825.1 R20826.1 U13025.14(DPEQ0/A1)
DPEQ1_EDP: R20916.2 R20917.2 U13079.2(DPEQ1)
DPEQ1_TBT: R20827.1 R20828.1 U13025.2(DPEQ1)
DPSNK_RBIAS_1: R400.1 U21.Y18(DPSNK_RBIAS)
DRAM_RESET#: R21108.2 R21113.1 U13113.BC14(DRAM_RESET#)
DSWROK_EC_R: R21141.2 U13113.AV11(DSW_PWROK)
EAPD: D13067.1(CATHODE) R22088.2 R22089.1
EC_AMP_GAIN0: R67202.1 U49.77(GPJ1(3)) U13150.6(G0)
EC_AMP_GAIN1: R67203.1 U49.83(EGCS#/GPE2) U13150.7(G1)
EC_FPBACK#: Q7824.2(BASE) U49.86(PS2DAT0/TMB1/GPF1)
EC_I2C_SCL_AMP: Q7915.4(S) R67017.1 U13151.3(SCL)
EC_I2C_SDA_AMP: Q7915.1(S) R67016.1 U13151.4(SDA)
EC_PECI: C802.2 R395.2 R563.2 U41.BT34(PECI)
EC_PECR_R: R395.1 U49.117(PECI/SMCLK2/GPF6(3))
EC_PWROK: C94815.1 R21148.2 R21152.2 R21157.2 R21159.2 U49.33(GINT/CTS0#/GPD5) U13098.1(INB)
EC_PWROK_R: R21156.1 R21157.1 R67172.2 U13113.AW11(PCH_PWROK)
EC_WIGIG_PERST1#: R21996.2 R67039.1
ECAGND: C574.1 C94641.2 L14.2 U49.75(AVSS)
EDP_AUX#_C: C94697.2 C94699.2 CN2042.5 R20924.2 R20942.2 R20943.1 U13079.25(AUXN)
EDP_AUX_C: C94698.2 C94700.2 CN2042.4 R20925.1 R20940.2 R20941.1 U13079.24(AUXP)
EDP_DISP_UTIL: T3.1 U41.A33(EDP_DISP_UTIL)
EDP_HPD_CPU: R20939.2 R67230.2 R67231.1 U13113.BD7(GPP_I4/EDP_HPD)
EDP_HPD_GPU: C95081.2 R20923.2 R20944.2 R21564.2
EDP_HPD_GPU_Q: Q7854.2(G) R21564.1 R21568.1
EDP_HPD_R: CN2042.29 R22071.1
EDP_HPD_RR: C95899.1 R20939.1 R20944.1 R22071.2
EDP_RCOMP: R116.2 U41.D37(EDP_RCOMP)
EDP_TXN0_C: C94677.2 C94679.2 CN2042.8
EDP_TXN1_C: C94686.2 C94688.2 CN2042.11
EDP_TXN2_C: C94690.2 C94692.2 CN2042.14
EDP_TXN3_C: C94694.2 C94696.2 CN2042.17
EDP_TXP0_C: C94676.2 C94678.2 CN2042.7
EDP_TXP1_C: C94684.2 C94685.2 CN2042.10
EDP_TXP2_C: C94689.2 C94691.2 CN2042.13
EDP_TXP3_C: C94693.2 C94695.2 CN2042.16
EDP_VDD_EN: R20959.2 R20960.2 R20961.2 U13080.4(EN)
EDPC_OUTPUT_CAP: R21598.2 U13114.BA3(GPIO29)
FAN1_PWM: Q16.1(EMITTER) U49.32(PWM6/SSCK/GPA6)
FAN1_PWM_Q: C216.1 CN2045.3 Q16.3(COLLECTOR) R229.2
FAN1_RPM: C218.1 CN2045.2 R223.2 U49.47(TACH0A/GPD6(3))
FAN2_PWM: Q7902.1(EMITTER) U49.31(PWM5/GPA5)
FAN2_PWM_Q: C95935.1 CN2046.3 Q7902.3(COLLECTOR) R22141.2
FAN2_RPM: C95934.1 CN2046.2 R22138.2 U49.48(TACH1A/TMA1/GPD7(3))
FB_CAL_PD_VDDQ: R21604.2 U13114.R44(FB_CAL_PD_VDDQ)
FB_CAL_PU_GND: R21605.2 U13114.P44(FB_CAL_PU_GND)
FB_CAL_TERM_GND: R21606.2 U13114.R45(FB_CAL_TERM_GND)
FB_VREF_PROBE: TP13117.1 U13114.P45(FB_VREF)
FBA_CMD0: U13114.Y51(FBA_CMD0) U13135.H4(CAS_N)
FBA_CMD1: R22011.1 U13114.Y52(FBA_CMD1) U13135.K2(RESET_N)
FBA_CMD2: U13114.Y49(FBA_CMD2) U13135.M4(RAS_N)
FBA_CMD3: U13114.AA52(FBA_CMD3) U13135.L5(A9_A1)
FBA_CMD4: U13114.AA51(FBA_CMD4) U13135.L4(A10_A0)
FBA_CMD5: U13114.AA50(FBA_CMD5) U13135.K5(A12_A13)
FBA_CMD6: U13114.AC50(FBA_CMD6) U13135.K4(ABI_N)
FBA_CMD7: U13114.AC51(FBA_CMD7) U13135.J5(A11_A6)
FBA_CMD8: U13114.AC52(FBA_CMD8) U13135.J4(A8_A7)
FBA_CMD9: U13114.AC49(FBA_CMD9) U13135.J11(BA2_A4)
FBA_CMD10: U13114.AD52(FBA_CMD10) U13135.J10(BA1_A5)
FBA_CMD11: U13114.AD51(FBA_CMD11) U13135.L10(BA3_A3)
FBA_CMD12: U13114.AD50(FBA_CMD12) U13135.L11(BA0_A2)
FBA_CMD13: R22010.2 U13114.AF50(FBA_CMD13) U13135.M11(CKE_N)
FBA_CMD14: U13114.AF51(FBA_CMD14) U13135.K12(A15_A14)
FBA_CMD15: U13114.AF52(FBA_CMD15) U13135.H11(WE_N)
FBA_CMD16: U13114.AN50(FBA_CMD16) U13136.M4(CAS_N)
FBA_CMD17: R22013.1 U13114.AN51(FBA_CMD17) U13136.K2(RESET_N)
FBA_CMD18: U13114.AN52(FBA_CMD18) U13136.H4(RAS_N)
FBA_CMD19: U13114.AM49(FBA_CMD19) U13136.J5(A9_A1)
FBA_CMD20: U13114.AM52(FBA_CMD20) U13136.J4(A10_A0)
FBA_CMD21: U13114.AM51(FBA_CMD21) U13136.K5(A12_A13)
FBA_CMD22: U13114.AM50(FBA_CMD22) U13136.K4(ABI_N)
FBA_CMD23: U13114.AK50(FBA_CMD23) U13136.L5(A11_A6)
FBA_CMD24: U13114.AK51(FBA_CMD24) U13136.L4(A8_A7)
FBA_CMD25: U13114.AK52(FBA_CMD25) U13136.L11(BA2_A4)
FBA_CMD26: U13114.AJ49(FBA_CMD26) U13136.L10(BA1_A5)
FBA_CMD27: U13114.AJ52(FBA_CMD27) U13136.J10(BA3_A3)
FBA_CMD28: U13114.AJ51(FBA_CMD28) U13136.J11(BA0_A2)
FBA_CMD29: R22012.2 U13114.AJ50(FBA_CMD29) U13136.H11(CKE_N)
FBA_CMD30: U13114.AG50(FBA_CMD30) U13136.K12(A15_A14)
FBA_CMD31: U13114.AG51(FBA_CMD31) U13136.M11(WE_N)
FBA_DBI0: U13114.U47(FBA_DQM0) U13135.R3(DBI0_N)
FBA_DBI1: U13114.Y48(FBA_DQM1) U13135.R12(DBI1_N)
FBA_DBI2: U13114.AG47(FBA_DQM2) U13135.E12(DBI2_N)
FBA_DBI3: U13114.AC48(FBA_DQM3) U13135.E3(DBI3_N)
FBA_DBI4: U13114.BB51(FBA_DQM4) U13136.E3(DBI0_N)
FBA_DBI5: U13114.AV50(FBA_DQM5) U13136.E12(DBI1_N)
FBA_DBI6: U13114.AM48(FBA_DQM6) U13136.R12(DBI2_N)
FBA_DBI7: U13114.AR49(FBA_DQM7) U13136.R3(DBI3_N)
FBA_DEBUG0: R21503.1 U13114.Y50(FBA_CMD34)
FBA_DEBUG1: R21504.1 U13114.AR50(FBA_CMD35)
FBA_EDC0: U13114.R48(FBA_DQS_WP0) U13135.T3(EDC0)
FBA_EDC1: U13114.V48(FBA_DQS_WP1) U13135.T12(EDC1)
FBA_EDC2: U13114.AF44(FBA_DQS_WP2) U13135.D12(EDC2)
FBA_EDC3: U13114.AA48(FBA_DQS_WP3) U13135.D3(EDC3)
FBA_EDC4: U13114.BB52(FBA_DQS_WP4) U13136.D3(EDC0)
FBA_EDC5: U13114.AT50(FBA_DQS_WP5) U13136.D12(EDC1)
FBA_EDC6: U13114.AK48(FBA_DQS_WP6) U13136.T12(EDC2)
FBA_EDC7: U13114.AR51(FBA_DQS_WP7) U13136.T3(EDC3)
FBA_PLL_AVDD: C95047.1 C95048.2 C95053.2 C95054.2 C95058.2 C95059.1 C95060.1 L4245.1 U13114.AF42(FB_REFPLL_AVDD0) U13114.AN42(FBA_PLL_AVDD) U13114.L17(FBC_PLL_AVDD) U13114.L29(FB_REFPLL_AVDD1) U13114.L38(FBB_PLL_AVDD) U13114.V11(FBD_PLL_AVDD)
FBA_VREFC: C95691.1 C95711.1 R21859.2 R21860.2 R21862.2 U13135.K13(VREFC) U13136.K13(VREFC)
FBA_VREFC_CTL: Q7876.3(D) R21862.1
FBB_CMD0: U13114.B35(FBB_CMD0) U13137.H4(CAS_N)
FBB_CMD1: R22015.1 U13114.A35(FBB_CMD1) U13137.K2(RESET_N)
FBB_CMD2: U13114.D35(FBB_CMD2) U13137.M4(RAS_N)
FBB_CMD3: U13114.A36(FBB_CMD3) U13137.L5(A9_A1)
FBB_CMD4: U13114.B36(FBB_CMD4) U13137.L4(A10_A0)
FBB_CMD5: U13114.C36(FBB_CMD5) U13137.K5(A12_A13)
FBB_CMD6: U13114.C38(FBB_CMD6) U13137.K4(ABI_N)
FBB_CMD7: U13114.B38(FBB_CMD7) U13137.J5(A11_A6)
FBB_CMD8: U13114.A38(FBB_CMD8) U13137.J4(A8_A7)
FBB_CMD9: U13114.D38(FBB_CMD9) U13137.J11(BA2_A4)
FBB_CMD10: U13114.A39(FBB_CMD10) U13137.J10(BA1_A5)
FBB_CMD11: U13114.B39(FBB_CMD11) U13137.L10(BA3_A3)
FBB_CMD12: U13114.C39(FBB_CMD12) U13137.L11(BA0_A2)
FBB_CMD13: R22014.2 U13114.C41(FBB_CMD13) U13137.M11(CKE_N)
FBB_CMD14: U13114.B41(FBB_CMD14) U13137.K12(A15_A14)
FBB_CMD15: U13114.A41(FBB_CMD15) U13137.H11(WE_N)
FBB_CMD16: U13114.B49(FBB_CMD16) U13138.M4(CAS_N)
FBB_CMD17: R22017.1 U13114.A49(FBB_CMD17) U13138.K2(RESET_N)
FBB_CMD18: U13114.A48(FBB_CMD18) U13138.H4(RAS_N)
FBB_CMD19: U13114.D47(FBB_CMD19) U13138.J5(A9_A1)
FBB_CMD20: U13114.A47(FBB_CMD20) U13138.J4(A10_A0)
FBB_CMD21: U13114.B47(FBB_CMD21) U13138.K5(A12_A13)
FBB_CMD22: U13114.C47(FBB_CMD22) U13138.K4(ABI_N)
FBB_CMD23: U13114.C45(FBB_CMD23) U13138.L5(A11_A6)
FBB_CMD24: U13114.B45(FBB_CMD24) U13138.L4(A8_A7)
FBB_CMD25: U13114.A45(FBB_CMD25) U13138.L11(BA2_A4)
FBB_CMD26: U13114.D44(FBB_CMD26) U13138.L10(BA1_A5)
FBB_CMD27: U13114.A44(FBB_CMD27) U13138.J10(BA3_A3)
FBB_CMD28: U13114.B44(FBB_CMD28) U13138.J11(BA0_A2)
FBB_CMD29: R22016.2 U13114.C44(FBB_CMD29) U13138.H11(CKE_N)
FBB_CMD30: U13114.C42(FBB_CMD30) U13138.K12(A15_A14)
FBB_CMD31: U13114.B42(FBB_CMD31) U13138.M11(WE_N)
FBB_DBI0: U13114.C32(FBB_DQM0) U13137.R3(DBI0_N)
FBB_DBI1: U13114.E33(FBB_DQM1) U13137.R12(DBI1_N)
FBB_DBI2: U13114.E44(FBB_DQM2) U13137.E12(DBI2_N)
FBB_DBI3: U13114.G39(FBB_DQM3) U13137.E3(DBI3_N)
FBB_DBI4: U13114.P49(FBB_DQM4) U13138.E3(DBI0_N)
FBB_DBI5: U13114.L48(FBB_DQM5) U13138.E12(DBI1_N)
FBB_DBI6: U13114.D50(FBB_DQM6) U13138.R12(DBI2_N)
FBB_DBI7: U13114.H50(FBB_DQM7) U13138.R3(DBI3_N)
FBB_DEBUG0: R21511.1 U13114.C35(FBB_CMD34)
FBB_DEBUG1: R21513.1 U13114.B50(FBB_CMD35)
FBB_EDC0: U13114.B33(FBB_DQS_WP0) U13137.T3(EDC0)
FBB_EDC1: U13114.E35(FBB_DQS_WP1) U13137.T12(EDC1)
FBB_EDC2: U13114.G44(FBB_DQS_WP2) U13137.D12(EDC2)
FBB_EDC3: U13114.H38(FBB_DQS_WP3) U13137.D3(EDC3)
FBB_EDC4: U13114.P50(FBB_DQS_WP4) U13138.D3(EDC0)
FBB_EDC5: U13114.J48(FBB_DQS_WP5) U13138.D12(EDC1)
FBB_EDC6: U13114.D51(FBB_DQS_WP6) U13138.T12(EDC2)
FBB_EDC7: U13114.F51(FBB_DQS_WP7) U13138.T3(EDC3)
FBB_VREFC: C95731.1 C95751.1 R21864.2 R21866.2 R21867.2 U13137.K13(VREFC) U13138.K13(VREFC)
FBB_VREFC_CTL: Q7877.3(D) R21866.1
FBC_CMD0: U13114.C11(FBC_CMD0) U13139.H4(CAS_N)
FBC_CMD1: R22019.1 U13114.B11(FBC_CMD1) U13139.K2(RESET_N)
FBC_CMD2: U13114.A11(FBC_CMD2) U13139.M4(RAS_N)
FBC_CMD3: U13114.D11(FBC_CMD3) U13139.L5(A9_A1)
FBC_CMD4: U13114.A12(FBC_CMD4) U13139.L4(A10_A0)
FBC_CMD5: U13114.B12(FBC_CMD5) U13139.K5(A12_A13)
FBC_CMD6: U13114.C12(FBC_CMD6) U13139.K4(ABI_N)
FBC_CMD7: U13114.C14(FBC_CMD7) U13139.J5(A11_A6)
FBC_CMD8: U13114.B14(FBC_CMD8) U13139.J4(A8_A7)
FBC_CMD9: U13114.A14(FBC_CMD9) U13139.J11(BA2_A4)
FBC_CMD10: U13114.D14(FBC_CMD10) U13139.J10(BA1_A5)
FBC_CMD11: U13114.A15(FBC_CMD11) U13139.L10(BA3_A3)
FBC_CMD12: U13114.B15(FBC_CMD12) U13139.L11(BA0_A2)
FBC_CMD13: R22018.2 U13114.C15(FBC_CMD13) U13139.M11(CKE_N)
FBC_CMD14: U13114.C17(FBC_CMD14) U13139.K12(A15_A14)
FBC_CMD15: U13114.B17(FBC_CMD15) U13139.H11(WE_N)
FBC_CMD16: U13114.B24(FBC_CMD16) U13140.M4(CAS_N)
FBC_CMD17: R22021.1 U13114.A24(FBC_CMD17) U13140.K2(RESET_N)
FBC_CMD18: U13114.D23(FBC_CMD18) U13140.H4(RAS_N)
FBC_CMD19: U13114.A23(FBC_CMD19) U13140.J5(A9_A1)
FBC_CMD20: U13114.B23(FBC_CMD20) U13140.J4(A10_A0)
FBC_CMD21: U13114.C23(FBC_CMD21) U13140.K5(A12_A13)
FBC_CMD22: U13114.C21(FBC_CMD22) U13140.K4(ABI_N)
FBC_CMD23: U13114.B21(FBC_CMD23) U13140.L5(A11_A6)
FBC_CMD24: U13114.A21(FBC_CMD24) U13140.L4(A8_A7)
FBC_CMD25: U13114.D20(FBC_CMD25) U13140.L11(BA2_A4)
FBC_CMD26: U13114.A20(FBC_CMD26) U13140.L10(BA1_A5)
FBC_CMD27: U13114.B20(FBC_CMD27) U13140.J10(BA3_A3)
FBC_CMD28: U13114.C20(FBC_CMD28) U13140.J11(BA0_A2)
FBC_CMD29: R22020.2 U13114.C18(FBC_CMD29) U13140.H11(CKE_N)
FBC_CMD30: U13114.B18(FBC_CMD30) U13140.K12(A15_A14)
FBC_CMD31: U13114.A18(FBC_CMD31) U13140.M11(WE_N)
FBC_DBI0: U13114.A5(FBC_DQM0) U13139.R3(DBI0_N)
FBC_DBI1: U13114.C8(FBC_DQM1) U13139.R12(DBI1_N)
FBC_DBI2: U13114.J18(FBC_DQM2) U13139.E12(DBI2_N)
FBC_DBI3: U13114.F12(FBC_DQM3) U13139.E3(DBI3_N)
FBC_DBI4: U13114.D29(FBC_DQM4) U13140.E3(DBI0_N)
FBC_DBI5: U13114.E27(FBC_DQM5) U13140.E12(DBI1_N)
FBC_DBI6: U13114.F20(FBC_DQM6) U13140.R12(DBI2_N)
FBC_DBI7: U13114.E26(FBC_DQM7) U13140.R3(DBI3_N)
FBC_DEBUG0: R21510.1 U13114.A9(FBC_CMD34)
FBC_DEBUG1: R21512.1 U13114.C24(FBC_CMD35)
FBC_EDC0: U13114.D5(FBC_DQS_WP0) U13139.T3(EDC0)
FBC_EDC1: U13114.D8(FBC_DQS_WP1) U13139.T12(EDC1)
FBC_EDC2: U13114.E17(FBC_DQS_WP2) U13139.D12(EDC2)
FBC_EDC3: U13114.E12(FBC_DQS_WP3) U13139.D3(EDC3)
FBC_EDC4: U13114.E30(FBC_DQS_WP4) U13140.D3(EDC0)
FBC_EDC5: U13114.B29(FBC_DQS_WP5) U13140.D12(EDC1)
FBC_EDC6: U13114.G21(FBC_DQS_WP6) U13140.T12(EDC2)
FBC_EDC7: U13114.E24(FBC_DQS_WP7) U13140.T3(EDC3)
FBC_VREFC: C95771.1 C95791.1 R21869.2 R21870.2 R21872.2 U13139.K13(VREFC) U13140.K13(VREFC)
FBC_VREFC_CTL: Q7878.3(D) R21872.1
FBD_CMD0: U13114.AD2(FBD_CMD0) U13141.H4(CAS_N)
FBD_CMD1: R22022.1 U13114.AD1(FBD_CMD1) U13141.K2(RESET_N)
FBD_CMD2: U13114.AD4(FBD_CMD2) U13141.M4(RAS_N)
FBD_CMD3: U13114.AC1(FBD_CMD3) U13141.L5(A9_A1)
FBD_CMD4: U13114.AC2(FBD_CMD4) U13141.L4(A10_A0)
FBD_CMD5: U13114.AC3(FBD_CMD5) U13141.K5(A12_A13)
FBD_CMD6: U13114.AA3(FBD_CMD6) U13141.K4(ABI_N)
FBD_CMD7: U13114.AA2(FBD_CMD7) U13141.J5(A11_A6)
FBD_CMD8: U13114.AA1(FBD_CMD8) U13141.J4(A8_A7)
FBD_CMD9: U13114.AA4(FBD_CMD9) U13141.J11(BA2_A4)
FBD_CMD10: U13114.Y1(FBD_CMD10) U13141.J10(BA1_A5)
FBD_CMD11: U13114.Y2(FBD_CMD11) U13141.L10(BA3_A3)
FBD_CMD12: U13114.Y3(FBD_CMD12) U13141.L11(BA0_A2)
FBD_CMD13: R22023.2 U13114.V3(FBD_CMD13) U13141.M11(CKE_N)
FBD_CMD14: U13114.V2(FBD_CMD14) U13141.K12(A15_A14)
FBD_CMD15: U13114.V1(FBD_CMD15) U13141.H11(WE_N)
FBD_CMD16: U13114.L3(FBD_CMD16) U13142.M4(CAS_N)
FBD_CMD17: R22024.1 U13114.L2(FBD_CMD17) U13142.K2(RESET_N)
FBD_CMD18: U13114.L1(FBD_CMD18) U13142.H4(RAS_N)
FBD_CMD19: U13114.M4(FBD_CMD19) U13142.J5(A9_A1)
FBD_CMD20: U13114.M1(FBD_CMD20) U13142.J4(A10_A0)
FBD_CMD21: U13114.M2(FBD_CMD21) U13142.K5(A12_A13)
FBD_CMD22: U13114.M3(FBD_CMD22) U13142.K4(ABI_N)
FBD_CMD23: U13114.P3(FBD_CMD23) U13142.L5(A11_A6)
FBD_CMD24: U13114.P2(FBD_CMD24) U13142.L4(A8_A7)
FBD_CMD25: U13114.P1(FBD_CMD25) U13142.L11(BA2_A4)
FBD_CMD26: U13114.R4(FBD_CMD26) U13142.L10(BA1_A5)
FBD_CMD27: U13114.R1(FBD_CMD27) U13142.J10(BA3_A3)
FBD_CMD28: U13114.R2(FBD_CMD28) U13142.J11(BA0_A2)
FBD_CMD29: R22025.2 U13114.R3(FBD_CMD29) U13142.H11(CKE_N)
FBD_CMD30: U13114.U3(FBD_CMD30) U13142.K12(A15_A14)
FBD_CMD31: U13114.U2(FBD_CMD31) U13142.M11(WE_N)
FBD_DBI0: U13114.AJ1(FBD_DQM0) U13141.R3(DBI0_N)
FBD_DBI1: U13114.AG1(FBD_DQM1) U13141.R12(DBI1_N)
FBD_DBI2: U13114.AA7(FBD_DQM2) U13141.E12(DBI2_N)
FBD_DBI3: U13114.AD5(FBD_DQM3) U13141.E3(DBI3_N)
FBD_DBI4: U13114.D3(FBD_DQM4) U13142.E3(DBI0_N)
FBD_DBI5: U13114.H3(FBD_DQM5) U13142.E12(DBI1_N)
FBD_DBI6: U13114.U5(FBD_DQM6) U13142.R12(DBI2_N)
FBD_DBI7: U13114.M9(FBD_DQM7) U13142.R3(DBI3_N)
FBD_DEBUG0: R21522.1 U13114.AD3(FBD_CMD34)
FBD_DEBUG1: R21523.1 U13114.J3(FBD_CMD35)
FBD_EDC0: U13114.AJ3(FBD_DQS_WP0) U13141.T3(EDC0)
FBD_EDC1: U13114.AG2(FBD_DQS_WP1) U13141.T12(EDC1)
FBD_EDC2: U13114.AA9(FBD_DQS_WP2) U13141.D12(EDC2)
FBD_EDC3: U13114.AF4(FBD_DQS_WP3) U13141.D3(EDC3)
FBD_EDC4: U13114.E3(FBD_DQS_WP4) U13142.D3(EDC0)
FBD_EDC5: U13114.H2(FBD_DQS_WP5) U13142.D12(EDC1)
FBD_EDC6: U13114.U6(FBD_DQS_WP6) U13142.T12(EDC2)
FBD_EDC7: U13114.M5(FBD_DQS_WP7) U13142.T3(EDC3)
FBD_VREFC: C95811.1 C95831.1 R21874.2 R21876.2 R21877.2 U13141.K13(VREFC) U13142.K13(VREFC)
FBD_VREFC_CTL: Q7879.3(D) R21877.1
FBVDD_EN: PR9123.2 U13118.4(Y)
