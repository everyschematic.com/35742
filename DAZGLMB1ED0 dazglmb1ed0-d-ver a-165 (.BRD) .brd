# Allegro board DAZGLMB1ED0 dazglmb1ed0-d-ver a-165 (.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DMI_RXP3: length 132
  TOP w0.14: v1(229.5,109.13) 229.48,109.11 229.48,108.75 229.61,108.61 229.85,108.61 229.97,108.73 U41.J8 ; U13113.A30 291.69,67.12 291.57,67.25 291.18,67.25 291.1,67.17 v1(291.1,67.05)
  IN5 w0.089: v1(291.1,67.05) 290.89,67.05 290.8,67.14 290.8,67.47 291.02,67.69 291.39,67.69 291.69,67.39 291.69,64.35 291.21,63.87 288.03,63.87 286.3,65.6 284.67,65.6 282.78,67.48 282.78,72.72 280.98,74.53 280.98,78.2 266.33,92.84 233.91,92.84 226.69,100.07 218.74,100.07 213.94,104.86 213.94,109.45 216.56,112.07 221.58,112.07 222.16,112.65 225,112.65 225.99,111.66 228.45,111.66 229.24,110.87 229.24,110.2 229.17,110.13 228.7,110.13 228.62,110.05 228.62,109.82 228.72,109.72 229.15,109.72 229.26,109.62 229.26,109.19 229.31,109.13 v1(229.5,109.13)
DMI_TXN0: length 103.2
  TOP w0.079: v1(223.22,109.65) 223.22,109.36 223.8,108.78 224.18,108.78 224.23,108.72 U41.A8
  TOP w0.14: U13113.L27 296.73,65.45 296.73,65.77 v2(296.61,65.89)
  IN5 w0.089: v1(223.22,109.65) 223.22,109.3 223.74,108.78 224.35,108.78 225.48,107.65 225.48,106.88 226.72,105.64 227.89,105.64 235.65,97.88 256.46,97.88 256.55,97.79 256.55,96.95 256.74,96.77 257.14,96.77 257.33,96.95 257.33,97.79 257.42,97.88 266.83,97.88 280.39,84.32 281.06,84.32 285.55,79.83 285.55,79.5 286.08,78.97 287.76,78.97 288.65,78.08 288.65,76.6 289.89,75.36 291.54,75.36 292.77,74.13 295.03,74.13 297.63,71.53 297.63,66.89 297.37,66.63 297.16,66.63 296.92,66.39 296.92,66.19 v2(296.61,65.89)
DMI_TXN1: length 104.7
  TOP w0.079: v1(224.07,107.84) 224.5,108.27 225.97,108.27 226.06,108.18 226.06,108.09 U41.B6
  TOP w0.14: U13113.E24 293.93,64.23 294.05,64.35 294.05,64.66 293.93,64.78 v2(293.77,64.78)
  IN5 w0.089: v1(224.07,107.84) 223.95,107.71 223.95,107.42 224.76,106.6 224.76,105.21 223.45,103.91 223.45,103.46 223.78,103.14 228.48,103.14 234.69,96.93 253.1,96.93 254.23,95.8 267.56,95.8 280.4,82.96 281.03,82.96 284.59,79.4 284.59,77.29 285.19,76.7 285.19,74.35 287.68,71.85 290.65,71.85 293.03,69.46 293.03,67.94 293.24,67.73 293.24,67.1 293.64,66.69 294.61,66.69 295.37,65.93 295.37,65.68 295.77,65.28 295.77,64.47 295.35,64.05 294.3,64.05 294.1,64.25 294.1,64.65 293.97,64.78 v2(293.77,64.78)
DMI_TXN2: length 100.6
  TOP w0.14: U13113.G27 294.23,65.34 294.13,65.44 294.13,65.73 294.29,65.89 v2(294.48,65.89) ; v1(223.29,105.91) 223.36,105.91 224.51,107.05 225.14,107.05 U41.A5
  IN5 w0.089: v1(223.29,105.91) 223.46,106.09 223.63,106.09 223.78,105.94 223.78,105.26 222.72,104.21 222.72,103.16 223.6,102.29 228.3,102.29 234.39,96.2 252.8,96.2 253.93,95.07 267.12,95.07 280.02,82.17 280.8,82.17 283.87,79.1 283.87,77.93 283.32,77.38 283.32,75.13 286,72.45 286,70.4 286.25,70.15 290.38,70.15 292.18,68.35 292.18,67.71 292.46,67.43 292.46,66.11 293.31,65.27 293.92,65.27 294.11,65.45 294.11,65.76 294.24,65.89 v2(294.48,65.89)
DMI_TXN3: length 99.1
  TOP w0.079: U41.B4 226.45,106.43 226.54,106.34 226.54,106.22 226.41,106.09 226.08,106.09 225.91,106.26 225.91,106.53 225.74,106.71 225.12,106.71 224.81,106.4 224.81,106.32 224.78,106.29
  TOP w0.14: U13113.L29 296.51,66.52 296.33,66.7 296.33,66.86 296.56,67.09 v2(296.61,67.09) ; 224.78,106.29 224.23,105.74 224.23,104.33 v1(224.33,104.23)
  IN5 w0.089: v1(224.33,104.23) 224.33,103.76 224.38,103.7 229.23,103.7 235.44,97.49 254.66,97.49 254.84,97.3 254.84,96.45 254.93,96.36 255.2,96.36 255.29,96.45 255.29,97.3 255.47,97.49 255.88,97.49 256.07,97.3 256.07,96.45 256.16,96.36 267.8,96.36 280.63,83.52 281.29,83.52 285.16,79.66 285.16,78.01 288.52,74.64 289.51,74.64 292.06,72.1 292.06,71.4 292.76,70.7 294.92,70.7 295.55,70.08 295.55,68.19 296.25,67.49 296.25,67.34 296.5,67.09 v2(296.61,67.09)
DMI_TXP0: length 103.3
  TOP w0.079: v1(223.81,109.34) 223.81,109 223.87,108.94 224.24,108.94 224.3,108.88 224.94,108.88 225.09,109.03 225.39,109.03 225.71,108.72 U41.B8
  TOP w0.14: U13113.N27 297.08,65.34 296.95,65.47 296.95,65.61 v2(297.22,65.89)
  IN5 w0.089: v1(223.81,109.34) 223.69,109.23 223.69,109.07 223.81,108.95 224.42,108.95 225.65,107.72 225.65,106.95 226.79,105.81 227.96,105.81 235.72,98.05 256.53,98.05 256.72,97.86 256.72,97.02 256.81,96.93 257.07,96.93 257.16,97.02 257.16,97.86 257.35,98.05 266.9,98.05 280.46,84.48 281.13,84.48 285.72,79.9 285.72,79.57 286.15,79.14 287.83,79.14 288.82,78.15 288.82,76.67 289.96,75.53 291.61,75.53 292.84,74.3 295.1,74.3 297.8,71.6 297.8,66.83 297.44,66.46 297.23,66.46 297.09,66.32 297.09,66.02 v2(297.22,65.89)
DMI_TXP1: length 104.7
  TOP w0.079: U41.C6 226.53,107.93 226.03,108.43 224.44,108.43 224.3,108.29 223.77,108.29 v1(223.67,108.4)
  TOP w0.14: U13113.G24 294.27,64.3 294.27,64.57 v2(294.48,64.78)
  IN5 w0.089: v1(223.67,108.4) 223.64,108.37 223.64,107.69 223.78,107.55 223.78,107.35 224.59,106.53 224.59,105.28 223.29,103.98 223.29,103.39 223.71,102.97 228.41,102.97 234.62,96.76 253.03,96.76 254.16,95.63 267.49,95.63 280.33,82.8 280.97,82.8 284.43,79.33 284.43,77.22 285.02,76.63 285.02,74.28 287.61,71.68 290.58,71.68 292.87,69.39 292.87,67.87 293.07,67.66 293.07,67.03 293.57,66.52 294.54,66.52 295.2,65.86 295.2,65.61 295.6,65.21 295.6,64.54 295.28,64.22 294.37,64.22 294.27,64.32 294.27,64.57 v2(294.48,64.78)
DMI_TXP2: length 100.7
  TOP w0.14: v2(293.77,65.89) 293.91,65.75 293.91,65.47 293.72,65.29 U13113.E26 ; v1(223.31,106.6) 223.67,106.6 224.4,107.32 224.9,107.32 225.11,107.53 225.52,107.53 U41.B5
  IN5 w0.089: v2(293.77,65.89) 293.94,65.71 293.94,65.52 293.85,65.44 293.37,65.44 292.63,66.18 292.63,67.5 292.35,67.78 292.35,68.42 290.45,70.31 286.32,70.31 286.17,70.47 286.17,72.52 283.48,75.2 283.48,77.31 284.03,77.86 284.03,79.17 280.87,82.34 280.09,82.34 267.19,95.23 254,95.23 252.87,96.36 234.46,96.36 228.37,102.45 223.67,102.45 222.89,103.23 222.89,104.14 223.95,105.19 223.95,106.01 223.7,106.25 223.65,106.25 v1(223.31,106.6)
DMI_TXP3: length 99.1
  TOP w0.079: 224.59,106.48 224.62,106.51 224.7,106.51 225.05,106.86 225.8,106.86 225.86,106.8 226.3,106.8 226.81,106.3 U41.D4
  TOP w0.14: U13113.K29 296.11,66.77 296.11,66.89 v2(295.9,67.09) ; 224.59,106.48 223.96,105.85 223.96,104.7 223.84,104.59 v1(223.84,103.72)
  IN5 w0.089: v1(223.84,103.72) 224.12,103.72 224.31,103.53 229.16,103.53 235.37,97.32 254.59,97.32 254.67,97.23 254.67,96.38 254.86,96.19 255.27,96.19 255.45,96.38 255.45,97.23 255.54,97.32 255.81,97.32 255.9,97.23 255.9,96.38 256.09,96.19 267.73,96.19 280.56,83.36 281.22,83.36 284.99,79.59 284.99,77.94 288.45,74.47 289.44,74.47 291.89,72.03 291.89,71.33 292.69,70.54 294.85,70.54 295.38,70.01 295.38,68.12 296.08,67.42 296.08,67.27 v2(295.9,67.09)
DMIC_CLK: length 359.9
  TOP w0.14: R22083.1 C94968.1 36.49,35.57 36.8,35.88 v1(37.33,35.88)
  IN2 w0.089: v1(351.99,60.54) 351.99,61.23 352.72,61.97 353.63,61.97 354.08,62.42 354.08,64.1 356.36,66.39 356.36,73.21 353.5,76.08 352.61,76.08 v1(351.78,76.9)
  IN5 w0.089: v1(351.99,60.54) 351.23,59.78 349.34,59.78 348.74,60.38 347.57,60.38 346.81,59.62 342.27,59.62 341.93,59.27 340.25,59.27 340.15,59.38 338.16,59.38 335.89,57.12 335.89,54.27 334.42,52.79 332.64,52.79 332.15,52.31 332.15,51.92 330.74,50.51 329.66,50.51 328.02,48.87 323.6,48.87 322.45,47.72 315.76,47.72 315.03,46.99 290.88,46.99 290.48,46.59 288.98,46.59 287.03,48.54 268.57,48.54 268.4,48.7 266.99,48.7 264.96,46.67 257.16,46.67 256.79,46.3 203.92,46.3 203.05,47.17 198.38,47.17 198.04,47.51 191.14,47.51 189.69,46.05 181.52,46.05 179.84,47.73 173.28,47.73 98.29,47.73 97.87,47.32 95.58,47.32 94.18,45.92 93.4,45.92 92.76,45.28 92.76,44.88 92.52,44.64 91.01,43.97 87.88,43.97 85.81,41.89 83.98,41.89 83.62,41.53 76.94,41.53 75.84,40.43 68.73,40.43 68.43,40.73 65.78,40.73 64.69,39.64 62,39.64 61.42,40.22 57.43,40.22 55.58,38.37 52.66,38.37 50.97,36.69 50.97,34.72 50.41,34.15 42.61,34.15 41.88,34.88 40.72,34.88 39.31,36.29 37.74,36.29 v1(37.33,35.88)
  BOTTOM w0.14: R20952.1 351.94,77.05 v1(351.78,76.9)
DMIC_CLK_C: length 3.2
  TOP w0.14: CN2042.25 351.35,79.47 v1(351.45,79.37) 351.58,79.24 D8555.1
  BOTTOM w0.14: R20952.2 351.45,79.2 v1(351.45,79.37)
DMIC_DAT: length 361.6
  TOP w0.14: R22084.2 35.83,34.06 36.14,33.75 C94967.1 36.46,33.97 v1(36.9,34.41)
  IN2 w0.089: v1(352.65,60.54) 352.65,61.03 353.13,61.51 353.66,61.51 354.42,62.27 354.42,63.96 355.55,65.09 356.71,66.24 356.71,73.35 352.77,77.29 351.46,77.29 v1(351.07,76.9)
  IN5 w0.089: v1(36.9,34.41) 40.04,34.41 40.17,34.54 41.73,34.54 42.5,33.77 50.57,33.77 51.35,34.56 51.35,36.58 52.76,37.99 55.74,37.99 57.63,39.88 61.28,39.88 61.89,39.26 64.84,39.26 65.93,40.35 68.27,40.35 68.57,40.05 76,40.05 77.1,41.15 83.72,41.15 84.12,41.55 85.95,41.55 88.03,43.62 91.15,43.62 92.6,44.27 92.64,44.27 93.1,44.74 93.1,45.14 93.54,45.58 94.32,45.58 95.72,46.97 98.02,46.97 98.43,47.39 124.61,47.39 179.7,47.39 181.38,45.71 189.83,45.71 191.28,47.17 197.9,47.17 198.24,46.82 202.91,46.82 203.78,45.95 257.18,45.95 257.55,46.32 265.15,46.32 267.18,48.36 268.24,48.36 268.4,48.2 286.88,48.2 288.84,46.24 290.63,46.24 291.03,46.64 315.18,46.64 315.87,47.34 319.81,47.34 320.44,46.7 321.13,46.7 321.76,47.34 322.55,47.34 323.74,48.53 328.16,48.53 329.76,50.13 330.87,50.13 332.51,51.77 332.51,52.18 332.78,52.45 334.56,52.45 336.24,54.13 336.24,56.33 336.69,56.78 338.36,56.78 340.51,58.93 342.07,58.93 342.41,59.27 346.95,59.27 347.71,60.04 348.6,60.04 349.2,59.44 351.91,59.44 352.65,60.18 v1(352.65,60.54)
  BOTTOM w0.14: v1(351.07,76.9) 350.79,77.18 R20950.1
DMIC_DATA_C: length 3
  TOP w0.14: CN2042.24 350.85,79.44 v1(350.8,79.39) 350.57,79.16 D8556.1
  BOTTOM w0.14: v1(350.8,79.39) 350.79,79.39 R20950.2
DNBSWON#: length 159.8
  TOP w0.102: U13113.AT13 307.68,58.48 307.34,58.14
  TOP w0.14: v1(184.22,53.1) 184.68,53.56 184.68,55.74 184.11,56.31 184.11,57.95 184.8,58.63 184.8,61.58 185.17,61.95 185.17,62.53 182.52,65.18 182.52,65.98 182,66.5 U49.123 ; v2(306.09,56.79) 306.24,56.63 307.03,56.63 307.16,56.76 307.16,57.96 307.34,58.14
  IN4 w0.089: v1(179.44,50.24) 179.44,50.49 179.8,50.85 195.85,50.85 196.06,51.06 205.22,51.06 205.56,51.4 237.56,51.4 238.79,50.18 264.31,50.18 265.08,50.94 288.15,50.94 289.67,49.42 291.26,49.42 292.81,50.97 292.81,51.39 295.26,53.84 300.44,53.84 300.63,54.03 302.68,54.03 303.34,54.69 303.34,55.77 303.67,56.1 305.33,56.1 306.01,56.79 v2(306.09,56.79)
  BOTTOM w0.14: v1(184.22,53.1) 183.37,52.25 180.7,52.25 179.59,51.13 179.59,50.38 v1(179.44,50.24)
DP_D0: length 143.9
  TOP w0.14: v2(154.12,116.66) 154.46,116.32 U13114.BH17 ; C94726.2 240.69,167.45 v1(240.76,167.38)
  IN2 w0.089: v2(154.12,116.66) 154.12,116.93 154.25,117.06 154.55,117.06 154.71,116.91 154.71,115.94 155.98,114.67 172.41,114.67 173.15,113.94 175.61,113.94 176.17,114.49 189.07,114.49 191.14,112.43 204.89,112.43 206.88,114.42 206.88,116.53 207.72,117.37 207.72,133.4 208.53,134.2 208.53,163.71 210.01,165.19 212.71,165.19 216.11,168.58 216.44,168.58 217.06,169.21 239.67,169.21 241.07,167.81 241.07,167.58 240.86,167.38 v1(240.76,167.38)
DP_D0#: length 143.9
  TOP w0.14: U13114.BG17 154.46,117.03 v2(154.1,117.39) ; v1(241.5,167.38) 241.57,167.45 C94719.2
  IN2 w0.089: v2(154.1,117.39) 154.25,117.24 154.63,117.24 154.88,116.98 154.88,116.02 156.05,114.85 172.48,114.85 173.22,114.11 175.54,114.11 176.1,114.67 189.15,114.67 191.21,112.61 204.82,112.61 206.7,114.49 206.7,116.6 207.54,117.44 207.54,133.47 208.35,134.28 208.35,163.78 209.93,165.36 212.64,165.36 216.03,168.76 216.37,168.76 216.99,169.38 239.75,169.38 241.24,167.89 241.24,167.63 v1(241.5,167.38)
DP_D1: length 156
  TOP w0.14: v2(153.46,117.39) 153.44,117.39 U13114.BG15 ; v1(243.45,167.38) 243.78,167.71 243.78,167.79 243.68,167.89 C94737.2
  IN2 w0.089: v2(153.46,117.39) 153.46,117.54 153.33,117.67 153.21,117.67 152.85,117.31 152.85,117.08 153.06,116.88 153.06,115 153.28,114.77 154.55,114.77 155.16,114.16 156.48,114.16 156.59,114.06 172.05,114.06 172.79,113.33 175.69,113.33 176.25,113.88 188.82,113.88 190.88,111.82 204.97,111.82 208.19,115.04 208.19,131.07 209.01,131.89 209.01,160.82 216.3,168.11 216.99,168.11 217.08,168.2 217.08,168.54 217.28,168.74 217.72,168.74 217.91,168.54 217.91,168.2 218,168.11 218.29,168.11 218.38,168.2 218.38,168.54 218.57,168.74 219.01,168.74 219.2,168.54 219.2,168.2 219.29,168.11 219.59,168.11 219.67,168.2 219.67,168.54 219.87,168.74 220.31,168.74 220.5,168.54 220.5,168.2 220.59,168.11 220.88,168.11 220.97,168.2 220.97,168.54 221.16,168.74 221.6,168.74 221.8,168.54 221.8,168.2 221.88,168.11 222.18,168.11 222.27,168.2 222.27,168.54 222.46,168.74 222.9,168.74 223.09,168.54 223.09,168.2 223.18,168.11 223.47,168.11 223.56,168.2 223.56,168.54 223.75,168.74 224.19,168.74 224.39,168.54 224.39,168.2 224.48,168.11 224.77,168.11 224.86,168.2 224.86,168.54 225.05,168.74 225.49,168.74 225.68,168.54 225.68,168.2 225.77,168.11 238.65,168.11 240.76,166.01 243.63,166.01 243.79,166.16 243.79,167.3 243.71,167.38 v1(243.45,167.38)
DP_D1#: length 156.1
  TOP w0.14: C94738.2 244.37,167.58 v1(244.16,167.38) ; v2(153.49,118) 153.2,117.71 U13114.BF15
  IN2 w0.089: v2(153.49,118) 153.34,117.85 153.14,117.85 152.67,117.39 152.67,117.01 152.88,116.81 152.88,114.93 153.21,114.6 154.48,114.6 155.09,113.99 156.41,113.99 156.51,113.88 171.98,113.88 172.71,113.15 175.76,113.15 176.32,113.71 188.74,113.71 190.81,111.65 205.04,111.65 208.37,114.97 208.37,131 209.19,131.82 209.19,160.75 216.37,167.94 217.07,167.94 217.26,168.13 217.26,168.47 217.35,168.56 217.64,168.56 217.73,168.47 217.73,168.13 217.92,167.94 218.36,167.94 218.56,168.13 218.56,168.47 218.65,168.56 218.94,168.56 219.03,168.47 219.03,168.13 219.22,167.94 219.66,167.94 219.85,168.13 219.85,168.47 219.94,168.56 220.23,168.56 220.32,168.47 220.32,168.13 220.52,167.94 220.95,167.94 221.15,168.13 221.15,168.47 221.24,168.56 221.53,168.56 221.62,168.47 221.62,168.13 221.81,167.94 222.25,167.94 222.44,168.13 222.44,168.47 222.53,168.56 222.82,168.56 222.91,168.47 222.91,168.13 223.11,167.94 223.55,167.94 223.74,168.13 223.74,168.47 223.83,168.56 224.12,168.56 224.21,168.47 224.21,168.13 224.4,167.94 224.84,167.94 225.03,168.13 225.03,168.47 225.12,168.56 225.41,168.56 225.5,168.47 225.5,168.13 225.7,167.94 238.58,167.94 240.69,165.83 243.71,165.83 243.96,166.08 243.96,167.18 v1(244.16,167.38)
DP_D2: length 159.7
  TOP w0.14: v1(246.25,166.84) 246.03,167.06 246.01,167.06 245.61,167.45 C94735.2 ; U13114.BE14 152.35,118.41 v2(151.96,118.03)
  IN2 w0.089: v1(246.25,166.84) 245.77,166.36 245.77,165.57 244.85,164.66 244.85,164.57 244.32,164.04 238.15,164.04 236.92,165.27 229.38,165.27 228.93,164.82 216.58,164.82 210.61,158.85 210.61,131.03 209.8,130.22 209.8,114.47 205.35,110.02 190.45,110.02 189.29,111.18 179.13,111.18 174.26,106.32 173.72,106.32 173.3,106.74 173.3,107.44 171.41,109.33 167.03,109.33 166.32,110.04 164.41,110.04 162.45,111.99 157.26,111.99 156.02,110.76 154.05,110.76 153.03,111.78 153.03,112.31 151,114.34 151,114.8 150.77,115.03 150.77,116.93 151.03,117.2 151.03,117.35 151.38,117.69 151.53,117.69 151.66,117.82 151.76,117.82 v2(151.96,118.03)
DP_D2#: length 159.6
  TOP w0.14: C94736.2 246.7,167.97 246.2,167.97 246.04,167.82 246.04,167.68 v1(246.2,167.53) ; U13114.BF14 152.06,117.42 v2(151.96,117.42)
  IN2 w0.089: v2(151.96,117.42) 151.96,117.57 151.89,117.64 151.73,117.64 151.61,117.52 151.45,117.52 151.21,117.28 151.21,117.12 150.95,116.86 150.95,115.1 151.18,114.88 151.18,114.42 153.21,112.38 153.21,111.85 154.12,110.94 155.95,110.94 157.18,112.17 162.53,112.17 164.48,110.21 166.39,110.21 167.1,109.51 171.48,109.51 173.48,107.51 173.48,106.81 173.79,106.49 174.19,106.49 179.05,111.36 189.36,111.36 190.52,110.2 205.28,110.2 209.62,114.54 209.62,130.29 210.43,131.11 210.43,158.92 216.51,164.99 228.86,164.99 229.31,165.45 237,165.45 238.22,164.22 244.25,164.22 244.67,164.64 244.67,164.73 245.59,165.65 245.59,166.44 245.84,166.69 245.84,167.45 245.92,167.53 v1(246.2,167.53)
DP_D3: length 154.8
  TOP w0.14: U13114.BH14 152.05,116.01 v2(151.98,116.01) ; C94720.1 248.07,167.89 248.23,167.73 248.23,167.56 v1(248.03,167.35)
  IN2 w0.089: v1(248.03,167.35) 248.2,167.35 248.43,167.58 248.43,167.81 248.05,168.19 245.28,168.19 244.95,167.86 244.95,165.83 244.26,165.14 243.02,165.14 242.63,164.75 238.35,164.75 236.82,166.29 229.74,166.29 229.31,166.72 227.65,166.72 227.22,166.29 215.82,166.29 209.87,160.34 209.87,131.39 209.09,130.6 209.09,114.72 205.17,110.81 190.6,110.81 189.25,112.16 172.29,112.16 171.35,113.1 157.17,113.1 157.09,113.02 155.65,113.02 155.47,113.2 153.41,113.2 152.23,114.38 152.23,115.97 152.19,116.01 v2(151.98,116.01)
DP_D3#: length 154.8
  TOP w0.14: U13114.BG14 151.97,116.62 v2(151.94,116.62) ; C94721.1 248.94,167.56 v1(248.76,167.38)
  IN2 w0.089: v1(248.76,167.38) 248.61,167.53 248.61,167.88 248.12,168.37 245.21,168.37 244.77,167.93 244.77,165.9 244.19,165.32 242.95,165.32 242.56,164.93 238.43,164.93 236.9,166.46 229.81,166.46 229.38,166.89 227.58,166.89 227.15,166.46 215.74,166.46 209.7,160.42 209.7,131.46 208.91,130.67 208.91,114.8 205.1,110.99 190.68,110.99 189.33,112.34 172.36,112.34 171.42,113.28 157.09,113.28 157.02,113.2 155.72,113.2 155.54,113.38 153.49,113.38 152.41,114.46 152.41,116.13 151.94,116.59 v2(151.94,116.62)
DP_HPD: length 19.3
  TOP w0.14: v1(252.29,168.49) 252.11,168.31 ESD8.7 ESD8.4
  IN1 w0.089: v1(257.2,173.96) 250.97,173.96 250.5,173.48 CN2043.18 250.7,172.92 251.23,173.45 251.78,173.45 252.5,172.74 252.5,168.7 v1(252.29,168.49)
  BOTTOM w0.14: R22136.2 257.73,171.45 257.57,171.62 C95933.1 257.57,173.58 v1(257.2,173.96)
DP_HPD_PCH: length 431.2
  TOP w0.14: v1(329.15,52.85) 328.98,52.85 327.88,53.95 326.92,53.95 326.17,54.7 R67234.2 326.17,55.97 326.94,56.74 Q7932.3 ; v1(198.57,50.64) 198.57,51.07 200.33,52.82 202.05,52.82 202.89,53.66 202.89,54.07 204.79,55.97 v1(205.25,55.97) ; C95079.2 133.55,118.46 133.49,118.52 R21563.2 133.49,119.08 132.2,120.36 131.69,120.36 131.5,120.55 131.15,120.55 v1(130.96,120.74)
  IN1 w0.089: v1(197.84,92.52) 197.47,92.89 155.82,92.89 150.97,97.74 138.79,97.74 138.28,98.25 134.26,98.25 133.61,98.9 129.48,98.9 127.74,100.64 127.74,108.89 126.76,109.88 126.76,114.7 126.61,114.85 126.61,115.38 125.52,116.48 125.52,117.31 126.08,117.87 126.51,117.87 127.66,119.02 127.66,119.7 128.7,120.74 v1(130.96,120.74)
  IN2 w0.089: v1(329.15,52.85) 329.15,51.99 328.44,51.27 328.44,50.38 327.93,49.88 326.41,49.88 323.79,47.25 321.22,47.25 320.88,47.59 320.44,47.59 320.19,47.34 318.85,47.34 317.45,45.94 316.5,45.94 315.56,45 307.16,45 v1(306.52,45.64)
  IN3 w0.079: v1(198.57,50.64) 198.57,50.59 198.83,50.33 203.68,50.33 203.81,50.46 222.32,50.46 223.03,49.75 223.03,47.36 224.47,45.93 237.07,45.93 238.02,46.88 255.62,46.88 256.35,47.61 264.39,47.61 264.56,47.44 267.71,47.44 268.65,48.38 286.69,48.38 288.93,46.14 288.93,46.14 306.02,46.14 v1(306.52,45.64)
  IN5 w0.089: v1(205.25,55.97) 205.25,56.1 205.56,56.41 205.56,63.82 203.11,66.27 203.11,70.74 204.12,71.75 204.12,78.13 205.73,79.75 205.73,85.6 204.4,86.92 201.26,86.92 198.39,89.78 198.39,91.96 v1(197.84,92.52) 197.84,93.64 203.14,98.95 203.14,108.8 209.69,115.35 209.69,128.43 211.26,130 211.26,160.84 213.41,162.99 213.41,165.52 217.34,169.45 257.61,169.45 v1(257.86,169.69)
  BOTTOM w0.14: v1(257.86,169.69) 258.18,170.02 R22136.1
DP_HPD_PCH_R: length 24.2
  TOP w0.14: U13113.AY2 310.37,53.86 v2(310.31,53.86) ; R67235.1 329.13,60.4 329.08,60.35 v1(326.98,60.35) 326.77,60.35 Q7932.1 324.96,58.54 v1(324.96,58.3)
  IN5 w0.089: v1(324.96,58.3) 324.45,58.3 323.62,57.47 323.62,57.12 323.11,56.61 319.93,56.61 319.43,57.12 318.84,57.12 317.95,56.23 317.52,56.23 317.01,55.72 313.46,55.72 313.2,55.97 312.19,55.97 311.93,55.72 311.93,55.08 311.68,54.83 311.04,54.83 310.31,54.09 v2(310.31,53.86)
DPEQ0_A1_EDP: length 7
  TOP w0.14: v1(331.44,74.71) U13079.14
  BOTTOM w0.14: R20913.2 331.92,79.85 331.82,79.75 331.82,79.26 331.95,79.14 R20915.2 331.11,77.85 v1(331.11,77.39) 330.92,77.2 330.92,75.23 v1(331.44,74.71)
DPEQ0_A1_TBT: length 3.3
  TOP w0.14: U13025.14 v1(331.16,56.3)
  BOTTOM w0.14: R20825.1 R20826.1 331.11,56.35 v1(331.16,56.3) v1(331.69,55.77)
DPEQ1_EDP: length 3.6
  TOP w0.14: U13079.2 335.28,78.13 v1(335.5,78.35)
  BOTTOM w0.14: v1(335.5,78.35) 335.48,78.32 335.16,78.32 R20917.2 334.84,79.54 R20916.2 335.44,79.59 v1(335.71,79.32)
DPEQ1_TBT: length 2.5
  TOP w0.14: R20827.1 R20828.1 335.03,60.3 U13025.2
DPSNK_RBIAS_1: length 2.9
  TOP w0.14: U21.Y18 346.47,50.24 v4(346.47,49.57)
  BOTTOM w0.14: v1(345.38,48.74) R400.1 346.22,48.96 346.47,49.21 v4(346.47,49.57)
DRAM_RESET#: length 13.3
  TOP w0.102: U13113.BC14 312.48,59.17 313.08,59.17 313.19,59.28 313.51,59.28 313.76,59.53 314.37,59.53 v1(314.8,59.1)
  TOP w0.14: v1(321.81,58.31) 322.31,58.31 R21108.2 323.61,58.79 R21113.1
  IN1 w0.089: v1(314.8,59.1) 315.24,59.54 317.49,59.54 318.27,58.75 320.55,58.75 320.9,58.4 321.72,58.4 v1(321.81,58.31)
DSWROK_EC_R: length 3.4
  TOP w0.114: U13113.AV11 309.9,57.25 309.65,56.99 v2(309.62,56.99)
  BOTTOM w0.14: R21141.2 310.51,57.51 310.29,57.29 309.94,57.29 309.65,56.99 v2(309.62,56.99)
EAPD: length 32.8
  TOP w0.203: v1(36.9,50.79) 36.9,50.08 37.69,49.29 37.69,48.12 37.92,47.9 D13067.1
  IN3 w0.203: v1(35.02,30.98) 34.69,30.65 33.5,30.65 32.84,31.31 32.84,33.37 32,34.21 32,35.45 32.43,35.88 33.37,35.88 33.88,36.39 33.88,36.98 33.8,37.05 33.8,44.82 33.95,44.97 33.95,46.35 33.4,46.91 33.4,47.64 35.52,49.76 35.52,50.55 36.01,51.03 36.66,51.03 v1(36.9,50.79)
  BOTTOM w0.203: R22089.1 36.98,50.87 v1(36.9,50.79) ; v1(35.02,30.98) 34.9,31.1 R22088.2
EC_AMP_GAIN0: length 208.4
  TOP w0.14: U49.77 192.49,58 v1(192.09,58.39)
  TOP w0.203: v1(22.09,17.9) 22.07,17.88 U13150.6
  IN3 w0.079: v1(62.86,46.91) 63.32,46.44 66.57,46.44 67.84,45.17 73.29,45.17 73.79,44.68 76.58,44.68 77,44.25 78.87,44.25 79.51,44.88 88.23,44.88 89.17,45.83 90.06,45.83 94.01,49.78 168.37,49.78 171.37,52.78 171.37,54.1 172.86,55.59 174.77,55.59 175.27,56.09 176.5,56.09 178.67,58.26 181.67,58.26 182.11,57.82 182.11,57.4 182.36,57.15 184.49,57.15 185.11,57.77 187.06,57.77 187.43,58.14 191.84,58.14 v1(192.09,58.39)
  IN5 w0.089: v1(62.86,46.91) 62.38,46.42 61.89,46.42 61.62,46.7 61.62,46.73 61.44,46.91 60.04,46.91 59.13,45.99 59.13,44.57 58.62,44.06 53.28,44.06 52.14,45.2 51.46,45.2 51.28,45.03 50.46,45.03 49.65,44.21 49.65,42.82 48.97,42.13 42.67,42.13 41.53,43.27 40.81,43.27 40.05,42.51 40.05,40.48 39.19,39.62 39.19,38.6 38.91,38.32 37.5,38.32 35.91,36.73 35.91,36.36 35.55,36 35.55,32.61 36.19,31.97 36.19,31.08 35.84,30.73 35.84,28.59 32.11,24.86 30.65,24.86 25.45,19.65 25.45,18.33 24.33,17.21 22.78,17.21 22.1,17.9 v1(22.09,17.9)
  BOTTOM w0.14: v1(22.09,17.9) 22.62,17.37 v1(22.78,17.37)
  BOTTOM w0.203: v1(22.09,17.9) 21.94,17.75 R67202.1
EC_AMP_GAIN1: length 206.3
  TOP w0.14: U49.83 192.39,60.4 191.95,59.96 190.42,59.96 189.76,59.3 v1(189.76,59.1)
  TOP w0.203: U13150.7 21.78,18.38 21.97,18.56 v1(22.12,18.56)
  IN3 w0.079: v1(62.17,46.91) 62.78,47.51 64.92,47.51 65.83,46.6 66.64,46.6 67.91,45.33 73.36,45.33 73.85,44.83 75.02,44.83 75.23,45.04 88.12,45.04 89.12,46.04 90.04,46.04 94,50 168.37,50 171.18,52.81 171.18,54.13 172.79,55.75 174.71,55.75 175.23,56.27 176.46,56.27 178.6,58.41 181.74,58.41 182.15,58 187.06,58 187.36,58.29 189.03,58.29 189.76,59.02 v1(189.76,59.1)
  IN5 w0.089: v1(22.12,18.56) 23.24,17.44 24.3,17.44 25.22,18.36 25.22,19.67 30.63,25.09 32.09,25.09 35.66,28.66 35.66,30.81 36.01,31.16 36.01,31.89 35.35,32.55 35.35,36.01 35.36,36.01 35.36,36.08 35.72,36.44 35.72,36.83 38.32,39.44 38.32,40.86 39.67,42.21 39.67,42.59 40.94,43.86 41.19,43.86 42.74,42.31 46.35,42.31 46.86,42.82 46.86,43.58 47.65,44.37 48.18,44.37 50.59,46.78 51.68,46.78 52.73,47.82 58.01,47.82 58.84,48.66 59.94,48.66 61.74,46.85 62.12,46.85 v1(62.17,46.91)
  BOTTOM w0.203: R67203.1 21.13,18.48 21.2,18.56 v1(22.12,18.56)
EC_FPBACK#: length 206.6
  TOP w0.14: v1(344.9,90.14) 344.9,90.72 344.62,91 Q7824.2 ; v1(192.93,70.83) 193.22,70.83 194.43,69.62 194.43,66.92 194.63,66.72 194.63,66.16 194.39,65.91 193.22,65.91 193.09,65.79 193.09,65.34 192.45,64.7 191.89,64.7 190.8,63.61 190.8,62.37 191.21,61.96 192.8,61.96 193.16,61.6 U49.86
  IN3 w0.079: v1(344.9,90.14) 344.34,90.14 342.15,87.96 340.14,87.96 335.92,83.74 335.6,83.74 335.12,83.25 334.61,83.25 334.31,82.95 334.31,82.59 332.97,81.25 314.96,81.25 313.69,79.98 311.09,79.98 309.78,81.3 309.05,81.3 308.42,80.67 303.05,80.67 301.22,82.49 299.41,82.49 298.82,83.08 289.96,83.08 289.96,83.08 289.65,83.08 289.27,83.08 288.17,84.18 285.77,84.18 284.65,85.3 283.29,85.3 282.3,86.29 282.3,86.75 279.98,89.07 208.09,89.07 206.07,91.09 201.7,91.09 198.95,88.34 198.95,79.78 197.32,78.15 194.14,78.15 189.67,73.68 187.22,73.68 187.01,73.47 v1(185.85,73.47)
  BOTTOM w0.14: v1(185.85,73.47) 187.29,72.03 190.04,72.03 190.67,71.39 192.37,71.39 v1(192.93,70.83)
EC_I2C_SCL_AMP: length 4.4
  TOP w0.14: Q7915.4 15.61,31.11 R67017.1 15.78,31.28 16.71,31.28 v1(17.04,30.95) 17.58,30.42 U13151.3
EC_I2C_SDA_AMP: length 11.9
  TOP w0.14: U13151.4 17.08,30.23 16.66,30.65 14.45,30.65 14.04,30.24 v1(12.03,30.24) 10.84,30.24 10.31,30.78 10.31,31.87 10.75,32.31 R67016.1 12.27,32.31 12.47,32.11 Q7915.1
EC_PECI: length 169.3
  TOP w0.14: v1(269.64,131.16) 270.14,131.66 R563.2 270.01,131.79 C802.2 269.36,131.64 269.11,131.39 268.35,131.39 267.84,130.88 267.84,129.35 266.62,128.13 265.92,128.13 U41.BT34
  IN2 w0.089: v1(204.97,96) 204.97,94.89 205.39,94.47 205.39,91.95 206.58,90.76 206.58,80.88 203.3,77.6 203.3,72.99 204.87,71.42 204.87,68.75 204.34,68.22 202.03,68.22 200.81,69.43 198.22,69.43 197.66,68.88 196.39,68.88 195.71,69.56 195.19,69.56 194.51,68.88 191.02,68.88 190.44,69.46 189.66,69.46 188.63,70.49 185.25,70.49 v1(184.7,71.04)
  IN3 w0.079: v1(269.64,131.16) 265.28,126.8 265.28,125.19 264.85,124.76 262.73,124.76 262.17,124.2 262.17,115.03 262.55,114.65 265.98,114.65 268.29,112.34 268.29,110.96 268.14,110.81 268.14,104.87 268.63,104.39 268.63,103.24 268.27,102.89 267.51,102.89 264.85,100.23 207.76,100.23 207.52,100.47 206.35,100.47 205.2,99.32 205.2,96.23 v1(204.97,96)
  BOTTOM w0.14: R395.2 184.81,68.22 184.7,68.32 v1(184.7,71.04)
EC_PECR_R: length 4.4
  TOP w0.14: v1(184.35,65.37) 184.58,65.6 184.58,66.18 184.4,66.36 U49.117
  BOTTOM w0.14: v1(184.35,65.37) 185.11,65.37 v1(185.24,65.5) 184.81,65.93 R395.1
EC_PWROK: length 156.4
  TOP w0.14: U49.33 180,50.84 179.86,50.7 179,50.7 178.06,49.76 v1(178.06,49.12) ; R21152.2 319.24,45.62 318.5,46.36 U13098.1 317.15,46.36 317.05,46.46 317.05,46.69 317.29,46.93 317.9,46.93 318.03,47.06 R21157.2 317.58,47.43 317.52,47.37 R21148.2 316.53,47.37 316.44,47.28 C94815.1 315.95,46.91 v1(315.49,46.45) 315.23,46.7 R21159.2 314.56,47.05 314.27,47.34 v1(314.27,47.62)
  IN5 w0.089: v1(178.06,49.12) 178.06,48.8 178.48,48.38 180.05,48.38 180.53,47.9 187.68,47.9 188.08,47.49 189.68,47.49 190.32,48.13 198.27,48.13 198.63,47.76 203.3,47.76 204.17,46.89 233.42,46.89 233.79,47.27 242.99,47.27 243.36,46.89 256.5,46.89 256.87,47.27 258.48,47.27 259.32,48.1 263.8,48.1 265.28,49.58 268.39,49.58 268.84,49.14 287.27,49.14 289.22,47.18 290.22,47.18 290.62,47.58 302.2,47.58 302.94,48.33 313.56,48.33 v1(314.27,47.62)
EC_PWROK_R: length 27.5
  TOP w0.102: U13113.AW11 310.2,57.04 v2(310.2,56.84)
  TOP w0.14: v1(322.7,51.58) 322.36,51.24 322.36,51.13 321.71,50.49 321.34,50.49 321.08,50.22 321.08,48.33 v1(320.97,48.23) 320.96,48.21 R67172.2 R21156.1 R21157.1
  IN4 w0.089: v1(322.7,51.58) 322.7,52.52 322.98,52.8 322.98,54.45 321.84,55.59 319.43,55.59 318.41,54.58 318.41,53.69 317.82,53.1 316.02,53.1 315,54.12 314.3,54.12 312.95,55.46 312.95,55.65 312.12,56.48 310.56,56.48 v2(310.2,56.84)
EC_WIGIG_PERST1#: length 146.3
  IN3 w0.079: v1(51.81,52.92) 51.96,52.77 56.61,52.77 57.47,51.91 57.47,50.21 58.29,49.39 59.64,49.39 60.38,48.66 61.11,48.66 61.23,48.53 63.14,48.53 63.48,48.19 66.37,48.19 66.93,47.63 66.93,46.75 68.04,45.65 73.49,45.65 73.81,45.97 74.85,45.97 75.41,45.41 80.12,45.41 80.17,45.36 87.91,45.36 88.95,46.4 89.91,46.4 93.89,50.38 168.3,50.38 170.75,52.83 170.75,54.18 174.1,57.54 177.17,57.54 178.36,58.73 180.7,58.73 181.16,59.19 v1(181.16,59.27)
  BOTTOM w0.14: v1(181.16,59.27) 181.87,59.27 182,59.41 R67039.1 ; v1(51.81,52.92) 52.24,52.92 53.27,53.95 v1(53.27,54.56) R21996.2
ECAGND: length 4.3
  TOP w0.203: v1(192.81,57.45) 193.05,57.2 U49.75
  IN4 w0.508: v1(191.18,56.25) 192.37,57.45 v1(192.81,57.45)
  BOTTOM w0.508: v1(191.18,56.25) 191.34,56.09 C574.1
  vias: v1(193.21,57.95)
EDP_AUX#_C: length 23
  TOP w0.14: v1(341.14,79.09) 341.35,79.29 CN2042.5 ; R20924.2 334.91,69.5 334.91,69.95 334.68,70.18 334.68,70.34 334.56,70.46 v1(334.56,70.65) 334.48,70.73 U13079.25
  IN1 w0.089: v1(334.56,70.65) 334.56,71.24 336.34,73.02 336.34,74.48 337.11,75.25 337.31,75.25 v1(341.14,79.09)
  BOTTOM w0.14: C94697.2 341.4,78.83 v1(341.14,79.09) 340.93,79.3 340.93,82.08 341.15,82.3 C94699.2 341.15,82.94 340.98,83.1 340.98,83.37 340.95,83.4 340.95,83.97 R20942.2 R20943.1
EDP_AUX_C: length 23.2
  TOP w0.14: U13079.24 334.08,70.86 v1(333.9,70.68) 334.23,70.35 334.23,70.34 334.37,70.21 334.37,70.04 334.6,69.81 334.6,69.5 R20925.1 ; CN2042.4 340.85,79.46 v1(340.48,79.09)
  IN1 w0.089: v1(333.9,70.68) 334.39,71.16 334.39,71.31 336.16,73.09 336.16,74.55 337.04,75.43 337.23,75.43 340.53,78.73 340.53,79.04 v1(340.48,79.09)
  BOTTOM w0.14: C94698.2 340.51,79.06 v1(340.48,79.09) 340.62,79.22 340.62,82.19 340.5,82.3 C94700.2 340.5,82.94 340.67,83.1 340.67,83.24 340.63,83.27 340.63,83.9 R20940.2 R20941.1
EDP_DISP_UTIL: length 4
  TOP w0.14: T3.1 222.02,128.13 225.19,128.13 U41.A33
EDP_HPD_CPU: length 70.6
  TOP w0.127: U13113.BD7 313.03,55.41 313.44,55.41 313.94,54.91 313.94,54.49
  TOP w0.14: v1(316.31,51.66) 316.31,52.16 315.27,53.2 315.23,53.2 313.94,54.49
  IN2 w0.089: v1(316.31,51.66) 317.77,51.66 318.14,51.29 318.14,50.27 318.48,49.93 318.65,49.93 318.86,49.72 321.28,49.72 321.41,49.59 321.75,49.59 322.03,49.87 323.87,49.87 325.98,51.97 325.98,52.92 326.97,53.91 326.97,58.14 328.67,59.84 329.05,59.84 330.02,60.8 330.02,62.73 328.29,64.46 v1(328.29,66.67)
  IN5 w0.089: v1(328.29,66.67) 328.29,67.16 328.71,67.59 329.65,67.59 329.77,67.47 330.29,67.47 330.47,67.66 330.47,68.29 334.03,71.85 335.43,71.85 336.49,72.91 338.55,72.91 338.91,72.56 338.91,72.05 339.63,71.33 340.6,71.33 343.45,74.18 343.45,75.21 344.1,75.86 345.61,75.86 346.1,76.34 346.8,76.34 347.03,76.11 348.13,76.11 348.89,76.88 348.89,78.86 v1(348.36,79.39)
  BOTTOM w0.14: R20939.2 v1(349.14,80.86) 348.36,80.08 v1(348.36,79.39) ; R67231.1 317.14,51.46 R67230.2 316.69,51.03 316.31,51.41 v1(316.31,51.66)
EDP_HPD_GPU: length 238
  TOP w0.14: v1(142.13,98.92) 142.13,99.28 142.83,99.97 C95081.2 R21564.2
  IN1 w0.089: v1(282.6,79.75) 285.21,79.75 287.2,81.74 298.19,81.74 298.85,81.08 306.15,81.08 306.72,80.51 308.71,80.51 309.27,79.95 311.42,79.95 311.75,80.28 314.57,80.28 315.11,80.81 328.73,80.81 330.05,82.13 332.25,82.13 332.38,82.26 333.27,82.26 333.55,81.98 338.5,81.98 339.36,81.12 339.36,79.21 338.73,78.58 338.19,78.58 337.05,77.44 v1(337.05,77.31)
  IN4 w0.089: v1(142.13,98.92) 142.54,99.33 147.15,99.33 147.67,98.8 148.83,98.8 149.55,98.09 150.14,98.09 156.86,91.37 169.25,91.37 174.47,86.14 183.13,86.14 183.39,86.4 197.38,86.4 198.98,84.8 205.23,84.8 207.51,87.09 219.01,87.09 219.83,86.28 274.89,86.28 281.41,79.75 v1(282.6,79.75)
  IN5 w0.089: v1(337.05,77.31) 337.76,78.02 341.73,78.02 342.54,78.83 342.54,79.53 343.54,80.53 348.13,80.53 v1(349.5,81.91)
  BOTTOM w0.14: R20944.2 349.6,82.01 v1(349.5,81.91) ; R20923.2 339.03,75.91 337.64,77.31 v1(337.05,77.31)
EDP_HPD_GPU_Q: length 12.2
  TOP w0.14: R21564.1 141.25,103.2 141.25,105.68 141.07,105.87 141.07,106.44 138.59,108.92 137.85,108.92 137.21,109.57 v1(137.21,110.13) R21568.1 137.42,110.74 Q7854.2
EDP_HPD_R: length 3.3
  TOP w0.14: v1(353.08,82.39) 353.35,82.12 CN2042.29
  BOTTOM w0.14: v1(353.08,82.39) 353.13,82.34 R22071.1 v1(353.89,81.55)
EDP_HPD_RR: length 4
  BOTTOM w0.14: R20944.1 R20939.1 350.94,80.86 C95899.1 352.49,80.43 v1(352.88,80.43) 353.13,80.69 R22071.2
EDP_RCOMP: length 6.6
  TOP w0.127: U41.D37 227.18,129.95 225.7,129.95 225.61,130.04 224.64,130.04 224.55,130.13 ; v1(221.38,129.3) 221.75,129.3 222.02,129.57 R116.2
  TOP w0.508: 224.55,130.13 R116.2
EDP_TXN0_C: length 4.9
  TOP w0.14: C94677.2 342.69,78.4 342.69,78.83 v1(343,79.14) 342.74,79.39 342.74,79.98 342.85,80.09 CN2042.8
  BOTTOM w0.14: v1(343,79.14) 342.71,79.42 342.71,80.29 342.92,80.5 C94679.2
EDP_TXN1_C: length 4.7
  TOP w0.14: CN2042.11 344.35,80.09 344.28,80.02 344.28,79.46 v1(344.52,79.21) 344.28,78.97 344.28,78.34 344.3,78.31 344.3,78.31 C94688.2
  BOTTOM w0.14: C94686.2 344.44,80.5 344.3,80.35 344.3,80.35 344.29,80.33 344.29,79.45 v1(344.52,79.21)
EDP_TXN2_C: length 4.7
  TOP w0.14: CN2042.14 345.85,80.09 345.77,80.01 345.77,79.46 v1(345.99,79.24) 345.76,79.01 345.76,78.37 C94690.2
  BOTTOM w0.14: C94692.2 345.97,80.49 345.76,80.28 345.76,79.47 v1(345.99,79.24)
EDP_TXN3_C: length 4.6
  TOP w0.14: CN2042.17 347.35,80.09 347.23,79.97 347.23,79.52 v1(347.45,79.3) 347.31,79.16 347.31,78.35 C94694.2
  BOTTOM w0.14: C94696.2 347.49,80.56 347.24,80.31 347.24,79.52 v1(347.45,79.3)
EDP_TXP0_C: length 4.9
  TOP w0.14: C94676.2 342.37,78.38 342.37,78.88 v1(342.08,79.16) 342.42,79.51 342.42,80.01 342.35,80.09 CN2042.7
  BOTTOM w0.14: C94678.2 342.16,80.5 342.39,80.26 342.39,79.47 v1(342.08,79.16)
EDP_TXP1_C: length 4.7
  TOP w0.14: C94684.2 343.96,78.45 343.96,79.09 v1(343.83,79.21) 343.96,79.34 343.96,79.98 343.85,80.09 CN2042.10
  BOTTOM w0.14: v1(343.83,79.21) 343.93,79.31 343.93,79.32 343.97,79.36 343.97,80.21 343.68,80.5 C94685.2
EDP_TXP2_C: length 4.7
  TOP w0.14: CN2042.13 345.35,80.09 345.46,79.98 345.46,79.44 v1(345.26,79.24) 345.45,79.05 345.45,78.41 C94689.2
  BOTTOM w0.14: v1(345.26,79.24) 345.45,79.43 345.45,80.37 345.21,80.61 C94691.2
EDP_TXP3_C: length 4.7
  TOP w0.14: C94693.2 346.73,78.17 347,78.44 347,79.02 v1(346.78,79.24) 346.92,79.37 346.92,80.02 346.85,80.09 CN2042.16
  BOTTOM w0.14: C94695.2 346.73,80.61 346.92,80.42 346.92,79.39 346.91,79.38 346.91,79.37 v1(346.78,79.24)
EDP_VDD_EN: length 5.1
  TOP w0.14: R20959.2 322.74,73.39 R20961.2 ; R20961.2 321.76,73.38 R20960.2 ; R20961.2 323.23,73.38 323.8,72.81 U13080.4 324.33,72.81 v1(325.19,71.95)
EDPC_OUTPUT_CAP: length 7.2
  TOP w0.14: U13114.BA3 144.31,120.87 140.1,120.87 139.59,120.36 R21598.2 139.31,120.62 139.11,120.82 138.5,120.82 v1(138.27,121.05)
FAN1_PWM: length 176
  TOP w0.14: Q16.1 319.81,75.68 v1(319.86,75.63) ; U49.32 180.31,53.2 180.59,53.48 182.85,53.48 183.71,54.35 183.71,55.58 183.31,55.98 183.31,58.28 184,58.97 184,61.91 182.73,63.18 v1(182.73,63.34)
  IN3 w0.079: v1(182.73,63.34) 183.12,63.73 183.23,63.73 184.72,65.22 184.72,66.45 185.4,67.13 191.87,67.13 193.48,65.51 194.35,65.51 198.13,69.29 200.58,69.29 204.13,72.84 204.13,75.11 204.29,75.27 204.29,75.95 205.28,76.94 205.42,76.94 205.96,77.48 207.09,77.48 212.75,83.14 276.16,83.14 280.63,78.66 282.5,76.8 282.5,75.8 285.75,72.54 291.19,72.54 292.39,73.74 298.75,73.74 299.74,72.75 299.74,72.1 300.09,71.75 301.3,71.75 302.14,70.91 302.77,70.91 303.31,71.45 304.93,71.45 305.3,71.82 305.3,72.68 306.39,73.77 315.47,73.77 317.81,76.12 319.37,76.12 v1(319.86,75.63)
FAN1_PWM_Q: length 5.6
  TOP w0.14: Q16.3 v1(322.97,77.82) 322.98,77.83 R229.2 C216.1 325.27,78.71 325.25,78.72 CN2045.3
FAN1_RPM: length 188.9
  TOP w0.14: C218.1 326.38,78.55 326.5,78.67 CN2045.2 ; C218.1 326.88,77.83 327.05,77.66 R223.2 ; C218.1 325.9,77.34 v1(325.9,76.22) ; v1(179.09,67.68) 179.6,67.17 179.6,66.51 179.81,66.29 180.89,66.29 181.46,65.72 181.46,65.07 182.26,64.27 182.69,64.27 184.24,62.72 184.24,62.05 184.28,62.02 184.28,58.85 183.59,58.16 183.59,56.09 184.09,55.59 184.09,53.89 183.75,53.55 183.75,52.79 184.03,52.51 185.42,52.51 185.6,52.33 U49.47
  IN3 w0.079: v1(179.09,67.68) 181.85,67.68 183,68.83 183,69.33 183.25,69.59 190.87,69.59 191.42,69.03 194.18,69.03 196.81,71.66 198.69,71.66 200.08,73.04 200.08,73.75 201.94,75.61 201.94,77.38 205.16,80.6 206.33,80.6 211.06,85.33 277.9,85.33 279.08,84.16 280.82,84.16 284.52,80.46 287.11,80.46 289.59,77.99 290.52,77.99 291.34,77.17 294.54,77.17 295.05,77.68 300.47,77.68 301.17,76.98 304.04,76.98 304.46,76.56 305.55,76.56 305.58,76.53 305.59,76.53 305.98,76.15 310.44,76.15 310.75,76.45 311.68,76.45 312.01,76.12 315.81,76.12 317.6,77.91 321.93,77.91 324.05,75.78 325.27,75.78 325.7,76.22 v1(325.9,76.22)
FAN2_PWM: length 155.6
  TOP w0.14: v1(175.41,55.52) 177.32,53.6 U49.31 ; 50.69,75.28 v1(51.89,75.28) 52.45,75.28 52.8,75.63 53.51,75.63 54.05,75.1 54.05,74.49 54.35,74.18 54.35,71.24 54.05,70.93 54.05,65.57 v1(54.45,65.17)
  IN5 w0.089: v1(175.41,55.52) 175.28,55.64 174.77,55.64 173.33,54.21 170.4,54.21 169.21,53.01 155.44,53.01 154.79,53.66 125.74,53.66 125.61,53.79 118.85,53.79 117.94,54.69 112.53,54.69 111.38,53.54 101.27,53.54 100.63,52.9 93.85,52.9 92.04,51.09 90.9,51.09 89.52,49.71 84.24,49.71 83.42,48.89 73.78,48.89 72.62,50.06 70.6,50.06 66.84,53.81 66.38,53.81 65.42,54.77 65.42,58.85 64.33,59.94 62.17,59.94 60.62,61.49 60.62,65.71 60.02,66.31 57.07,66.31 56.28,65.52 54.81,65.52 v1(54.45,65.17)
FAN2_PWM_Q: length 3.4
  TOP w0.508: v1(50.91,77.22) 50.91,77.81 v1(50.85,77.87) 50.24,77.87 Q7902.3 ; v1(54.97,76.88) CN2046.3
FAN2_RPM: length 197.4
  TOP w0.14: CN2046.2 v1(56.23,76.98) ; U49.48 186,52.34 185.24,53.1 v1(185.24,53.13)
  IN3 w0.079: v1(185.24,53.13) 184.81,53.56 180.25,53.56 179.8,53.11 178.12,53.11 172.57,47.55 99.09,47.55 98.65,47.11 93.82,47.11 90.7,43.98 89.86,43.98 88.75,42.87 84.84,42.87 84.02,42.05 80.92,42.05 78.13,39.26 75.53,39.26 74.67,38.4 71.8,38.4 70.68,39.51 69.08,39.51 68.32,40.28 65.2,40.28 64.04,41.43 62.75,41.43 62.68,41.5 61.91,41.5 61.36,42.05 58.8,42.05 58.49,42.36 50.82,42.36 48.43,44.75 47.67,44.75 v1(47.16,45.25)
  BOTTOM w0.14: v1(47.16,45.25) 47.34,45.43 47.34,47.82 46.84,48.32 45.62,48.32 45.39,48.55 45.39,54.34 43.73,56 43.73,59.07 46.42,61.76 46.42,66.58 48.31,68.47 48.31,75 50.01,76.7 50.01,77.82 50.36,78.17 51.4,78.17 51.84,78.6 54.6,78.6 v1(56.23,76.98) 56.84,76.37 C95934.1 56.95,75.93 R22138.2
FB_CAL_PD_VDDQ: length 11.7
  TOP w0.127: U13114.R44 173.32,139.41 v4(173.01,139.1)
  BOTTOM w0.127: R21604.2 182.5,139.26 181.61,139.26 181.02,138.68 180.59,138.68 180.33,138.93 180.33,139.25 180.1,139.49 173.38,139.49 173.01,139.12 v4(173.01,139.1)
FB_CAL_PU_GND: length 10
  TOP w0.127: v4(173.01,140.43) 173.32,140.11 U13114.P44
  BOTTOM w0.127: v4(173.01,140.43) 173.01,140.4 173.69,139.72 180.44,139.72 181.36,140.64 R21605.2
FB_CAL_TERM_GND: length 9.7
  TOP w0.127: v4(173.71,139.1) 174.02,139.41 U13114.R45
  BOTTOM w0.127: v4(173.71,139.1) 174.09,138.72 174.09,138.34 174.56,137.86 180.99,137.86 R21606.2
FB_VREF_PROBE: length 9.5
  TOP w0.102: v4(173.71,140.43) 174.02,140.11 U13114.P45
  BOTTOM w0.14: TP13117.1 180.18,140 174.16,140 173.73,140.43 v4(173.71,140.43)
FBA_CMD0: length 33.5
  TOP w0.102: U13135.H4 200.89,141.5 200.89,143.35 200.81,143.43 200.81,143.84 200.69,143.96 ; 183.05,137.41 183.05,136.87 182.85,136.67 182.39,136.67 181.96,136.23 178.58,136.23 U13114.Y51
  TOP w0.216: 183.05,137.41 182.54,137.91 182.54,139.21 v1(190.22,146.88) 196.24,146.88 197.48,145.63 199.36,145.63 200.6,144.39 200.6,144.05 200.69,143.96
FBA_CMD1: length 29.5
  TOP w0.102: v4(199.41,144.36) 199.66,144.11 199.66,143.4 199.6,143.34 199.6,142.79 U13135.K2 ; U13114.Y52 182.14,135.91 182.59,136.36 182.97,136.36 183.38,136.77
  TOP w0.216: v4(199.41,144.36) 198.9,144.87 197.12,144.87 195.96,146.04 v1(192.58,146.04) 190.7,146.04 183.18,138.52 183.18,137.86 183.38,137.66 183.38,136.77
  BOTTOM w0.216: R22011.1 199.54,144.49 v4(199.41,144.36)
FBA_CMD2: length 29.3
  TOP w0.102: U13135.M4 198.93,141.49 198.93,143.85 198.79,144 ; 183.15,136.06 182.62,136.06 182.12,135.56 177.21,135.56 U13114.Y49
  TOP w0.216: 198.79,144 198.69,144.09 192.79,144.09 v1(192.16,143.47) 189.44,143.47 183.81,137.84 183.81,136.72 183.15,136.06
FBA_CMD3: length 25.5
  TOP w0.102: 193.29,140.07 193.52,139.84 197.15,139.84 197.54,140.22 198.96,140.22 U13135.L5
  TOP w0.216: 193.29,140.07 193.29,141.24 v1(192.37,142.16) 189,142.16 184.27,137.43 184.27,136.72 183.22,135.67 182.69,135.67 182.32,135.29 179.03,135.29 U13114.AA52
FBA_CMD4: length 27.1
  TOP w0.102: 179.32,134.92 179.28,134.88 178.77,134.88 178.44,135.21 U13114.AA51 ; U13135.L4 199.59,140.85 199.59,140.22 199.37,140 197.62,140 197.25,139.62 193.33,139.62 192.79,140.16
  TOP w0.216: 192.79,140.16 192.79,140.87 192.12,141.55 189.25,141.55 v1(189.07,141.37) 184.75,137.05 184.75,136.49 183.56,135.3 182.85,135.3 182.47,134.92 179.32,134.92
FBA_CMD5: length 26.9
  TOP w0.102: U13135.K5 199.92,140.16 199.53,139.77 197.71,139.77 197.34,139.41 193.09,139.41 192.45,140.05 ; 182.75,134.71 182.67,134.64 178.63,134.64 178.4,134.86 178.02,134.86 177.67,135.21 U13114.AA50
  TOP w0.216: 182.75,134.71 182.9,134.87 183.71,134.87 185.19,136.34 185.19,136.62 189.5,140.94 v1(190.37,140.94) 191.87,140.94 192.45,140.35 192.45,140.05
FBA_CMD6: length 27.7
  TOP w0.102: 192.04,139.81 192.65,139.19 197.46,139.19 197.81,139.54 199.93,139.54 200.24,139.85 200.24,140.85 U13135.K4 ; U13114.AC50 177.91,134.16 178.44,134.16 178.69,134.41 183.84,134.41
  TOP w0.216: 192.04,139.81 192.04,139.91 v1(191.62,140.33) 189.76,140.33 183.84,134.41
FBA_CMD7: length 26.1
  TOP w0.102: 184.18,134.14 178.8,134.14 178.47,133.81 U13114.AC51 ; U13135.J5 200.57,139.79 200.08,139.31 197.9,139.31 197.57,138.97 192.13,138.97 191.49,139.61
  TOP w0.216: 191.49,139.61 191.38,139.72 190.14,139.72 v1(189.5,139.08) 185.97,135.55 185.59,135.55 184.18,134.14
FBA_CMD8: length 26.3
  TOP w0.102: U13135.J4 200.89,140.85 200.89,139.61 200.36,139.08 198,139.08 197.68,138.76 191.86,138.76 191.54,139.08 191.27,139.08
  TOP w0.216: 191.27,139.08 190.44,139.08 v1(188.28,136.92) 186.3,134.94 185.59,134.94 184.46,133.81 U13114.AC52
FBA_CMD9: length 28.4
  TOP w0.102: 191.27,138.47 191.69,138.47 191.84,138.32 192.4,138.32 192.62,138.54 197.78,138.54 198.09,138.85 200.13,138.85 200.89,138.09 200.89,136.95 U13135.J11 ; 184.73,133.47 177.21,133.47 U13114.AC49
  TOP w0.216: 184.73,133.47 185.6,134.33 186.74,134.33 v1(187.9,135.5) 190.88,138.47 191.27,138.47
FBA_CMD10: length 24.9
  TOP w0.102: 191.55,138.01 192.48,138.01 192.78,138.31 197.88,138.31 198.19,138.62 199.95,138.62 200.57,138 U13135.J10
  TOP w0.216: 191.55,138.01 v1(187.25,133.72) 185.59,133.72 184.98,133.11 U13114.AD52
FBA_CMD11: length 24.3
  TOP w0.102: 192.15,137.63 192.55,137.63 193,138.09 197.98,138.09 198.29,138.4 198.82,138.4 199.19,138.02 199.19,137.35 U13135.L10 ; 185.34,132.76 178.83,132.76 178.48,133.11 U13114.AD51
  TOP w0.216: 185.34,132.76 185.69,133.11 v1(185.95,133.11) 187.5,133.11 192.02,137.63 192.15,137.63
FBA_CMD12: length 25.7
  TOP w0.102: 192.45,137.2 192.6,137.2 193.26,137.86 198.1,137.86 198.41,138.17 198.76,138.17 198.97,137.96 198.97,137.52 198.93,137.48 198.93,136.97 U13135.L11 ; 185.21,132.4 180.73,132.4 180.61,132.51 178.72,132.51 178.47,132.76 178.09,132.76 177.74,133.11 U13114.AD50
  TOP w0.216: 185.21,132.4 187.65,132.4 v1(190.9,135.65) 192.45,137.2
FBA_CMD13: length 25.1
  TOP w0.102: U13135.M11 198.29,136.95 198.29,137.43 198.12,137.61 193.34,137.61 192.82,137.09 192.82,136.81 192.75,136.74 ; U13114.AF50 177.62,131.71 177.98,132.07 178.38,132.07 178.61,132.3 180.46,132.3 180.74,132.02 184.58,132.02
  TOP w0.216: 184.58,132.02 184.81,131.79 187.95,131.79 v1(188.95,132.78) 189.91,133.75 R22010.2 190.38,133.75 191.99,135.36 191.99,135.88 192.75,136.64 192.75,136.74
FBA_CMD14: length 26.5
  TOP w0.102: 199.3,134.14 199.3,134.27 199.6,134.58 199.6,135.66 U13135.K12 ; U13114.AF51 178.4,131.71 178.75,132.06 180.32,132.06 180.74,131.64 184.18,131.64 184.63,131.18
  TOP w0.216: 184.63,131.18 189.1,131.18 v1(189.86,130.42) 197.35,130.42 199.3,132.36 199.3,134.14
FBA_CMD15: length 27.9
  TOP w0.102: U13135.H11 200.88,136.29 200.88,134.14
  TOP w0.216: U13114.AF52 180.08,131.71 180.49,131.31 183.94,131.31 184.68,130.57 188.56,130.57 189.33,129.81 v1(191.21,129.81) 197.89,129.81 200.88,132.81 200.88,134.14
FBA_CMD16: length 35
  TOP w0.102: U13136.M4 200.9,117.26 200.9,114.75 ; 180.49,125.67 179.85,126.3 178.62,126.3 178.47,126.46 177.92,126.46 U13114.AN50
  TOP w0.216: 180.49,125.67 180.49,122.87 v1(189.5,113.85) 192,113.85 193.26,112.59 199.16,112.59 200.78,114.22 200.78,114.63 200.9,114.75
FBA_CMD17: length 32.3
  TOP w0.102: 180.92,125.67 180.03,126.56 179.2,126.56 179.15,126.51 178.76,126.51 178.45,126.81 U13114.AN51 ; 200.17,114.76 200.17,115.35 200.25,115.43 200.25,115.95 U13136.K2
  TOP w0.216: 180.92,125.67 180.92,123.28 189.75,114.45 v1(192.04,114.45) 192.25,114.45 193.5,113.19 198.84,113.19 v4(200.05,114.39) 200.17,114.52 200.17,114.76
  BOTTOM w0.216: v4(200.05,114.39) 199.82,114.17 R22013.1
FBA_CMD18: length 31.1
  TOP w0.102: U13114.AN52 179.01,126.86 180.18,126.86 ; 199.31,114.93 199.31,114.93 199.31,115.23 199.58,115.5 199.58,117.07 199.41,117.24 198.96,117.24 U13136.H4
  TOP w0.216: 199.31,114.93 199.31,114.52 198.58,113.79 193.75,113.79 192.49,115.04 v1(190.75,115.04) 190,115.04 181.48,123.56 181.48,125.57 180.18,126.86
FBA_CMD19: length 29.3
  TOP w0.102: U13136.J5 198.96,118.53 197.54,118.53 197.16,118.92 194.08,118.92 193.21,118.05 193.21,117.81 ; 180.39,127.17 177.4,127.17 177.16,127.41 176.96,127.41 U13114.AM49
  TOP w0.216: 180.39,127.17 182.04,125.52 182.04,123.85 v1(189.26,116.63) 192.02,116.63 193.21,117.81
FBA_CMD20: length 27.6
  TOP w0.102: U13136.J4 199.59,117.9 199.59,118.38 199.24,118.74 197.63,118.74 197.23,119.14 193.77,119.14 192.94,118.3 192.83,118.3
  TOP w0.216: 192.83,118.3 191.92,117.39 189.34,117.39 v1(186.9,119.83) 182.6,124.14 182.6,125.46 180.55,127.51 U13114.AM52
FBA_CMD21: length 27.6
  TOP w0.102: U13136.K5 199.92,118.36 199.34,118.94 197.71,118.94 197.3,119.35 193.47,119.35 192.96,118.84 192.53,118.84 192.48,118.79 192.46,118.79 ; U13114.AM51 178.52,127.51 178.85,127.84 180.73,127.84
  TOP w0.216: 192.46,118.79 191.67,118 189.58,118 184.09,123.48 184.09,123.49 v1(183.15,124.43) 183.15,125.41 180.73,127.84
FBA_CMD22: length 29.1
  TOP w0.102: 192.02,119.22 192.81,119.22 193.15,119.57 197.37,119.57 197.8,119.14 199.49,119.14 200.24,118.39 200.24,117.9 U13136.K4 ; U13114.AM50 177.82,127.51 178.15,127.84 178.45,127.84 178.73,128.11 180.97,128.11 181.3,127.78
  TOP w0.216: 192.02,119.22 191.39,118.59 189.84,118.59 v1(186.6,121.84) 183.69,124.74 183.69,125.39 181.3,127.78
FBA_CMD23: length 28.1
  TOP w0.102: U13114.AK50 177.78,128.91 178.13,128.56 178.35,128.56 178.54,128.37 181.16,128.37 181.4,128.13 ; U13136.L5 200.57,118.37 199.59,119.35 197.88,119.35 197.44,119.78 192.81,119.78 192.63,119.6 191.55,119.6
  TOP w0.216: 181.4,128.13 181.55,128.13 184.3,125.39 v1(184.3,124.98) 189.96,119.32 191.27,119.32 191.55,119.6
FBA_CMD24: length 28.1
  TOP w0.102: U13136.L4 200.89,117.9 200.89,118.4 199.72,119.58 197.95,119.58 197.53,120 191.62,120 ; 181.68,128.59 178.71,128.59 178.39,128.91 U13114.AK51
  TOP w0.216: 181.68,128.59 184.83,125.44 184.83,125.3 v1(185.75,124.38) 190.2,119.92 191.55,119.92 191.62,120
FBA_CMD25: length 27.7
  TOP w0.102: U13114.AK52 181.99,128.91 ; U13136.L11 200.89,121.81 200.89,120.67 200,119.78 198.04,119.78 197.6,120.22 192.6,120.22 192.37,120.44 191.6,120.44
  TOP w0.216: 191.6,120.44 191.46,120.44 191.37,120.53 190.6,120.53 v1(184.87,126.25) 184.64,126.25 181.99,128.91
FBA_CMD26: length 28.7
  TOP w0.102: 191.7,121.01 191.94,120.77 192.63,120.77 192.95,120.44 197.7,120.44 198.13,120.01 199.82,120.01 200.57,120.75 U13136.L10 ; 182.24,129.26 177.21,129.26 U13114.AJ49
  TOP w0.216: 191.7,121.01 191.56,121.15 191.03,121.15 v1(186.33,125.85) 185.29,126.89 184.61,126.89 182.24,129.26
FBA_CMD27: length 25.1
  TOP w0.102: 192.01,121.39 192.13,121.26 192.52,121.26 193.11,120.67 197.76,120.67 198.17,120.26 198.8,120.26 199.17,120.63 199.17,121.38 U13136.J10 ; U13114.AJ52 182.49,129.61
  TOP w0.216: 182.49,129.61 184.6,127.5 v1(185.56,127.5) 191.48,121.58 191.81,121.58 192.01,121.39
FBA_CMD28: length 26.3
  TOP w0.102: 192.34,121.72 192.5,121.56 192.58,121.56 193.23,120.9 197.84,120.9 198.22,120.51 198.71,120.51 198.94,120.75 198.94,121.8 U13136.J11 ; 182.8,129.94 178.79,129.94 178.46,129.61 U13114.AJ51
  TOP w0.216: 182.8,129.94 184.63,128.11 185.8,128.11 v1(188.28,125.62) 191.83,122.08 191.98,122.08 192.34,121.72
FBA_CMD29: length 27.1
  TOP w0.102: 180.69,130.31 180.52,130.14 178.61,130.14 178.42,129.95 178.16,129.95 177.82,129.61 U13114.AJ50 ; 192.41,122.34 192.41,122.23 193.51,121.13 198.1,121.13 198.29,121.32 198.29,121.8 U13136.H11
  TOP w0.216: 180.69,130.31 183.11,130.31 184.7,128.72 v1(186.05,128.72) 188.32,126.45 R22012.2 190.27,126.45 191.27,125.45 191.27,123.61 192.41,122.48 192.41,122.34
FBA_CMD30: length 28.5
  TOP w0.102: U13114.AG50 177.91,130.66 178.41,130.66 178.71,130.37 180.32,130.37 180.6,130.65 ; 198.95,124.29 198.95,123.25 199.09,123.1 199.59,123.1 U13136.K12
  TOP w0.216: 180.6,130.65 183.39,130.65 184.68,129.35 187.78,129.35 188.82,128.31 v1(190.09,128.31) 197.28,128.31 198.03,127.56 199.55,126.04 199.55,125.56 198.97,124.98 198.97,124.32 198.95,124.29
FBA_CMD31: length 29.1
  TOP w0.102: 180.54,130.98 180.16,130.59 178.87,130.59 178.44,131.01 U13114.AG51 ; U13136.M11 200.89,122.45 200.89,124.31 201.18,124.59 201.18,124.83
  TOP w0.216: 180.54,130.98 183.66,130.98 184.68,129.96 188.13,129.96 188.97,129.12 v1(192.76,129.12) 197.53,129.12 201.18,125.48 201.18,124.83
FBA_DBI0: length 23.6
  TOP w0.17: v4(196.34,142.15) U13135.R3
  TOP w0.216: U13114.U47 175.49,138.01 v4(175.81,138.33)
  IN4 w0.081: 194.83,141.83 195.43,141.83 195.76,142.15 v4(196.34,142.15)
  IN4 w0.14: 194.83,141.83 194.82,141.83 194.76,141.83 194.47,142.12 193.43,142.12 191.36,140.05 184.68,140.05 183.13,138.49 178.05,138.49 177.49,137.94 176.2,137.94 v4(175.81,138.33)
FBA_DBI1: length 22.6
  TOP w0.102: U13114.Y48 176.47,136.23 v4(177.21,136.23)
  TOP w0.216: v4(196.34,136.3) U13135.R12
  IN4 w0.081: 196.02,137.19 196.02,136.63 v4(196.34,136.3)
  IN4 w0.14: 196.02,137.19 196.02,137.37 195.84,137.55 191.96,137.55 190.24,135.83 177.77,135.83 177.37,136.23 v4(177.21,136.23)
FBA_DBI2: length 35.5
  TOP w0.102: U13135.E12 203.49,136.3 v4(204.14,136.3)
  TOP w0.216: v4(175.81,130.7) 175.49,131.01 U13114.AG47
  IN4 w0.081: v4(204.14,136.3) 204.53,135.92 204.53,135.37 204.47,135.31 204.47,134.74
  IN4 w0.14: 204.47,134.74 204.47,134.67 204.42,134.63 204.42,134 204.2,133.78 204.1,133.67 204.1,132.94 201.08,129.92 185.6,129.92 185.02,130.49 178.2,130.49 177.61,131.08 176.17,131.08 175.81,130.72 v4(175.81,130.7)
