# Allegro board DAZGLMB1ED0 dazglmb1ed0-d-ver a-165 (.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N34290079: length 8.3
  TOP w0.127: 143.6,120.16 U13114.BB2
  TOP w0.14: TP13114.1 137.55,119.87 137.55,119.18 137.85,118.88 138.24,118.88 138.27,118.91 139.8,118.91 140.3,119.42 141.47,119.42 142.21,120.16 143.6,120.16
N34291908: length 1.5
  TOP w0.102: U13113.AW31 310.58,67.74 v2(310.15,68.16)
  BOTTOM w0.14: v2(310.15,68.16) 309.98,67.99 309.49,67.99 TP13138.1
N34874002:
  vias: v1(219.7,169)
N34984408: length 2.4
  TOP w0.14: R222.2 318.9,78.06 319.12,77.84 v1(319.65,77.84) 319.81,77.99 Q16.2
N34985582: length 2.5
  TOP w0.14: v1(49.65,75.02) 49.4,75.28 Q7902.2
  TOP w0.508: R22140.2 47.27,75.28 Q7902.2
N34999680: length 5.9
  TOP w0.102: 309.09,53.04 308.96,53.18 308.96,53.32 308.72,53.56 U13113.AR3
  TOP w0.127: 309.09,53.04 309.09,51.88 309.5,51.48
  TOP w0.14: 309.5,51.48 310.59,51.48 311.34,50.72 v1(311.34,50.35)
  BOTTOM w0.14: v1(311.34,50.35) 311.25,50.45 TP13145.1
N35181174: length 4.9
  TOP w0.102: U13113.BC15 312.74,59.8 313.46,59.8 313.59,59.94 314.55,59.94 314.75,59.73 316.5,59.73 316.53,59.71 TP13139.1
N35181196: length 3.2
  TOP w0.102: v2(310.71,58.03) 311.16,58.48
  TOP w0.127: 311.16,58.48 U13113.BA13
  BOTTOM w0.14: TP13140.1 308.88,56.96 309.49,57.57 310.17,57.57 310.64,58.03 v2(310.71,58.03)
N35716714: length 1.4
  TOP w0.14: U13113.AN38 307.37,70.58 v1(307,70.58)
  BOTTOM w0.14: R67163.2 307.14,70.71 v1(307,70.58)
N35891430: length 3.2
  TOP w0.305: U3.18 44.09,59.38 v1(44.24,59.53) 44.37,59.53 45.13,60.29 R22185.1
N35891432: length 3
  TOP w0.14: R22167.1 34.42,53.7 v1(35.33,54.6) 35.55,54.83 U3.10
N35891440: length 2.8
  TOP w0.14: U3.2 35.9,60.03 35.76,59.88 35.65,59.88 35.14,60.39 34.98,60.39 R22208.1
N35891446: length 2.8
  TOP w0.14: R22209.1 34.45,59.92 34.65,60.13 35.03,60.13 35.54,59.62 35.67,59.62 35.91,59.38 U3.3
N35891448: length 5.9
  TOP w0.254: R22163.1 33.57,61.89 33.8,61.66 34.67,61.66 35.03,62.03 R22164.2 35.22,62.22 35.43,62.02 v1(35.43,61.36) 35.43,61.21 35.96,60.68 U3.1
N35891500:
  vias: v1(44.75,60.77)
N35891518: length 3
  TOP w0.14: U3.11 v1(42.82,54.09)
  TOP w0.305: R22168.1 43.83,54.83 U3.11
N35891538: length 5.8
  TOP w0.305: U3.17 43.66,58.73 43.87,58.51 44.27,58.51 44.65,58.13 v1(45.51,58.13) 45.92,58.13 46.38,58.6 R22166.1 R22211.2
N35891554: length 2.3
  TOP w0.14: U3.13 43.73,56.13 43.99,56.38 44.6,56.38 R22170.2
N35891556: length 2.3
  TOP w0.14: U3.14 43.71,56.78 43.84,56.65 44.54,56.65 R22169.2
N35891568: length 4.8
  TOP w0.14: R22213.1 33.01,58.64 33.19,58.82 R22210.2 34.17,58.31 35.22,58.31 v1(35.33,58.41) 35.64,58.73 U3.4
N35927903: length 3.3
  TOP w0.14: v1(19.39,25.67) 19.39,27.3 U13151.13
  TOP w0.203: C95975.1 20.51,27.1 20.28,27.33 U13151.13
N35927908: length 2.7
  TOP w0.14: C95974.2 20.56,29.76 v1(20.84,30.04)
  TOP w0.203: C95974.2 20.34,29.48 20.34,29.18 20,28.83 U13151.16
N35928782: length 3.9
  TOP w0.203: v1(18.31,30.83) 18.08,30.59 U13151.2
  BOTTOM w0.203: v1(18.31,30.83) v1(18.31,29.91) 18.31,29.63 18.68,29.26 C95976.1
N35948693: length 2
  TOP w0.203: v1(19.2,15.56) 19.33,15.69 U13150.2
  BOTTOM w0.203: v1(19.2,15.56) 19.2,15.74 18.79,16.15 C95984.2
N35948694: length 2.5
  TOP w0.203: U13150.3 19.83,15.67 v1(19.88,15.61)
  BOTTOM w0.14: v1(20.57,15.84) 20.34,15.61 v1(19.88,15.61)
  BOTTOM w0.203: v1(19.88,15.61) 19.76,15.74 C95985.2
N35948729: length 1.6
  TOP w0.203: U13150.11 19.33,20.95 19.42,21.04 C95982.1
N35948730: length 2.6
  TOP w0.14: C95982.2 20.2,21.67 v1(20.62,22.09)
  TOP w0.203: C95982.2 20.2,21.02 20.33,20.89 U13150.9
N35948737: length 3.3
  TOP w0.203: C95978.1 22.82,20.52 22.18,19.88 v1(21.84,19.88) 21.84,19.15 21.57,18.88 U13150.8
N35948761: length 2.5
  TOP w0.14: R67013.1 v1(21.84,28.15)
  TOP w0.203: R67013.1 20.68,27.83 U13151.14
N35948766: length 2.5
  TOP w0.14: v1(14.7,27.93) 14.7,27.22 C95973.2
  TOP w0.203: U13151.7 15.74,27.83 15.31,27.41 14.99,27.41 C95973.2
N35948770: length 2.4
  TOP w0.14: v1(18.4,24.85) 18.31,24.93 C95962.1
  TOP w0.203: C95962.1 17.58,25.08 17.58,25.09 U13151.10
N35948773: length 2.6
  TOP w0.203: U13151.8 15.81,27.33 15.39,26.92 v1(15.26,26.92)
  BOTTOM w0.14: v1(15.26,26.92) 15.38,27.03 v1(15.93,27.03)
  BOTTOM w0.203: v1(15.26,26.92) 15.42,26.76 R67014.1
N35948778: length 2.5
  TOP w0.203: U13151.9 17.08,25.91 16.94,25.77 16.45,25.77 v1(16.25,25.98) 15.97,26.25 R67015.1
N35952409: length 3.2
  TOP w0.14: R22193.2 34.38,55.19 34.61,55.19 35.71,56.28 35.88,56.28 36.04,56.13 U3.8
N35952413: length 3.2
  TOP w0.14: U3.7 35.98,56.78 35.75,56.54 35.6,56.54 34.5,55.45 34.42,55.45 R22192.2
N36010424: length 5.3
  TOP w0.14: R21450.1 14.48,12.95 v1(14.22,12.69)
  TOP w0.254: R21450.1 15.08,12.52 15.26,12.35 R22159.1 15.53,12.04 15.7,11.87 16.13,11.87 16.61,12.34 R67207.1 16.82,12.34 16.82,11.36 R67205.2
N36010432: length 5
  TOP w0.14: R21447.1 14.62,14.31 v1(14.29,13.99)
  TOP w0.254: R67204.2 16.29,13.31 16.2,13.4 R21449.1 15.79,13.65 16.43,14.29 16.43,14.66 R67206.1 16.27,14.82 15.84,14.39 15.8,14.39 15.73,14.31 R21447.1
N36060148: length 2.5
  TOP w0.203: U13151.15 20.23,28.33 v1(20.37,28.46)
  BOTTOM w0.14: v1(20.37,28.46) 20.59,28.69 v1(20.59,29.15)
  BOTTOM w0.203: C95976.2 20.35,28.48 v1(20.37,28.46)
N36087926: length 1.3
  TOP w0.14: U13113.AF5 303.85,54.68 v2(303.7,54.83)
  BOTTOM w0.14: T71.1 303.93,55.06 v2(303.7,54.83)
N36087928: length 2.1
  TOP w0.14: U13113.AG7 303.98,55.39 v2(303.73,55.64)
  BOTTOM w0.14: v2(303.73,55.64) 304.34,56.25 T72.1
N36183553: length 1.8
  TOP w0.14: R67303.2 378.55,10.04 378.45,9.94 378.45,9.93 378.24,9.72 U13152.31
N36183599: length 2.6
  TOP w0.14: U13152.30 378.51,9.22 v1(378.69,9.04) 379,8.73 v1(379.32,8.73)
  BOTTOM w0.14: R67023.1 378.43,9.3 v1(378.69,9.04)
N36184365: length 29.1
  TOP w0.14: CN2071.6 187.85,46.12 187.07,45.33 180.94,45.33 178.25,48.02 176.27,48.02 175.64,48.66 175.64,53.53 174.76,54.41 174.41,54.41 173.22,55.59 v1(173.22,57.04) 172.87,57.4 D8565.1 173.47,58.22 173.67,58.41 R21049.2
N36184511: length 4.1
  BOTTOM w0.14: R22150.2 377.24,14.59 377.01,14.82 D13042.1 377.13,15.49 v1(377.79,15.49) 378.91,15.49 SW3.2
N36196173: length 4
  TOP w0.14: v1(177,56.4) U49.24 179.65,56.4 v1(179.75,56.51)
  BOTTOM w0.14: R67164.1 180.53,56.51 v1(179.75,56.51)
N36343328: length 2.1
  TOP w0.203: C94922.2 25.06,30.22 25.57,30.73 25.85,30.73 25.99,30.86 U13108.32
N36343332: length 2.9
  TOP w0.203: C94925.1 24.61,35 25.59,34.03 25.88,33.74 26.19,33.74 26.27,33.66 U13108.25
N36343342: length 4.8
  TOP w0.203: U13108.21 28.74,35.74 28.44,36.03 27.86,36.03 v1(27.6,35.78)
  BOTTOM w0.14: v1(28.06,36.82) 28.06,36.24 v1(27.6,35.78)
  BOTTOM w0.203: C94933.1 27.47,35.64 v1(27.6,35.78)
N36343351: length 2.5
  TOP w0.14: v1(29.71,35.53) 29.54,35.35 U13108.19
  BOTTOM w0.14: v1(29.03,35.78) 29.28,35.53 v1(29.71,35.53) 29.74,35.5 C94937.1
N36343359: length 3
  TOP w0.203: U13108.38 27.94,27.81 27.76,27.63 26.51,27.63 26.03,27.14 C94926.2
N36343360: length 5.6
  TOP w0.203: 26.42,26.76 26.19,26.53 C94930.2 ; 26.42,26.76 v1(26.44,26.76) ; 26.42,26.76 26.42,27.03 26.66,27.27 27.91,27.27 28.34,27.7 U13108.39
  BOTTOM w0.14: v1(26.44,26.76) v1(26.44,27.55)
  BOTTOM w0.203: C94930.2 26.19,26.52 v1(26.44,26.76)
N36392478:
  vias: v1(39.72,45.97)
N36639740: length 8.5
  BOTTOM w0.14: R20972.2 v1(251.48,170.43) 251.48,170.65 252.62,171.8 252.62,172.69 251.61,173.7 249.28,173.7 CN2043.14
N36754118: length 2.6
  TOP w0.14: U13092.1 357.42,43.92 v1(357.02,43.52)
  BOTTOM w0.14: 358.17,43.78 357.28,43.78 v1(357.02,43.52)
N36762992: length 2.4
  TOP w0.305: PU9011.5 131.65,94.51 v1(131.26,94.12) 130.83,93.69 PR9068.1
N36763078: length 2.8
  TOP w0.305: PC9027.2 130.83,92.27 v1(131.29,92.73) 131.29,93.21 131.59,93.51 PU9011.7
N36765623: length 2.2
  TOP w0.14: v1(322.74,76.23) R67148.2 323.42,75.4 323.62,75.21 U13080.3
N36766745: length 3.4
  TOP w0.14: PC9485.2 128.19,80.07 v1(128.19,79.32)
  TOP w0.305: PU9012.7 128.81,81.42 PC9485.2
N36769397: length 3.2
  TOP w0.14: PC9486.2 156.46,68.71 v1(156.46,69.08)
  TOP w0.305: PU9013.7 155.12,68.84 PC9486.2
N36770302: length 3.2
  TOP w0.14: PC9487.2 168.19,68.61 v1(168.19,69.08)
  TOP w0.305: PU9014.7 166.85,68.94 PC9487.2
N36980981: length 4.9
  TOP w0.14: v1(180.49,55.21) 180,54.73 179.34,54.73 179.27,54.8 U49.28 177.11,54.8 v1(176.96,54.65)
  BOTTOM w0.14: v1(180.49,55.21) 181.12,55.85 R67166.1
N37464977: length 89.6
  TOP w0.14: v1(134.36,64.81) 134.59,64.58 R67281.2 136.55,64.59 R21065.1 ; U49.70 193.3,55.2 193.09,55.41 193.09,55.56 192.94,55.71 190.91,55.71 190.65,55.97 190.65,56.86 190.95,57.17 190.95,57.77 190.66,58.06 188.33,58.06 187.48,58.92 187.48,59.28 188.41,60.22 188.41,63.58 188.23,63.76 188.23,65.12 188.46,65.35 v1(188.62,65.35)
  IN5 w0.089: v1(180.23,72.61) 179.95,72.9 175.39,72.9 169.77,67.28 168.17,67.28 166.64,65.75 166.64,64.86 165.8,64.02 165.3,64.02 164.02,65.29 162.86,65.29 162.15,64.58 156.39,64.58 155.13,65.83 153.89,65.83 152.22,64.17 150.08,64.17 149.24,65.01 134.56,65.01 v1(134.36,64.81)
  BOTTOM w0.14: v1(180.23,72.61) 179.58,71.96 179.58,69.52 179.96,69.14 179.96,67.32 181.47,65.81 182.16,65.81 182.52,65.45 182.52,64.71 183.32,63.91 C96218.1 187.06,63.91 188.49,65.35 v1(188.62,65.35)
N37522594: length 11.1
  TOP w0.254: PR9231.2 367.36,82.32 v1(367.44,82.41)
  BOTTOM w0.254: v1(367.44,82.41) 367.61,82.41 372.73,87.52 372.73,87.91 373.67,88.85 v1(373.67,90.11)
  vias: v1(370.07,89.35)
N37522596: length 12.3
  TOP w0.254: PR9234.2 366.02,88.07 PU8006.8
  BOTTOM w0.254: v1(361.12,90.95) 362.72,89.36 362.72,88.92 365.31,86.32 v1(369.81,86.32)
  vias: v1(359.73,91.61)
N37522685: length 1
  TOP w0.254: PR9233.1 PC8101.2
N37550876:
  vias: v1(354.6,90.34)
N37550890: length 3.3
  TOP w0.14: PQ9080.3 359.1,88.02 v1(359.1,88.59)
  TOP w0.508: PQ9080.3 359.98,87.31 360.46,87.79 PR67172.2
N37550892:
  vias: v1(354.25,87.6)
N37551635:
  vias: v1(357.09,92.8)
N37551639: length 6.7
  TOP w0.14: v1(357.53,90.62) 357.53,90.85 357.22,91.15 PQ17.1
  TOP w0.508: PQ17.1 356.69,91.76 356.26,92.18 PC8109.1 PR49.1 353.42,92.18 352.94,92.66 PR67176.2
N37551712: length 7
  TOP w0.508: PQ9082.3 349.5,93.82 v1(349.65,93.97) 350.36,94.68 353.53,94.68 354.29,93.92 PR51.2
N37551735: length 3.8
  TOP w0.254: 347.47,93.56 346.56,93.56 PR67223.2 PR67224.2 345.41,93.46 v1(345,93.87) 344.67,93.54 PR67225.2
N37571887: length 262.3
  TOP w0.14: v1(178.61,67.2) 178.94,66.87 178.94,66.64 179.56,66.01 180.75,66.01 181.18,65.59 181.18,64.96 182.27,63.87 182.27,63.15 183.72,61.7 183.72,59.08 183.03,58.4 183.03,55.86 183.43,55.46 183.43,55.08 182.97,54.62 181.87,54.62 181.66,54.83 181.66,55.74 181.4,56 U49.25 ; v1(361.46,41.52) 361.61,41.52 362.02,41.11 v1(362.02,40.89) 362.02,40.12 361.22,39.33 R67174.1
  IN3 w0.079: v1(178.61,67.2) 178.61,67.73 179.91,69.03 181.94,69.03 182.65,69.74 190.94,69.74 191.49,69.19 194.02,69.19 196.7,71.86 198.67,71.86 199.92,73.11 199.92,73.82 201.78,75.68 201.78,77.44 205.1,80.76 206.27,80.76 210.99,85.49 278.48,85.49 279.66,84.31 280.89,84.31 282.81,82.39 284.32,82.39 285.5,81.21 287.66,81.21 290.07,78.79 290.84,78.79 291.06,78.57 294.85,78.57 294.99,78.42 300.77,78.42 301.47,77.72 304.77,77.72 305.03,77.99 306.72,77.99 307.81,76.89 310.14,76.89 310.44,77.2 311.65,77.2 312.11,77.66 316.2,77.66 317.2,78.66 322.9,78.66 323.21,78.35 324.91,78.35 325.37,78.81 329.51,78.81 330.16,79.47 330.64,79.47 330.95,79.16 330.95,78.89 332.46,77.39 332.46,72.31 332.96,71.8 332.96,69.87 334.16,68.67 335.17,68.67 335.94,67.91 335.94,67.4 337.07,66.27 337.07,63.58 337.43,63.22 344.64,63.22 346.82,65.39 349.16,65.39 350.38,66.61 353.28,66.61 354.15,65.74 354.15,62.78 355.36,61.57 358.7,61.57 362.39,57.88 362.39,54.23 364.84,51.77 364.84,47.92 362.29,45.37 362.29,42.07 361.74,41.52 v1(361.46,41.52)
N37575832: length 2.3
  TOP w0.14: v1(368.47,28.49) 368.12,28.84 U13155.E10
  BOTTOM w0.14: v1(368.47,28.49) 368.47,28.89 T96.1
N37576451: length 5.1
  TOP w0.14: PQ9020.3 111.75,68.67 v1(112.06,68.37)
  TOP w0.203: PQ9020.3 112.42,69.36 112.73,69.05 PR9140.1 PR9132.2 113.59,68.05 113.81,68.27 PQ9021.2
N37576488: length 3.7
  TOP w0.14: PQ9020.2 109.72,69.56 v1(109.54,69.38)
  TOP w0.203: PR9141.1 PR9139.1 109.08,71.02 PQ9020.2
N37576489: length 5.8
  TOP w0.14: PR9142.2 118.84,69.91 v1(118.84,68.44)
  TOP w0.305: PR9142.2 PC9186.1 117.06,71.71 PR9145.2
N37576527: length 10.5
  TOP w0.14: PQ9031.2 103.7,79.8 v1(102.92,79.8)
  TOP w0.254: v1(104.03,78.32) 103.91,78.45 PQ9031.2 ; v1(108.66,77.56) 108.66,77.23 108.11,76.68 PQ9032.3
  BOTTOM w0.254: v1(108.66,77.56) 108.53,77.69 105.43,77.69 104.8,78.32 v1(104.03,78.32) 103.91,78.2 PR9210.1 PR9209.2
N37576543: length 2.6
  TOP w0.14: v1(116.5,70.53) 116.28,70.3 PQ9021.3
  TOP w0.203: PQ9021.3 114.68,70.3 114.62,70.36 114.61,70.36 114.2,70.77 PR9131.1
N37576561: length 2.4
  TOP w0.254: PR9208.2 104.36,76.75 v1(103.88,77.23) 103.55,77.56 PQ9031.3
N37576565:
  vias: v1(119.25,88.56)
N37576617:
  vias: v1(109.47,87.9)
N38117819: length 1.2
  TOP w0.14: v1(264.26,121.49) 263.93,121.81 U41.BN25
  BOTTOM w0.14: v1(264.26,121.49) 264.28,121.5 T9019.1
N38117832: length 1.5
  TOP w0.14: v1(263.61,123.85) 263.93,123.52 U41.BN27
  BOTTOM w0.14: v1(263.61,123.85) 263.61,123.86 T9020.1
N38117858: length 2.8
  TOP w0.14: v1(266.75,120.23) 266.47,120.23 266.04,120.67 265.6,120.67 U41.BR23
  BOTTOM w0.14: v1(266.75,120.23) 266.52,120.23 T9021.1
N38117859: length 8.6
  TOP w0.127: U41.BR22 265.35,119.52 265.81,119.06
  TOP w0.14: 265.81,119.06 266.07,119.06 266.9,118.23 267.2,118.23 271.5,113.94 T9022.1
N38117884: length 6.4
  TOP w0.14: U41.BT19 266.04,117.15 266.57,116.63 266.57,115.79 267.96,114.4 269.07,114.4 270.12,113.35 T9010.1
N38117885: length 6.4
  TOP w0.14: U41.BP19 264.98,116.76 266.05,116.76 266.26,116.54 266.26,115.38 267.81,113.83 T9009.1
N38117910: length 1.3
  TOP w0.14: U41.BN23 263.93,120.24 v1(264.26,119.91)
  BOTTOM w0.14: T9011.1 263.93,119.57 v1(264.26,119.91)
N38117911: length 1.2
  TOP w0.14: U41.BP23 264.91,120.63 v1(264.91,120.7)
  BOTTOM w0.14: v1(264.91,120.7) 264.94,120.67 T9012.1
N38117936: length 1.3
  TOP w0.14: v1(264.26,119.12) 263.93,119.45 U41.BN22
  BOTTOM w0.14: v1(264.26,119.12) 264.31,119.08 T9014.1
N38117937: length 3.5
  TOP w0.127: U41.BP22 264.59,119.52 264.97,119.9
  TOP w0.14: 264.97,119.9 266.01,119.9 266.26,119.65 266.26,119.52 v1(266.69,119.09)
  BOTTOM w0.14: T9013.1 266.59,118.99 v1(266.69,119.09)
N38117962: length 2.4
  TOP w0.14: U41.BR27 265.61,123.08 265.98,123.08 266.26,122.8 v1(266.54,122.8)
  BOTTOM w0.14: v1(266.54,122.8) 266.06,122.32 T9015.1
N38117963: length 1.6
  TOP w0.14: U41.BT27 v1(266.52,123.45)
  BOTTOM w0.14: T9016.1 266.41,123.56 v1(266.52,123.45)
N38117988: length 2.9
  TOP w0.14: v1(266.61,125.85) 266.57,125.82 U41.BT30
  BOTTOM w0.14: v1(266.61,125.85) 266.38,126.08 T9018.1
N38117989: length 3.3
  TOP w0.14: U41.BM31 263.28,126.53 v1(263.61,126.21)
  BOTTOM w0.14: T9017.1 261.64,124.93 262.92,126.21 v1(263.61,126.21)
N38649202: length 6.5
  BOTTOM w0.254: PR139.1 PR138.1 132.56,68.57 132.14,68.99 PC182.2 131.44,68.99 130.9,69.53 129.43,69.53 v1(129.4,69.5) 128.87,69.5 128.55,69.19 PU12.12
N38649204: length 7.4
  BOTTOM w0.14: v1(132.93,71.36) PR146.1
  BOTTOM w0.254: PU12.11 127.9,69.38 128.58,70.05 131.02,70.05 131.3,69.77 PC182.1 132.2,69.77 PR146.1
N38649215: length 3.4
  BOTTOM w0.203: PR67217.1 PR67199.1 125.83,63.03 PC184.1 126.61,63.34 126.6,63.35 PU12.4
N38649229: length 14.1
  TOP w0.14: v1(124.35,63.28) 124.68,62.95 125.16,62.95 125.7,63.49 v1(125.7,64.74)
  IN1 w0.089: v1(121.94,68.16) 123.85,68.16 125.7,66.31 v1(125.7,64.74)
  BOTTOM w0.14: PU12.5 125.98,65.54 126.2,65.32 126.2,65.23 v1(125.7,64.74) ; PR67217.2 124.35,62.57 v1(124.35,63.28) ; PR161.1 PR706.1 122.19,67.91 v1(121.94,68.16)
N38649281: length 4.5
  BOTTOM w0.14: PC174.2 131.57,67.23 v1(131.57,67.98)
  BOTTOM w0.254: PR119.1 132.67,67.53 132.27,67.13 PC174.2 130.81,67.13 130.52,66.84 PU12.14
N38649283: length 6
  BOTTOM w0.14: v1(131.57,65.07) 131.67,65.17 PC174.1
  BOTTOM w0.254: PU12.15 130.74,66.19 130.91,66.35 PC174.1 131.92,66.35 132.68,65.6 PR124.1 PR67194.1
N38649292: length 2.9
  BOTTOM w0.203: T9008.1 127.25,71.45 PU12.10
N38655762: length 3.9
  BOTTOM w0.203: PR705.2 114.83,67.48 v1(114.88,67.53) 115,67.65 PR67201.1 PR417.2 PR416.2
N38655784: length 5
  BOTTOM w0.203: PD101.2 PD102.2 119.35,67.23 119.39,67.19 119.39,66.48 v1(118.79,65.88) 118.55,65.64 PQ147.1
N38655792: length 2.5
  BOTTOM w0.203: PR705.1 114.88,65.74 115.57,66.44 v1(115.69,66.44) 115.87,66.26 115.87,65.8 116.03,65.64 PQ147.2
N38784914: length 2.5
  TOP w0.14: v1(269.82,107.94) 269.82,107.94 270.69,107.94 R21411.2
  TOP w0.254: R21411.2 271.18,107.96 Q7844.2
N38791003: length 3.1
  TOP w0.14: U13113.AR17 308.4,60.88 v2(308.01,61.27)
  BOTTOM w0.14: v2(308.01,61.27) 308.01,61.57 308.48,62.04 308.48,62.55 308.86,62.93 TP13144.1
N39029594: length 4.5
  TOP w0.14: v1(213.3,137.2) 212.34,137.2 211.75,136.62 R191.1 R184.1 211.72,138.52 211.98,138.79 Q20.1
N39029637: length 2.6
  TOP w0.14: v1(211.88,134.23) 212.11,134.46 Q23.2 212.11,135.88 212.5,136.27 R191.2
N39882995: length 5.5
  TOP w0.102: 301.54,74.92 301.54,74.75 301.69,74.6 301.69,73.3 U13113.AB42
  TOP w0.14: T9024.1 299.52,77.44 301.26,75.7 301.26,75.2 301.54,74.92
N39883008: length 3.1
  TOP w0.102: 301.89,75.01 301.89,73.76 302.02,73.62 U13113.AB43
  TOP w0.14: v1(301.68,75.51) 301.68,75.21 301.89,75.01
  BOTTOM w0.14: T9025.1 301.7,76.37 301.7,75.52 v1(301.68,75.51)
N39885867: length 1.4
  TOP w0.14: v2(304.74,69.21) 304.53,69.21 U13113.AG35
  BOTTOM w0.14: v2(304.74,69.21) 304.21,68.67 TP13146.1
N39885880: length 1.3
  TOP w0.14: U13113.AG39 304.44,71.9 v1(304.82,71.9)
  BOTTOM w0.14: TP13147.1 304.82,71.29 v1(304.82,71.9)
N40227168: length 6.5
  BOTTOM w0.14: Q7843.3 310.16,78.44 310.09,78.36 R67271.2 310.09,77.43 309.79,77.13 309.24,77.13 309.06,76.95 309.06,76.09 309.25,75.9 R67255.1 309.52,75.53 309.82,75.23 309.82,74.04 R67272.2
N40589826: length 3.9
  TOP w0.14: U13155.F11 368.62,29.66 368.57,29.72 368.57,30.48 368.32,30.73 368.32,31.13 367.61,31.83 v1(367.61,32.02)
  BOTTOM w0.14: R67141.1 367.3,32.33 v1(367.61,32.02)
N40838180: length 2.6
  TOP w0.14: R67267.2 v1(30.96,74.35)
  TOP w0.508: R67267.2 32.16,73.96 32.16,73.71 32.68,73.19 R67268.1
N40838182: length 2.6
  TOP w0.14: Q7935.3 32.53,77.05 v1(32.28,77.31)
  TOP w0.508: Q7935.3 31.77,75.56 R67267.1
N40966338: length 5.3
  TOP w0.14: R67290.2 39.31,30.55 39.31,29.71 39.03,29.43 Q7937.3 38.5,28.92 37.84,28.26 Q7938.2 37.58,28.26 v1(36.48,27.16)
N42411396: length 1.7
  BOTTOM w0.14: Q7944.1 129.3,111.9 v1(129.48,112.08) 130.08,112.08 R67327.2
N42687628: length 7.3
  TOP w0.254: v1(15.31,28.21) 15.43,28.33 U13151.6
  BOTTOM w0.254: R67337.2 15.28,23.11 R67336.2 15.28,24.84 14.74,25.38 14.74,27.13 15.31,27.7 v1(15.31,28.21)
N42752592: length 7.4
  TOP w0.14: v2(156.91,119.46) U13114.BD21
  BOTTOM w0.14: v2(156.91,119.46) 156.91,115.28 156.48,114.85 TP13101.1
N42926777: length 2.9
  BOTTOM w0.14: v1(20.21,14.42) 19.78,14.42 19.52,14.16 C96224.1
  BOTTOM w0.203: U13156.4 20.09,12.51 19.99,12.61 19.99,12.76 19.52,13.23 C96224.1
N45101115: length 3
  TOP w0.14: U13157.28 33.72,37.03 33.84,36.91 v1(33.84,36.2) 33.93,36.11 C96225.2
N45105751: length 4.4
  TOP w0.14: C96226.2 38.6,45.26 v1(38.6,46.65)
  TOP w0.203: C96226.2 37.64,44.7 37.52,44.58 36.66,44.58 36.52,44.44 U13157.2
N45109965: length 7.6
  TOP w0.14: U13157.19 31.08,40.58 30.96,40.7 26.82,40.7 26.57,40.45 26.57,39.92 26.82,39.67 26.82,38.55 26.66,38.4 C96232.2
N45110044: length 7.1
  TOP w0.14: C96234.1 26.34,39.56 26.25,39.65 C96233.2 26.44,40.73 26.94,41.24 v1(26.99,41.24) 27.25,40.98 U13157.18
N45335220: length 6.2
  TOP w0.14: TP13151.1 71.67,29.4 71.92,29.65 CN11.8
N45685102: length 4.4
  BOTTOM w0.14: SW3.3 379,17.32 378.68,17.01 v1(378.25,17.01) 377.76,17.5 377.08,17.5 R67369.1 376.76,17.51 376.51,17.76 R67370.1
N45750134: length 9.1
  TOP w0.14: PQ9086.2 66.06,48.48 65.5,47.92 64.3,47.92 64.05,48.16 64.05,48.95 63.28,49.72 63.28,50.3 PR67234.1 64.24,51.25 64.98,51.25 65.45,51.72 PQ9087.3
N45750138: length 6.8
  TOP w0.14: v1(64.92,45.79) 64.92,46.3 PQ9086.3 65.78,46.78 65.93,46.63 66.42,46.63 66.75,46.96 66.75,49.29 66.18,49.86 65.64,49.86 PR67236.1
N46189580: length 7.6
  TOP w0.14: v1(28.16,19.32) 27.33,19.32 25.63,17.63 U13161.3
  BOTTOM w0.14: v1(28.16,19.32) 28.19,19.35 28.19,21.07 27.76,21.51 v1(27.3,21.51) 27.3,21.5 R67388.2
N46382419: length 1.3
  BOTTOM w0.14: U13159.12 375.76,11.6 375.64,11.72 C96250.2
N46382439: length 1.3
  BOTTOM w0.14: U13159.10 374.96,11.47 374.65,11.77 C96251.2
N46383446:
  vias: v1(377.34,11.14)
N46384360:
  vias: v1(371.72,11.45)
N46385421: length 50.5
  IN3 w0.079: v1(369.49,38.78) 368.68,37.97 368.68,32.47 369.03,32.13 369.03,31.01 371.05,28.99 371.05,25.46 372.13,24.38 372.13,23.41 372.42,23.12 372.42,22.03 374.04,20.41 374.63,20.41 375.43,19.61 375.43,18.59 375.58,18.43 378.58,18.43 378.91,18.1 378.91,13.48 379.39,13 379.39,10.94 379.55,10.78 379.55,9.7 379.32,9.46 379.32,8.93 380.37,7.88 380.37,6.41 379.39,5.44 379.39,5.17 378.99,4.77 377.62,4.77 v1(377.21,5.17)
  BOTTOM w0.14: U13159.4 375.36,7.92 376.56,6.71 376.95,6.71 376.95,6.72 376.96,6.72 377.51,6.16 377.51,5.58 377.21,5.27 v1(377.21,5.17) ; v1(369.49,38.78) 369.18,38.47 C96260.1 368.57,38.47 368.43,38.33 R67393.1
N46521490: length 9.5
  TOP w0.14: PQ9089.2 63.27,61.26 PR67239.1 63.43,61.95 63.71,61.67 63.71,59.41 64.23,58.89 64.65,58.89 65.42,58.13 65.42,56.55 65.64,56.32 PQ9088.3
N46528749: length 6
  TOP w0.14: PQ9089.3 64.55,59.39 65.7,58.24 65.7,57.81 65.71,57.79 65.71,56.97 66.12,56.57 67.57,56.57 PR67219.1
N46825791: length 1.9
  BOTTOM w0.14: U13158.12 126.81,59.33 C96269.2
N46825793: length 2.6
  BOTTOM w0.14: U13158.10 125.58,60.13 126.04,59.68 126.42,59.68 127.01,60.26 C96270.2
N46825849: length 2.9
  BOTTOM w0.14: 122.55,60.93 122.42,60.81 122.42,60.64 122.53,60.53 U13158.6 ; 122.55,60.93 122.43,61.05 122.43,62.02 T9036.1 ; 122.55,60.93 U13158.7
N46825877: length 1.5
  BOTTOM w0.14: U13158.5 122.53,60.13 121.97,60.7 T9034.1
N46825967: length 2.2
  BOTTOM w0.14: U13158.8 126.18,60.93 T9035.1 125.79,60.53 U13158.9
N46826030: length 2.6
  BOTTOM w0.14: R67401.1 121.66,60.49 C96279.1 121.96,59.73 U13158.4
N46971490: length 2
  BOTTOM w0.14: R67407.2 361.76,40.2 R67403.2 360.5,40.2 360.02,40.67 Q7949.3
N46971526: length 2.1
  BOTTOM w0.14: R67404.2 358.11,39.97 358.82,39.97 359.02,39.77 Q7949.6 359.02,38.77 R67408.2
N323001010: length 2.9
  TOP w0.14: CN2062.162 235.94,67.56 v1(235.17,68.32)
  BOTTOM w0.14: T63.1 235.02,68.16 v1(235.17,68.32)
N323001110: length 2.6
  TOP w0.14: CN2062.165 235.18,76.05 v1(235.22,76.09)
  BOTTOM w0.14: T64.1 235,75.86 v1(235.22,76.09)
N402557870: length 1.4
  TOP w0.14: U13155.F4 368.62,25.74 v1(368.35,25.47)
  BOTTOM w0.14: v1(368.35,25.47) 368.12,25.23 T92.1
N4025593943: length 2
  TOP w0.14: U13155.G4 369.12,25.56 v1(369.01,25.44)
  BOTTOM w0.14: T93.1 369.01,25.7 v1(369.01,25.44)

## Copper pours and planes (outline as drawn)
1V8_AON_S on TOP (solid shape): 103.75,69.68 103.78,69.66 103.8,69.62 103.8,68.8 104,68.8 104,69.48 104.06,69.57 104.17,69.55 104.19,69.54 104.19,68.22 103.86,67.89 103.86,67.33 103.63,67.1 103.07,67.1 102.81,66.84 101.37,66.84 101.21,67 101.21,69.16 101.37,69.31 103.02,69.31 103.38,69.68
1V8_MAIN_EN_G on TOP (solid shape): 110.48,61.33 110.48,60.8 108.9,59.21 107.5,59.21 106.75,59.96 106.24,59.96 106.09,60.11 106.09,61.18 106.19,61.28 109.39,61.28 109.57,61.46 110.36,61.46
1V8_MAIN_S on TOP (solid shape): 105.75,69.66 105.78,69.65 105.8,69.61 105.8,68.8 106,68.8 106,69.61 106.01,69.65 106.05,69.66 106.4,69.66 106.73,69.33 106.86,69.33 106.9,69.29 108.19,69.29 108.53,68.95 108.53,66.58 108.45,66.5 107.27,66.5 106.68,67.1 106.24,67.1 106.07,67.28 106.07,67.76 105.61,68.22 105.61,69.56 105.71,69.66
3V_LDO on BOTTOM (solid shape): 70.61,64.3 70.61,63.16 70.45,63 69.03,63 68.87,63.16 68.87,64.45 68.97,64.54 68.98,64.55 69,64.56 70.35,64.56
51211V_DRVL on TOP (solid shape): 239.26,162.4 239.26,161.64 238.27,161.64 238.2,161.71 238.2,162.63 238.37,162.81 238.86,162.81
51211V_SW on TOP (solid shape): 224.94,164.63 224.94,164.13 225.7,163.36 225.7,162.58 227.02,161.26 232.51,161.26 232.51,158.54 232.4,158.44 224.86,158.44 220.67,162.63 220.67,163.14 221.1,163.57 222.45,163.57 223.69,164.81 224.76,164.81
51211V_VBST on TOP (solid shape): 237.13,160.11 237.13,159.68 237.38,159.43 238.07,159.43 238.27,159.63 238.27,159.91 239.26,159.91 239.26,159.38 238.75,158.87 236.72,158.87 236.29,159.3 236.29,159.97 236.29,159.97 236.29,160.11 236.41,160.23 237.01,160.23
+1.2VSUS on TOP (solid shape): 168.42,66.01 168.52,65.99 168.63,66.01 169.11,66.01 169.13,65.99 170.9,65.99 171.49,65.4 171.52,65.3 171.44,65.23 171.2,65.1 171.1,64.85 171.07,64.78 171,64.75 170.71,64.61 170.62,64.3 170.59,64.22 170.51,64.19 170.14,64 170.15,63.58 170.15,62.81 169.79,62.45 167.08,62.45 166.87,62.65 166.87,65.75 167.13,66.01
+1.2VSUS on TOP (solid shape): outline of 138 points within 200.73,76.04 249.7,92.78
+1.2VSUS on TOP (solid shape): outline of 265 points within 234.58,62.82 251.29,65.47
+1.2VSUS on BOTTOM (solid shape): 240.61,55.41 240.61,54.07 239.51,52.98 237.1,52.98 237.05,53.03 237.05,54.67 237.18,54.8 238.85,54.8 238.86,54.81 238.92,54.81 239.8,55.68 240.34,55.68
+1.2VSUS on BOTTOM (solid shape): outline of 797 points within 232.23,56 239.96,65
+1.2VSUS on BOTTOM (solid shape): outline of 29529 points within 200.51,53.18 278.92,112.82
+1.2VSUS on IN2 (solid shape): outline of 3555 points within 231.41,54.77 280.69,68.67
+1.2VSUS on SVCC (solid shape): 207.03,88.91 207.03,82.85 199.71,75.54 199.64,75.48 199.58,75.4 192.96,68.79 192.74,68.69 192.64,68.46 189.74,65.57 189.39,65.49 189.31,65.13 187.64,63.47 183.05,63.47 182.73,63.68 182.41,63.47 167.74,63.47 166.77,64.44 166.77,69.22 169.14,71.59 177.6,71.59 177.83,71.5 178.06,71.59 178.79,71.59 179.06,71.46 179.33,71.59 185.82,71.59 186.01,71.63 186.18,71.74 198.25,83.81 198.36,83.97 198.39,84.17 198.39,87.26 201.02,89.88 206.06,89.88
+1.2VSUS on IN5 (solid shape): outline of 10935 points within 229.5,99.89 266.34,113.02
+1.2VSUS on IN5 (solid shape): outline of 21341 points within 210.79,54.82 277.49,79.19
+1.8V on TOP (solid shape): 30.06,41.68 30.06,41.42 29.96,41.32 28.01,41.32 27.93,41.39 27.93,42.08 28.01,42.16 29.25,42.16 29.25,42.16 29.57,42.16
+1.8V on TOP (solid shape): 119.65,67.53 119.65,65.97 119.44,65.76 119.44,65.42 119.43,65.39 119.39,65.37 118.13,65.37 117.75,65.75 117.75,67.53 117.88,67.66 119.53,67.66
+1.8V on BOTTOM (solid shape): 30.02,41.77 30.02,41.49 29.84,41.32 28.01,41.32 27.93,41.39 27.93,42.08 28.01,42.16 29.64,42.16
+1.8V on IN1 (solid shape): 119.78,67.66 119.78,64.74 119.02,63.97 112.03,63.97 111.91,64.1 111.91,65.24 112.03,65.37 114.64,65.37 114.72,65.32 114.73,65.22 115.03,64.72 115.34,65.22 115.34,65.32 115.43,65.37 117.37,65.37 117.75,65.75 117.75,67.53 118.38,68.16 119.27,68.16
+1.8V_AON on TOP (solid shape): 103.4,66.01 103.4,64.74 103.02,64.35 101.37,64.35 101.24,64.48 101.24,66.13 101.37,66.26 103.14,66.26
+1.8V_AON on TOP (solid shape): 149.88,121.1 152.29,121.1 152.55,120.84 152.55,119.7 152.42,119.57 152.29,119.57 151.78,120.08 149.24,120.08 148.99,120.33 148.99,120.92 149.42,121.35 149.63,121.35
+1.8V_AON on BOTTOM (solid shape): 103.4,67.02 103.4,64.99 102.89,64.48 101.11,64.48 100.73,64.86 100.73,67.15 100.99,67.4 103.02,67.4
+1.8V_AON on BOTTOM (solid shape): 150.64,122.77 150.64,121.25 150.77,121.12 150.77,120.74 150.62,120.59 149.09,120.59 148.97,120.72 148.97,122.39 149.14,122.57 150.13,122.57 150.36,122.8 150.62,122.8
+1.8V_AON on IN2 (solid shape): outline of 650 points within 149.8,102.2 160.42,108.17
+1.8V_AON on IN3 (solid shape): outline of 9410 points within 101.11,64.48 152.55,121.25
+1.8V_MAIN on TOP (solid shape): 142.77,127.22 142.77,124.55 142.26,124.04 140.1,124.04 139.85,124.3 139.85,127.22 140.1,127.47 142.51,127.47
+1.8V_MAIN on TOP (solid shape): 108.63,65.5 108.63,63.75 108.33,63.45 108.33,63.44 108.27,63.39 107.34,63.39 106.28,64.44 106.03,64.44 106.02,64.45 105.65,64.45 105.21,64.88 105.21,65.41 105.81,66.01 108.12,66.01
+1.8V_MAIN on TOP (solid shape): 165.28,120.79 165.28,119.55 164.93,119.55 164.92,119.58 164.8,119.73 164.62,119.79 164.6,119.79 164.5,119.89 164.5,119.9 164.43,120 164.32,120.06 164.26,120.1 164.24,120.16 164.15,120.39 163.84,120.52 163.81,120.59 163.81,120.84 163.91,120.96 163.96,121.1 164.97,121.1
+1.8V_MAIN on TOP (solid shape): 163.1,121.1 163.16,120.92 163.3,120.8 163.3,120.51 163.36,120.35 163.56,120.23 163.58,120.16 163.61,120.01 163.72,119.89 163.76,119.81 163.72,119.73 163.58,119.43 163.77,119.16 163.75,119.06 163.73,119.06 163.6,118.93 163.47,118.93 162.81,119.59 162.81,119.6 162.74,119.69 162.65,119.76 162.64,119.76 162.33,120.08 162.07,120.08 162.01,120.02 161.98,119.99 161.94,119.94 161.92,119.73 162.07,119.57 162.07,119.45 161.69,119.07 161.68,119.07 161.6,119.02 161.53,118.94 161.3,118.94 160.74,119.5 160.74,119.52 160.63,119.71 160.42,119.79 160.4,119.79 160.3,119.9 160.3,119.91 160.25,119.98 160.18,120.04 160.18,120.93 160.35,121.1
+1.8V_MAIN on BOTTOM (solid shape): 152.74,105.87 153.67,105.87 153.7,105.86 153.72,105.83 154.1,105.54 154.48,105.84 154.48,105.86 154.51,105.88 154.55,105.88 154.81,105.63 154.81,104.13 154.4,103.72 152.75,103.72 152.6,103.87 152.6,103.91 152.62,103.94 152.64,104.34 152.29,104.55 152.25,104.55 152.21,104.6 152.2,104.61 152.19,104.63 152.19,104.67 152.22,104.74 152.3,104.77 152.71,105.09 152.44,105.54 152.37,105.61 152.4,105.71 152.57,105.88 152.73,105.88
+1.8V_MAIN on BOTTOM (solid shape): outline of 86 points within 160.1,118.96 165.02,125.8
+1.8V_MAIN on BOTTOM (solid shape): outline of 628 points within 136.85,122.72 152.13,128.26
+1.8V_MAIN on IN2 (solid shape): outline of 3753 points within 105.05,63.72 142.39,126.71
+1.8V_MAIN on IN3 (solid shape): outline of 2129 points within 148.36,96.63 164.74,127.83
+1.8V_S5 on TOP (solid shape): 117.5,66.77 117.5,64.61 117.24,64.35 116.1,64.35 116.06,64.39 116.06,65.41 115.59,65.88 115.59,66.64 115.84,66.89 117.37,66.89
+1.8V_S5 on TOP (solid shape): 103.14,76.55 103.14,74.82 102.85,74.52 102.85,74.16 101.33,74.16 101.33,74.15 100.97,73.8 100.63,73.8 100.43,74 100.43,74.01 99.8,74.64 96.92,74.64 96.67,74.9 96.67,75.76 96.98,76.08 100.85,76.08 100.85,76.42 100.99,76.42 101.34,76.78 102.92,76.78
+1.8V_S5 on TOP (solid shape): 109.01,75.58 109.02,75.58 109.06,75.53 109.21,75.53 109.42,75.33 109.42,74.31 109.24,74.14 109.2,74.13 106.4,74.13 106.27,74.26 106.27,75.25 106.29,75.28 106.3,75.28 106.52,75.44 106.58,75.7 106.61,75.78 106.69,75.81 108.78,75.81
+1.8V_S5 on IN1 (solid shape): outline of 328 points within 106.9,65.52 117.52,76.01
+1.8V_S5 on IN2 (solid shape): outline of 245 points within 99.79,73.96 109.57,77.33
+1V_GFX on TOP (solid shape): 161.06,66.63 161.16,66.64 161.78,66.64 161.8,66.64 161.82,66.62 162.02,66.51 162.25,66.53 162.45,66.53 163.22,65.77 163.22,64.74 162.83,64.35 155.47,64.35 155.34,64.48 155.34,65.88 155.6,66.13 156.02,66.13 156.1,66.1 156.12,66.01 156.71,65.59 156.62,66.31 156.55,66.38 156.57,66.48 156.72,66.63 156.79,66.63 156.84,66.64 160.96,66.64
+1V_GFX on TOP (solid shape): 167.7,121.1 167.78,121.06 167.8,120.97 167.79,120.76 167.92,120.59 167.96,120.51 167.78,120.16 167.96,119.81 167.78,119.46 167.96,119.11 167.92,119.03 167.88,119 167.84,118.95 167.8,118.93 167.58,118.93 167.29,119.22 167.24,119.29 167.17,119.34 167.05,119.46 167.05,119.48 166.95,119.7 166.73,119.8 166.72,119.8 166.68,119.81 166.6,119.9 166.6,119.9 166.18,119.99 166.27,119.58 166.28,119.57 166.28,119.34 166.03,119.09 166.01,119.09 165.86,119.05 165.74,118.95 165.73,118.94 165.7,118.92 165.62,118.92 165.49,119.05 165.49,120.99 165.6,121.1
+1V_GFX on TOP (solid shape): outline of 176 points within 152.8,119.19 158.9,121.1
+1V_GFX on BOTTOM (solid shape): outline of 170 points within 152.83,119.24 158.67,122.37
+1V_GFX on BOTTOM (solid shape): outline of 757 points within 165.17,107.57 190.14,122.29
+1V_GFX on IN2 (solid shape): 163.85,104.49 164.08,104.4 164.31,104.49 164.96,104.49 165.04,104.45 165.06,104.37 165.08,104.19 165.19,104.05 165.23,103.97 165.19,103.89 165.36,103.25 165.58,103.87 165.54,103.96 165.59,104.04 165.71,104.18 165.74,104.37 165.76,104.45 165.84,104.49 166.96,104.49 167.03,104.46 167.06,104.39 167.37,104.07 167.74,104.32 167.81,104.39 167.91,104.37 168.68,103.6 168.68,101.31 168.17,100.8 154.58,100.8 153.94,101.44 153.94,101.95 154.11,102.11 155,102.11 155.21,102.33 161.44,102.33 163.6,104.49
+1V_GFX on IN2 (solid shape): outline of 1892 points within 153.08,115.64 167.25,121.92
+1V_GFX on IN3 (solid shape): outline of 977 points within 153,101.24 159.53,121.48
+1V_GFX on IN3 (solid shape): outline of 2050 points within 147.21,64.51 168.42,121.22
+1V_GFX_S on TOP (solid shape): outline of 250 points within 149.88,60.9 160.88,66.02
+1V_S5 on TOP (solid shape): 219.58,151.45 219.58,143.91 219.43,143.76 214.4,143.76 214.09,144.06 214.09,150 215.69,151.6 219.43,151.6
+1V_S5 on TOP (solid shape): outline of 934 points within 210,76.09 294.15,95.57
+1V_S5 on BOTTOM (solid shape): outline of 5928 points within 285.16,52.94 307.44,82.2
+1V_S5 on IN2 (solid shape): outline of 3691 points within 203.07,93.06 226.72,150.92
+1V_S5_SRC on TOP (solid shape): 226.68,157.15 226.68,155.41 225.84,154.58 222.19,154.58 221.36,153.74 221.36,152.85 221.18,152.67 220.24,152.67 219.7,152.14 215.69,152.14 215.49,152.34 215.49,152.83 214.3,154.01 213.91,154.01 213.69,154.23 213.69,154.61 214.1,155.01 214.87,155.01 215.49,155.63 215.49,156.56 215.89,156.96 216.86,156.96 216.86,156.96 216.96,156.96 217.49,157.5 226.33,157.5
+1V_S5_VIN on TOP (solid shape): 234.67,158.26 234.67,157.24 235.1,156.81 235.91,156.81 236.04,156.68 236.04,155.17 235.98,155.02 235.99,154.86 235.99,154.68 235.57,154.26 231.81,154.26 231.63,154.44 231.6,154.44 230.08,155.96 229.14,155.96 228.9,156.2 228.9,156.68 228.57,157.01 227.93,157.01 227.45,157.5 227.41,157.5 227.41,157.94 227.58,158.11 232.63,158.11 232.99,158.46 234.46,158.46
+2.5VSUS on TOP (solid shape): outline of 503 points within 196.87,60.75 212.31,75.71
+2.5VSUS on BOTTOM (solid shape): 211.19,62.11 213.64,62.11 213.81,61.94 213.81,61.03 213.64,60.85 209.84,60.85 209.67,61.02 209.67,62.09 209.7,62.12 211.18,62.12
+3V on TOP (solid shape): 48.53,30.03 48.53,28.2 48.01,27.68 47.57,27.68 47.57,27.88 46.01,27.88 46.01,30.22 46.04,30.25 48.32,30.25
+3V on TOP (solid shape): 40.03,31.84 40.03,31.36 39.75,31.08 38.76,31.08 38.37,30.7 37.49,30.7 37.23,30.95 37.23,31.84 38.5,31.84 38.63,31.97 39.9,31.97
+3V on TOP (solid shape): 326.66,72.86 326.96,72.86 326.99,72.86 327.02,72.86 327.31,72.86 327.55,72.61 327.55,71.95 327.22,71.62 327.02,71.62 326.92,71.72 326.54,71.72 326.41,71.59 325.9,71.59 325.65,71.85 325.65,73.12 325.78,73.24 326.28,73.24
+3V on TOP (solid shape): 252.88,164.94 252.88,162.76 252.87,162.7 252.86,162.64 252.62,162.4 251.86,162.4 251.73,162.53 251.73,163.77 251.75,163.81 251.78,163.82 251.79,163.82 252.05,164.08 252.15,164.23 252.19,164.4 252.19,164.68 252.17,164.8 252.12,164.91 252.12,165.01 252.21,165.07 252.75,165.07
+3V on TOP (solid shape): 47.71,54.7 47.87,54.66 48.03,54.7 48.04,54.7 48.56,54.7 48.66,54.69 48.76,54.7 48.79,54.7 48.92,54.58 48.92,53.4 48.91,53.38 48.87,53.31 48.85,53.25 48.85,53.24 48.67,53.07 47.97,53.07 47.95,53.05 47.77,53.05 47.65,52.92 47.44,52.92 47.28,53.08 47.28,53.1 47.28,53.17 47.26,53.25 47.26,54.58 47.31,54.63 47.4,54.66 47.46,54.7 47.7,54.7
+3V on TOP (solid shape): 58.97,27.91 59.06,27.91 59.07,27.9 59.19,27.89 59.31,27.9 59.32,27.91 59.48,27.91 59.66,27.73 59.66,25.8 59.56,25.7 59.48,25.7 59.46,25.71 59.23,25.79 58.99,25.71 58.98,25.7 58.92,25.7 58.77,25.54 58.77,25.26 58.64,25.14 58.6,25.14 58.55,25.19 58.35,25.19 58.25,25.18 58.15,25.14 58.14,25.14 58.08,25.14 58,25.17 57.98,25.25 58,26.34 57.78,27.41 57.78,27.42 57.78,27.52 57.81,27.55 57.81,28.29 57.93,28.41 58.47,28.41
+3V on TOP (solid shape): 39.54,64.84 41.7,64.84 42.49,64.05 46.4,64.05 47.37,63.08 47.37,60.98 46.65,60.98 46.48,61.15 46.48,61.89 46.02,62.35 45.14,62.35 45.07,62.38 45.04,62.46 44.77,62.85 44.32,62.69 44.24,62.65 44.16,62.68 43.7,62.78 43.47,62.37 43.47,62.34 42.67,61.54 38.93,61.54 38.5,61.97 38.5,62.98 37.76,63.72 37.76,64.96 37.87,65.07 39.31,65.07
+3V on BOTTOM (solid shape): 67.1,47.76 67.1,46.57 67.03,46.5 66.03,46.5 65.91,46.63 65.91,47.98 66.89,47.98
+3V on BOTTOM (solid shape): 51.38,50.86 51.38,50.33 51.3,50.26 49.65,50.26 49.49,50.42 49.49,50.9 49.59,51 51.24,51
+3V on BOTTOM (solid shape): 52.39,32.22 52.39,31.28 52.27,31.16 51.1,31.16 51,31.26 51,32.3 51.02,32.33 52.29,32.33
+3V on BOTTOM (solid shape): 332.06,69.64 332.06,68.62 332.02,68.58 329.85,68.58 329.71,68.71 329.71,69.69 329.98,69.95 331.75,69.95
+3V on BOTTOM (solid shape): 355.13,91.53 355.13,90.83 355.07,90.77 353.47,90.77 353.44,90.8 353.44,91.57 353.47,91.6 355.06,91.6
+3V on BOTTOM (solid shape): 361.3,63.72 361.3,63.06 360.7,62.46 360.7,62.07 360.45,61.81 359.56,61.81 359.44,61.93 359.44,63.78 359.44,63.84 359.45,63.86 359.57,63.97 361.04,63.97
+3V on BOTTOM (solid shape): 56.87,39.73 56.87,38.62 56.81,38.57 55.67,38.57 55.36,38.88 55.36,39.16 55.52,39.37 55.5,39.63 55.49,39.66 55.71,39.88 56.71,39.88
+3V on BOTTOM (solid shape): 27.96,20.91 27.96,19.67 27.77,19.29 27.94,19 27.95,18.98 27.96,18.96 27.96,18.63 27.31,17.98 27.06,17.98 27.05,17.99 24.9,17.99 24.53,18.36 24.53,19.52 24.66,19.65 26.99,19.65 27.65,20.3 27.65,20.93 27.69,20.98 27.9,20.98
+3V on BOTTOM (solid shape): 59.1,27.83 59.74,27.83 60.01,27.55 60.01,26.05 59.86,25.9 59.13,25.9 58.8,25.57 58.8,25.32 58.59,25.11 58.47,25.11 58.46,25.11 58.35,25.13 58.23,25.11 58.23,25.11 58.03,25.11 57.98,25.16 57.97,25.18 57.98,25.3 57.99,25.39 58.01,26.16 57.91,26.93 57.91,26.94 57.91,28.39 58.03,28.52 58.41,28.52
+3V on BOTTOM (solid shape): 32.96,31.61 32.96,31.13 33.24,30.85 34.01,30.85 34.04,30.81 34.63,30.81 34.66,30.81 34.68,30.79 34.9,30.6 35.2,30.63 35.21,30.63 35.24,30.63 36.01,29.86 36.75,29.86 36.98,29.63 36.98,28.57 36.85,28.44 34.95,28.44 34.34,29.05 34.34,29.48 34.06,29.76 32.01,29.76 31.98,29.77 31.97,29.78 31.6,29.95 31.28,29.71 31.27,29.7 31.19,29.61 30.42,29.61 30.27,29.76 30.27,30.67 30.45,30.85 31.82,30.85 32.07,31.11 32.07,31.61 32.18,31.72 32.86,31.72
+3V on BOTTOM (solid shape): 199.18,73.32 200.81,73.32 201.38,72.75 204.12,72.75 205.38,74.01 208.63,74.01 208.7,73.94 208.7,73.37 208.87,73.19 208.87,72.23 209.32,71.79 209.32,70.48 209.7,70.09 209.76,70.03 209.82,69.97 210.05,69.74 210.05,68.8 210.61,68.24 210.61,67.78 210.56,67.73 209.44,67.73 209.14,68.04 209.14,69.28 209,69.42 209,69.5 207.69,70.8 207.69,71.49 206.7,72.48 206.12,72.48 204.95,71.31 200.93,71.31 200.25,72 196.77,72 195.57,73.2 195.59,73.23 195.5,73.65 195.07,73.74 195.04,73.73 194.21,74.56 194.19,74.65 194.26,74.72 194.44,75.46 193.7,75.28 193.63,75.21 193.53,75.24 193.44,75.33 189.3,75.33 189.18,75.47 189.01,75.54 188.93,75.54 188.85,75.53 188.7,75.46 188.59,75.33 187.12,75.33 186.57,75.87 186.57,76.64 186.96,77.03 195.47,77.03
+3V on BOTTOM (solid shape): outline of 656 points within 302.64,46.52 313.71,53.61
+3V on IN1 (solid shape): outline of 1532 points within 39.75,61.48 59.76,78.48
+3V on IN2 (solid shape): outline of 143 points within 208.77,62.75 210.34,68.4
+3V on IN2 (solid shape): outline of 1603 points within 46.73,74.44 117.01,90.03
+3V on SVCC (solid shape): outline of 1364 points within 16.34,5.28 98.57,63.47
+3V on SVCC (solid shape): outline of 1483 points within 172.23,2.03 384.97,99.15
+3V on IN3 (solid shape): 48.42,29.89 48.42,28.06 48,27.63 46.74,27.63 46.46,27.91 46.46,29.47 47.01,30.02 48.29,30.02
+3V on IN3 (solid shape): outline of 245 points within 354.99,61.94 360.95,71.85
+3V on IN3 (solid shape): outline of 665 points within 239.03,162.14 255.04,170.65
+3V on IN3 (solid shape): outline of 2399 points within 45.99,71.72 123.22,84.04
+3V on IN3 (solid shape): outline of 2928 points within 317.01,58.34 332.94,76.67
+3V on IN4 (solid shape): outline of 1626 points within 316,53.52 325.14,66.72
+3V on IN4 (solid shape): outline of 6177 points within 112.77,62.48 189.66,80.13
+3V on IN5 (solid shape): 358.82,43.88 358.82,41.47 356.69,39.34 355.75,39.34 355.49,39.59 355.49,41.42 356.15,42.08 356.15,43.52 356.67,43.52 356.68,43.47 356.69,43.41 356.71,43.37 356.74,43.32 356.77,43.28 356.81,43.24 356.85,43.22 356.9,43.19 356.95,43.18 357,43.17 357.06,43.18 357.11,43.19 357.16,43.2 357.2,43.23 357.25,43.26 357.28,43.3 357.31,43.34 357.34,43.39 357.35,43.44 357.36,43.49 357.36,43.54 357.35,43.6 357.34,43.65 357.31,43.69 357.28,43.74 357.25,43.77 357.2,43.81 357.16,43.83 357.11,43.85 357.06,43.86 357,43.86 356.95,43.86 356.9,43.84 356.85,43.82 356.81,43.79 356.77,43.76 356.74,43.72 356.71,43.67 356.69,43.62 356.68,43.57 356.67,43.52 356.15,43.52 356.15,43.55 357.02,44.42 358.29,44.42
+3V3PD on BOTTOM (solid shape): 370,34.99 370,33.67 369.96,33.63 369.3,33.63 369.19,33.73 369.19,34.98 369.29,35.07 369.92,35.07
+3V3PD on BOTTOM (solid shape): 366.4,36.38 366.4,35.38 366.36,35.34 366.22,35.22 366.15,35.05 366.15,35.03 365.87,34.75 365.87,33.61 365.82,33.56 365.19,33.56 365.13,33.62 365.13,36.6 365.21,36.68 366.1,36.68
+3V3PD on IN5 (solid shape): outline of 1664 points within 357.99,19.55 370.83,39.19
+3V_2.5V_VDDSPD-CHA on BOTTOM (solid shape): 212.46,64.51 212.46,62.57 212.19,62.3 210.62,62.3 210.35,62.57 210.35,64.44 210.38,64.48 210.98,64.48 210.98,64.62 210.99,64.63 212.34,64.63
+3V_2.5V_VDDSPD-CHB on BOTTOM (solid shape): 213.02,73.93 213.02,72.82 212.77,72.56 212.12,72.56 212.08,72.58 212.04,72.6 212,72.62 211.95,72.63 211.55,72.53 211.35,72.18 211.35,72.16 211.21,72.03 209.39,72.03 209.02,72.4 209.02,73.93 209.1,74.01 212.47,74.01 212.49,74.03 212.93,74.03
+3V_AR on TOP (solid shape): 338.73,49.75 338.73,47.72 338.48,47.46 335.81,47.46 335.55,47.72 335.55,47.98 335.56,48.01 335.57,48.02 335.74,48.28 335.7,48.58 335.7,48.61 335.7,48.63 335.74,48.73 335.75,48.83 335.75,49.95 335.81,50 338.48,50
+3V_AR on TOP (solid shape): 360.75,60.67 360.75,59.33 360.34,58.92 358.08,58.92 357.91,58.74 357.45,58.74 357.28,58.58 357.28,57.99 356.89,57.6 356.31,57.6 355.92,57.22 354.83,57.22 354.78,57.17 354.6,57.17 354.5,57.27 354.5,57.4 354.58,57.47 354.81,57.47 354.93,57.6 354.93,57.8 354.99,57.85 355.19,57.85 355.49,58.16 355.49,58.46 357.42,60.39 357.42,60.57 357.53,60.67 358.03,60.67 358.19,60.82 360.6,60.82
+3V_AR on BOTTOM (solid shape): 361.21,60.6 361.21,59.66 360.83,59.27 357.6,59.27 357.25,59.63 357.25,61.18 357.45,61.38 360.42,61.38
+3V_AR on IN1 (solid shape): outline of 1543 points within 338.37,54.33 360.65,64.47
+3V_AR on IN5 (solid shape): outline of 2648 points within 335.43,47.46 360.7,60.6
+3V_DEEP_SUS on TOP (solid shape): outline of 145 points within 319.6,62.88 331.11,66.87
+3V_DEEP_SUS on BOTTOM (solid shape): 308.32,81.87 308.32,80.5 308.78,80.03 308.78,79.51 308.77,79.48 308.73,79.43 308.7,79.4 308.65,79.27 308.65,79.13 308.65,79.11 308.64,79.09 308.57,79.02 308.57,78.26 308.57,78.26 308.57,77.66 308.53,77.61 307.61,77.61 307.58,77.61 307.58,77.58 307.13,77.13 306.7,77.13 306.66,77.16 306.65,77.17 306.56,77.27 306.43,77.33 306.42,77.33 306.37,77.39 306.37,78 306.55,78.19 306.55,78.97 306.62,79.06 306.73,79.04 307.01,78.92 307.29,79.05 307.38,79.08 307.46,79.03 307.91,78.86 308.18,79.27 307.94,79.61 307.53,79.53 307.5,79.51 307.42,79.47 307.34,79.52 307.29,79.58 307.24,79.64 307.22,79.65 307.21,79.68 307.21,80.19 306.7,80.7 306.7,81.86 306.71,81.89 306.75,81.91 308.28,81.91
+3V_DEEP_SUS on BOTTOM (solid shape): outline of 408 points within 330.02,60.54 341.85,66.44
+3V_DEEP_SUS on BOTTOM (solid shape): outline of 527 points within 298.39,49.17 302.51,57.16
+3V_DEEP_SUS on BOTTOM (solid shape): outline of 1265 points within 309.85,67.66 326.79,82.41
+3V_DEEP_SUS on IN1 (solid shape): outline of 962 points within 313.84,46.76 323.27,58.28
+3V_DEEP_SUS on IN2 (solid shape): outline of 827 points within 294.15,77.05 317.23,81.88
+3V_DEEP_SUS on IN2 (solid shape): outline of 2612 points within 314.65,50.11 329.27,72.48
+3V_DEEP_SUS on IN4 (solid shape): outline of 576 points within 298.85,50.34 316.25,54.32
+3V_DVDD on TOP (solid shape): 38.37,32.82 38.37,32.22 38.25,32.1 36.14,32.1 35.97,31.93 35.97,31.45 35.71,31.18 35.71,30.73 35.63,30.65 35.45,30.65 35.4,30.7 35.4,31.16 35.2,31.36 35.2,32.38 35.81,32.99 38.21,32.99
+3V_DVDD_IO on BOTTOM (solid shape): 31.29,35.42 31.29,31.63 31.28,31.62 31.25,31.46 31.28,31.3 31.29,31.29 31.29,31.16 31.14,31 30.4,31 30.27,31.13 30.27,32.05 30.5,32.27 30.5,35.25 30.08,35.66 30.08,35.67 29.86,35.89 29.55,35.89 29.54,35.88 29.51,35.88 29.41,35.98 29.41,36.31 29.48,36.39 30.32,36.39
+3V_EC on TOP (solid shape): 176.07,61.97 176.47,61.97 176.74,61.7 179.03,61.7 179.06,61.66 179.06,61.54 179.03,61.5 177.02,61.5 176.83,61.31 176.6,61.31 176.5,61.32 176.4,61.31 176.3,61.31 175.64,60.65 175.64,60.16 175.51,60.04 174.82,60.04 174.7,60.16 174.7,62.37 174.77,62.45 175.58,62.45
+3V_EDP on BOTTOM (solid shape): 333.01,67.78 333.52,67.78 333.56,67.75 333.56,67.73 333.58,67.6 333.64,67.5 333.65,67.48 333.65,67.32 333.64,67.31 333.57,67.15 333.57,66.98 333.57,66.95 333.56,66.93 333.27,66.64 331.11,66.64 330.86,66.89 330.86,68.04 331.11,68.29 332.51,68.29
+3V_MINIDP on TOP (solid shape): outline of 224 points within 251.23,166.03 259.61,174.97
+3V_RTC on BOTTOM (solid shape): 310.73,63.78 310.73,63.77 310.94,63.58 311.21,63.59 311.29,63.59 311.34,63.54 311.75,63.33 312.05,63.68 312.05,63.7 312.08,63.73 312.28,63.73 312.34,63.71 312.39,63.7 313.3,63.7 313.42,63.59 313.42,63.57 313.66,63.21 314.08,63.29 314.15,63.32 314.22,63.29 314.48,63.2 314.73,63.3 314.8,63.32 314.87,63.3 315.18,63.2 315.46,63.37 315.53,63.42 315.62,63.39 316.04,63.39 316.12,63.35 316.14,63.27 316.4,62.84 316.87,63.02 316.96,63.07 317.05,63.02 317.38,62.82 317.72,62.99 317.79,63.04 317.88,63.01 318.03,62.86 318.03,62.28 317.77,62.02 317.31,62.02 317.29,61.98 317.26,61.97 317.01,61.97 316.73,62.08 316.45,61.97 315.59,61.97 315.51,62.01 315.49,62.09 315.11,62.59 314.73,62.09 314.71,62.01 314.63,61.97 314.35,61.97 313.71,62.6 312.59,62.6 312.35,62.69 312.11,62.6 311.63,62.6 311.61,62.61 311.59,62.63 311.27,62.81 310.95,62.63 310.93,62.61 310.9,62.6 310.78,62.6 310.76,62.61 310.57,62.69 310.36,62.65 310.33,62.64 310.3,62.66 310.03,62.93 310.03,63.59 310.2,63.77 310.62,63.77 310.65,63.8 310.7,63.8
+3V_RTC on IN3 (solid shape): outline of 2818 points within 292.63,56.05 326.41,67.4
+3V_S5 on TOP (solid shape): 45.11,66.13 45.11,64.61 44.85,64.35 42.44,64.35 42.18,64.61 42.18,66.13 42.31,66.26 44.98,66.26
+3V_S5 on TOP (solid shape): 31.93,56.82 31.93,56.23 31.93,56.21 31.91,56.19 31.87,56.16 31.83,56.12 31.82,56.11 31.8,56.11 31.61,56.11 31.17,55.66 30.48,55.66 30.34,55.81 30.34,56.68 30.4,56.74 31.16,56.74 31.31,56.89 31.86,56.89
+3V_S5 on TOP (solid shape): 349.3,64.18 349.48,64 349.74,63.97 349.77,63.98 350.12,63.62 350.12,63.3 350.2,63.23 350.2,63 349.94,62.74 349.87,62.74 347.92,62.74 347.72,62.94 347.72,64.15 347.75,64.18
+3V_S5 on TOP (solid shape): 131.08,69.31 131.08,65.24 130.07,64.23 129.81,64.23 129.48,64.56 129.48,64.71 129.33,64.86 128.42,64.86 128.29,64.99 128.29,65.56 128.3,65.6 128.34,65.61 128.61,65.78 128.67,66.1 128.67,66.11 128.67,66.95 128.68,66.97 128.69,66.99 128.81,67.28 128.69,67.56 128.68,67.58 128.67,67.6 128.67,69.18 128.93,69.43 130.96,69.43
+3V_S5 on BOTTOM (solid shape): 289.93,50.49 294.3,50.49 295.9,48.89 299.68,48.89 299.85,48.71 299.85,48.69 299.88,48.68 302.32,48.68 302.38,48.62 302.38,47.82 302.37,47.81 302.37,47.27 302.2,47.11 291.13,47.11 290.4,47.85 290.17,48.07 290.17,48.07 289.26,48.97 289.26,50.55 289.39,50.68 289.74,50.68
+3V_S5 on BOTTOM (solid shape): outline of 680 points within 31.21,56.02 45.03,67.09
+3V_S5 on IN3 (solid shape): outline of 265 points within 193.44,54.2 199.28,58.13
+3V_S5 on IN3 (solid shape): outline of 773 points within 169.18,58.27 191.38,63.31
+3V_S5 on IN3 (solid shape): outline of 3190 points within 281.45,55.21 317.01,62.07
+3V_S5 on IN3 (solid shape): outline of 3728 points within 43.58,56.18 131.85,69.43
+3V_S5 on IN4 (solid shape): outline of 1004 points within 285.07,49.93 293.64,60.06
+3V_S5 on IN5 (solid shape): outline of 1190 points within 129.18,60.52 170.8,69.3
+3V_SSD1 on TOP (solid shape): 75.51,22.47 75.51,21.35 75.41,21.25 75.03,21.25 74.49,21.78 74.21,21.78 74.11,21.89 74.11,22.44 74.24,22.57 75.41,22.57
+3V_SSD1 on TOP (solid shape): 61.46,26.97 67.05,26.97 67.23,26.79 67.23,25.49 67.1,25.37 61.76,25.37 61.75,25.37 61.6,25.4 61.44,25.38 61.39,25.38 60.99,24.97 60.81,24.97 60.65,25.12 60.65,25.41 60.37,25.7 60.19,25.7 60.09,25.8 60.09,27.27 60.14,27.32 61.11,27.32
+3V_SSD1 on BOTTOM (solid shape): 68.77,22.58 68.81,22.58 69.11,22.58 69.15,22.58 69.19,22.6 70.61,22.6 70.76,22.44 70.76,21.84 70.66,21.73 68.6,21.73 68.45,21.89 68.45,22.44 68.6,22.6 68.72,22.6
+3V_SSD1 on BOTTOM (solid shape): outline of 122 points within 72.99,17.01 75.89,22.62
+3V_SSD1 on BOTTOM (solid shape): outline of 145 points within 56.41,17.01 60.77,22.83
+3V_SSD1 on IN2 (solid shape): outline of 2312 points within 56.41,16.96 76.19,28.41
+3V_SSD2 on TOP (solid shape): 39.92,27.17 39.92,27.07 39.92,27.07 39.92,25.54 39.67,25.29 37.25,25.29 36.9,25.65 36.9,27.27 37.31,27.68 39.42,27.68
+3V_SSD2 on TOP (solid shape): 48.92,22.67 48.92,22.06 48.7,21.85 48.18,21.85 47.96,21.63 46.2,21.63 46.1,21.73 46.1,22.85 46.3,23.05 47.7,23.05 47.92,23.28 48.31,23.28
+3V_SSD2 on TOP (solid shape): 47.82,27.22 47.82,26.18 47.65,26 45.84,26 45.5,25.67 45.16,25.67 44.88,25.79 44.59,25.67 44.11,25.67 43.94,25.71 43.76,25.67 42.96,25.67 42.79,25.83 42.79,27.02 43.04,27.27 47.78,27.27
+3V_SSD2 on BOTTOM (solid shape): 49.27,22.29 49.27,18.69 49.52,18.43 49.52,17.26 49.3,17.03 47.8,17.03 47.59,17.25 47.59,17.36 48.06,17.83 48.06,19.67 47.54,20.19 47.54,22.97 47.81,23.24 48.32,23.24
