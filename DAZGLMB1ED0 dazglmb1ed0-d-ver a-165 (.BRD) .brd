# Allegro board DAZGLMB1ED0 dazglmb1ed0-d-ver a-165 (.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
XDP_TDO_CPU: length 4.4
  TOP w0.14: U41.BT28 265.94,124.3 267.2,124.3 267.35,124.45 270.1,124.45 R578.2
XDP_TMS_CPU: length 4.7
  TOP w0.14: R20753.2 268.86,124.04 268.83,124.08 267.4,124.08 267.34,124.02 266.29,124.02 266.14,123.87 264.96,123.87 U41.BP28
XDP_TRST#: length 127.7
  TOP w0.127: U41.BP30 264.59,125.82
  TOP w0.14: U13113.AY5 310.79,55.11 310.79,55.24 v2(310.69,55.34) ; R564.2 270.35,128.47 v1(270.35,128.46) 270.2,128.31 269.9,128.31 269.62,128.03 268.75,128.03 267.05,126.33 266.29,126.33 266.14,126.18 264.95,126.18 264.59,125.82
  IN2 w0.089: v1(283.41,62.35) 283.41,73.52 277.12,79.82 277.12,95.24 276.14,96.21 276.14,102.31 274.37,104.09 274.37,107.13 264.97,116.53 262.81,116.53 261.82,117.52 261.82,124.15 262.68,125.01 267.02,125.01 269.3,127.28 269.3,127.41 v1(270.35,128.46)
  IN5 w0.089: v1(283.41,62.35) 283.41,61.14 285,59.55 285.84,59.55 286.93,58.46 287.24,58.46 287.76,57.95 291.48,57.95 293.19,59.66 299.36,59.66 299.56,59.86 300.86,59.86 301.75,60.75 303.95,60.75 305.46,59.24 305.46,54.7 305.76,54.4 306.29,54.4 306.6,54.7 306.6,55.13 306.95,55.49 307.77,55.49 307.87,55.59 309.65,55.59 309.9,55.34 v2(310.69,55.34)
XTAL24_IN: length 9.7
  TOP w0.102: U13113.A6 291.6,55.02
  TOP w0.14: 291.6,55.02 R21218.1 C94820.2 287.44,56.14 v1(287.09,55.8) 287.45,55.44 287.45,54.46 287.15,54.17 286.15,54.17 286,54.32 286,54.45 Y1002.1
XTAL24_OUT: length 9.3
  TOP w0.102: 291.6,54.7 U13113.A5
  TOP w0.14: 291.6,54.7 291.53,54.78 289.65,54.78 289.56,54.68 289.56,54.37 289.43,54.24 289.15,54.24 289.02,54.37 289.02,54.61 288.87,54.75 288.56,54.75 288.46,54.65 288.46,53.84 288.36,53.74 288.01,53.74 287.93,53.81 R21218.2 287.73,54.24 287.45,53.96 287.45,53.59 287.59,53.45 287.81,53.45 287.93,53.33 C94822.2 287.87,53.05 286.89,53.05 286.68,53.27 Y1002.3
XTALOUTBUFF: length 11
  TOP w0.102: U13114.BK6 146.77,114.91 v2(147.11,115.25)
  BOTTOM w0.14: R21620.1 149.37,106.49 v1(149.07,106.8) 148.53,107.33 148.48,107.33 147.69,108.13 147.69,113.13 146.58,114.24 146.58,114.72 v2(147.11,115.25)
XTALSSIN: length 5.9
  TOP w0.102: 146.45,113.35 146.45,115.3 U13114.BJ6
  TOP w0.14: R21619.1 145.97,111.2 146.07,111.29 146.07,112.97 146.45,113.35
XTLI: length 5.6
  TOP w0.14: Y1003.1 352.31,65.24 352.31,65.59 352.55,65.83 352.55,66.06 352.23,66.37 C94991.2 352.23,66.84 352.32,66.92 352.58,66.92 352.9,67.25 352.9,67.45 352.83,67.53 v1(352.11,67.53) 351.99,67.53 351.41,68.1 U13143.8
XTLO: length 5.6
  TOP w0.14: Y1003.3 351.26,63.93 351.78,64.46 351.78,66.08 351.29,66.58 C94993.2 351.29,66.88 351.43,67.02 351.43,67.35 351.01,67.77 U13143.7
N259407: length 5.5
  TOP w0.14: MR1.2 v1(236.52,165.36) 236.52,166.35 R20968.1 C94711.1
N16771972: length 9.4
  TOP w0.104: U13114.BL26 160.76,114.02 160.45,113.7 160.45,113.35 160.55,113.25 160.55,112.87 160.39,112.71
  TOP w0.14: 160.39,112.71 158.82,111.14 158.82,110.68 v1(158.34,110.2) 158.24,110.1 158.24,107.46 158.42,107.28 R21502.1 158.42,106.55 158.4,106.53 Q7851.1
N16787949: length 2.2
  BOTTOM w0.14: C890.2 182.92,60.29 v1(182.39,60.29) 181.96,60.29 181.58,60.67 R817.1
N16788300: length 2.9
  TOP w0.14: v1(177.16,60.93) 177.43,61.2 U49.12
  BOTTOM w0.14: C891.1 177.29,61.06 v1(177.16,60.93) 176.8,61.28 v1(176.8,61.54)
N16788343: length 4.6
  TOP w0.14: U49.15 176.87,60 R67306.2 176.78,59.67 176.27,59.16 v1(176.25,59.16)
  BOTTOM w0.14: R67291.2 177.42,60.34 v1(176.25,59.16)
N16788450: length 5.7
  TOP w0.14: v1(176.98,65.04) 177.22,64.8 U49.3 179.22,64.8 179.32,64.91 180.23,64.91 v1(180.72,65.4)
  BOTTOM w0.14: v1(180.72,65.4) 180.72,65.02 181.27,64.47 R67038.1
N16788484: length 7.5
  TOP w0.14: U49.66 193.09,53.6 192.32,54.37 v1(192.32,54.93)
  BOTTOM w0.14: R67332.1 R20904.2 192.3,53.69 192.43,53.81 C94645.1 193.56,54.61 193.24,54.93 v1(192.32,54.93)
N16788554: length 7.1
  TOP w0.14: U49.82 192.39,60 191.9,59.51 190.63,59.51 v1(190.52,59.4)
  BOTTOM w0.14: v1(190.52,59.4) 190.52,59.67 C96219.2 189.56,60.23 189.5,60.29 R67312.2 188.71,60.67 188.36,61.02 R67335.1
N16788590: length 6.5
  TOP w0.14: U49.122 182.4,68.33 181.99,68.75 181.99,69.1 182.37,69.49 182.37,70.93 181.83,71.47 R67314.2 R67315.2 183.26,71.6 v1(183.36,71.7)
N16788625: length 6.3
  TOP w0.14: U49.98 192,65.79 v1(191.99,65.78)
  BOTTOM w0.14: v1(191.99,65.78) 191.36,66.41 v1(191.36,66.69) 191.43,66.76 C94643.1 192.55,66.76 192.68,66.63 R67341.2 192.39,65.09 R20902.2
N17045084: length 6.1
  TOP w0.14: U49.2 177.56,65.2 177.16,65.6 177.16,66.64 v1(177.59,67.07)
  BOTTOM w0.14: v1(177.59,67.07) 177.59,66.89 178.61,65.87 R67333.1 R67334.1
N17045098: length 4.1
  TOP w0.14: U49.128 180,68.32 v1(179.67,68.65) 179.67,68.98 179.1,69.55 C94646.1 178.37,69.55 178.2,69.72 R20905.2
N17086723: length 4.5
  TOP w0.14: C95057.2 R21507.1 133.76,114.81 133.47,114.52 132.1,114.52 131.98,114.4 U13115.5 132.36,113.56 v1(132.58,113.78)
N19293751: length 1.3
  TOP w0.14: U41.AU13 252.46,112.22 v1(252.15,112.53)
  BOTTOM w0.14: T27.1 252.57,112.95 v1(252.15,112.53)
N19293753: length 1.4
  TOP w0.14: U41.AY13 254.29,112.22 v1(253.98,112.53)
  BOTTOM w0.14: T28.1 254.4,112.11 v1(253.98,112.53)
N19293755: length 1.3
  TOP w0.14: v1(251.24,112.53) 251.55,112.22 U41.AT13
  BOTTOM w0.14: T25.1 251.23,112.54 v1(251.24,112.53)
N19293757: length 1.8
  TOP w0.14: v1(253.07,112.53) 253.38,112.22 U41.AW13
  BOTTOM w0.14: v1(253.07,112.53) 253.22,112.53 T26.1
N19641145: length 1.2
  TOP w0.102: U13113.BE5 313.16,54.61 v2(312.9,54.35)
  BOTTOM w0.14: v2(312.9,54.35) 312.9,54.88 TP13093.1
N19689710: length 1.7
  TOP w0.14: v2(311.27,61.15) 311.32,61.2 U13113.BC18
  BOTTOM w0.14: v2(311.27,61.15) 310.89,60.77 T78.1
N19748096: length 1.8
  TOP w0.14: U41.BM14 263.28,113.28 v1(263.61,113.61)
  BOTTOM w0.14: v1(263.61,113.61) 263.61,113.77 264.15,114.32 T23.1
N19748098: length 1.4
  TOP w0.14: v1(262.96,113.61) 262.63,113.28 U41.BL14
  BOTTOM w0.14: v1(262.96,113.61) 263.16,113.81 T24.1
N19799125: length 5.7
  TOP w0.102: v1(315.13,63.59) 315.11,63.59 314.68,63.16 313.18,63.16 313.13,63.21 312.57,63.21 312.31,63.47 U13113.BC23
  BOTTOM w0.14: v1(315.13,63.59) 315.26,63.72 316.89,63.72 TP13148.1
N19801823: length 1.7
  TOP w0.14: U13113.D8 293.41,56.38 293.93,56.38 v2(293.95,56.4)
  BOTTOM w0.14: v2(293.95,56.4) 294.15,56.61 TP13083.1
N19801825: length 1.2
  TOP w0.14: v2(292.93,55.85) 293.07,55.7 U13113.D7
  BOTTOM w0.14: TP13084.1 292.68,56.1 v2(292.93,55.85)
N19940934:
  vias: v1(75.59,72.2)
N19940984:
  vias: v1(70.45,72)
N19941004: length 29
  IN5 w0.508: v1(102.12,63.95) 101.01,63.95 100.38,64.58 94.17,64.58 92.22,66.54 88.29,66.54 87,67.83 87,71.74 v1(82.82,75.91)
  BOTTOM w0.203: PU9.14 81.88,74.97 82.33,75.42
  BOTTOM w0.508: v1(82.82,75.91) 82.33,75.42
N19941046: length 4.7
  BOTTOM w0.203: PR183.1 PR181.1 PR180.2 78,72 78.2,71.8 v1(78.56,71.8) 78.66,71.91 PU9.7
N19941188:
  vias: v1(96.13,74.39)
N19941230:
  vias: v1(87.5,72.46)
N20064057: length 8.5
  TOP w0.102: U13113.AG2 304.61,53.26 304.61,52.95 304.41,52.75 304.41,52.08 304.5,51.99 304.5,51.31 303.98,50.79 303.66,50.79 303.34,50.47
  TOP w0.14: 303.34,50.47 302.81,50.47 v1(301.75,49.41) 301.6,49.25 301.6,48.03 R21087.1
N20175011: length 6.6
  TOP w0.102: U13113.AU44 309.42,74.06 309.62,74.25 309.62,74.62 309.77,74.77 309.77,75.2 309.27,75.71 309.27,75.81
  TOP w0.14: 309.27,75.81 309.27,76.96 R67238.1 310.16,77.69 310.36,77.89 310.36,77.91 310.4,77.96 310.4,78.33 310.36,78.38 310.36,79.3 v1(310.26,79.39)
N20685724: length 6.9
  TOP w0.14: U41.BN1 263.87,104.24 265.35,102.76 265.35,101.67 v1(265.4,101.62)
  BOTTOM w0.14: v1(266.14,98.47) 266.2,98.53 R180.1 R181.1 266.2,100.81 v1(265.4,101.62)
N20974301: length 13.2
  TOP w0.203: v1(195.22,73.37) 195.12,73.27 v1(195.12,72.56) 195.25,72.42 PC261.1
  TOP w0.508: PL15.2 199.22,74.34 199.82,74.34 200.21,73.95 PC262.1 201,73.95 201.22,74.17 PC260.1
  TOP w0.635: PC261.1 196.79,72.42 196.84,72.37 PJ3007.1
  TOP w0.889: PJ3007.1 199.03,73.21 198.96,73.27 PL15.2
  BOTTOM w0.203: PR303.2 193.8,73.65 194.25,73.19 195.04,73.19 v1(195.22,73.37)
N20974305: length 4.5
  TOP w0.203: PU19.4 193.68,76.1 194.26,76.68 PC264.1 PR310.2
N20974309: length 1.8
  TOP w0.203: PR307.1 v1(191.21,74.16)
  BOTTOM w0.203: PR303.1 191.71,73.65 v1(191.21,74.16)
N20974321: length 4.2
  TOP w0.14: v1(192.94,72.14) PR306.1
  TOP w0.203: PR306.1 193.91,72.94 PC263.2 193.92,73.47 194.65,74.2 PU19.1
N20974323: length 3.8
  TOP w0.14: PR304.1 190.07,73.3 189.76,73.61 189.12,73.61 v1(188.92,73.8)
  TOP w0.203: PR304.1 190.53,72.99 190.59,73.05 PR305.1 191.55,73.05 191.66,72.94 PR306.2
N20974337: length 5.8
  TOP w0.14: PR307.2 189.57,74.36 v1(187.72,74.36)
  TOP w0.203: PU19.6 192.13,74.2 191.18,75.15 PR308.1 190.53,74.91 PR307.2
N20974362: length 3.3
  TOP w0.14: v1(190.27,77.23) 190.61,76.89 PR309.1
  TOP w0.305: PU19.5 191.94,75.15 190.67,76.42 PR309.1
N21037008: length 5.1
  TOP w0.14: R20758.1 273.96,124.68 273.45,124.17 273.02,124.17 272.79,123.95 R20754.1 R20755.1 R20757.1 R578.1 270.05,124.04 R20753.1
N21715576:
  vias: v1(107.49,55.57)
N21715610:
  vias: v1(112.64,62.48)
N21715628: length 4.3
  BOTTOM w0.14: PR136.1 104.96,58.81 105.53,59.38 105.97,59.38 PC108.1 106.61,58.74 PU5.4
N21715632: length 2.7
  BOTTOM w0.14: v1(112.21,57.75) PC100.1 112.03,58.56 111.73,58.26 111.09,58.26 111.01,58.34 PU5.12
N21715634: length 2
  BOTTOM w0.14: PU5.10 110.94,59.14 111.21,59.4 v1(111.45,59.4) 111.7,59.66 PC101.1
N21715638:
  vias: v1(112.24,55.57)
N21715675: length 4.6
  BOTTOM w0.14: PU5.5 107.65,59.14 v1(107.36,59.43) 106.7,60.09 PC107.1 106.1,60.57 104.98,60.57 PR132.2
N21715683: length 6.4
  BOTTOM w0.14: PU5.3 107.54,58.34 106.9,57.7 PC106.1 106.1,57.22 105.48,57.22 105.23,57.47 PR131.1 104.55,57.07 104.34,56.86 v1(102.97,56.86)
N21716526:
  vias: v1(43.84,71.34)
N21716528:
  vias: v1(37.51,71.85)
N21716560:
  vias: v1(37.18,68.29)
N21716568: length 6
  TOP w0.14: v1(40.23,74.92) 40.69,74.92 v1(41.04,74.57) 41.09,74.51 41.09,72.94 40.78,72.63 PR175.1 40.57,71.99 40.69,71.87 PU8.4
  BOTTOM w0.14: PC145.1 40.58,75.28 v1(40.23,74.92)
N21716582: length 1.3
  TOP w0.14: PU8.12 41.09,68.22 41.13,68.17 PC129.1
N21716584: length 1.4
  TOP w0.14: PC132.1 40.12,68.18 40.29,68.35 PU8.10
N21716588:
  vias: v1(45.49,68.65)
N21716627: length 5.8
  TOP w0.14: v1(39.49,74.95) 40.05,74.39 40.05,72.91 39.84,72.7 PR176.2 39.48,72.42 40.29,71.61 PU8.5
  BOTTOM w0.14: v1(39.49,74.95) PC146.1
N21716633: length 5.5
  TOP w0.14: v1(41.9,74.97) 42.06,74.82 42.06,72.89 41.8,72.63 PR174.1 41.22,72.26 41.22,71.64 41.09,71.51 PU8.3
  BOTTOM w0.14: PC147.1 41.65,75.23 v1(41.9,74.97)
N22430008: length 1.5
  TOP w0.14: U13113.AD10 302.91,57.19 v2(302.51,57.19)
  BOTTOM w0.14: R21086.1 302.45,57.13 v2(302.51,57.19)
N22944814: length 1.4
  BOTTOM w0.381: C94919.2 238.96,69.81 239.62,70.48 R21436.2
N23334321: length 3.4
  BOTTOM w0.203: PR2023.2 PC2030.1 177.9,77.56 178.72,78.38 PU2001.4
N23334329: length 2.9
  BOTTOM w0.14: v1(183.26,83.1) 183.45,83.1 183.9,82.65 PC2029.2
  BOTTOM w0.508: PC2029.2 183.9,81.48 184.11,81.27 PR2022.1
N23334357:
  vias: v1(202.64,90.03)
N23334507: length 2.2
  BOTTOM w0.203: PR2028.1 178.86,77.66 v1(179.01,77.82) 179.12,77.92 PU2001.3
N23334555: length 1.5
  TOP w0.508: PC2039.1 PR2025.2
N24995566: length 5.1
  TOP w0.14: PR3020.2 286.6,84.31 286.76,84.47 286.76,85.89 287.02,86.16 PC6228.1 287.39,85.56 287.35,85.52 PU3002.5 v1(288.13,84.7)
N24995570: length 2.3
  TOP w0.14: PU3002.1 287.35,80.91 287.39,80.87 PR3021.1 287.11,80.68 286.76,80.68 v1(286.56,80.89)
N24995581: length 3.1
  TOP w0.14: PU3002.3 289.25,81.07 289.43,80.89 289.89,80.89 290.38,81.38 PR3022.1 290.57,82.19 v1(290.54,82.22)
N25175376: length 2.6
  BOTTOM w0.508: PC9484.2 168.01,76.61 v1(167.63,76.98) 167.05,76.98 166.61,76.54 PR66983.1
N25176926: length 2.9
  TOP w0.14: v1(163.75,66.72) 164.05,67.02 164.05,67.52 PR66994.1
  TOP w0.305: PR67001.2 PR66994.1 PR67000.2
N25176932: length 4.9
  TOP w0.14: v1(164.83,65.81) 164.83,66.7 165.24,67.12 165.44,67.12 166.26,67.95 PR66986.1
  TOP w0.305: PR66986.1 166.26,68.34 165.85,68.75 PU9014.5
N25176937: length 2.5
  TOP w0.14: PR66986.2 166.26,66.09 v1(166.46,65.9)
  TOP w0.61: PR66986.2 PC9487.1
N25176943: length 6.7
  TOP w0.305: v1(164.76,69.03) 164.85,69.12 PU9014.3 ; v1(162.33,70.92) 161.84,70.44 PR66989.2 ; v1(162.33,70.92) 161.89,71.35 PC9490.2 ; v1(162.33,70.92) 162.33,71.01 162.74,71.43 PU9014.29
  IN5 w0.305: v1(162.33,70.92) 164.19,69.05 164.74,69.05 v1(164.76,69.03)
N25176945: length 3.4
  TOP w0.14: v1(161.34,68.19) 161.99,68.19 PR66995.2
  TOP w0.305: PU9014.1 163.13,69.78 162.45,69.1 162.45,68.66 PR66995.2
N25176947: length 1.5
  TOP w0.305: PR66994.2 164.1,69.16 164.3,69.35 164.3,69.35 164.35,69.41 PU9014.2
N25195796: length 4.3
  TOP w0.14: PC5583.1 270.64,168.37 270.56,168.46 PR66837.1 270.07,167.66 269.46,167.05 268.4,167.05 268.16,166.82 PU37.26
N25195989: length 4.3
  TOP w0.14: v1(262.22,163.16) 262.45,163.16 262.75,162.87 PU37.44
  BOTTOM w0.14: v1(262.9,164.46) PC5584.1
  BOTTOM w0.508: PR66838.1 261.42,163.16 v1(262.22,163.16) 262.61,163.54 PC5584.1
N25196021: length 1
  TOP w0.203: PR66849.1 262.99,168.83 262.58,169.23 T9005.1
N25196023: length 1
  TOP w0.14: PR66856.1 264.41,168.9 T9006.1
N25196027: length 0.8
  TOP w0.14: T9007.1 265.12,169.41 PR66850.1
N25200237: length 2.6
  TOP w0.508: 266.16,148 266.16,148.94 265.81,149.29 PC5635.2
  BOTTOM w0.508: PR66917.1 v1(270.71,146.57)
N25200251: length 3.5
  TOP w0.508: 259.2,147.39 258.41,148.17 PC5646.2
  BOTTOM w0.508: PR66922.1 263.47,146.83 v3(263.16,146.52)
  vias: v1(258.36,147.34)
N25200989: length 5.6
  TOP w0.203: PC5654.2 225.07,149.34 PL6.1
  BOTTOM w0.508: v1(224.51,144.8) 225.38,145.68 PR66927.1
  vias: v1(220.31,149.17)
N25200997: length 2.8
  TOP w0.203: PC5654.1 227.2,148.79 227.2,147.67 227.67,147.19 PU43.13
N25248500: length 1.4
  TOP w0.14: PC5594.1 PR66897.2 v1(272.71,159.4)
N25248502: length 1.5
  TOP w0.14: v1(269.79,157.01) 269.31,157.49 PR66880.2 PC5588.1
N25248512: length 1.6
  BOTTOM w0.14: PR66867.2 PC5586.1 268.83,160.27 v1(269.05,160.05)
N25255287: length 3.4
  BOTTOM w0.178: PU1.20 71.84,57.79 72.05,58 72.77,58 v1(73.38,58.61) 73.86,59.1 PR5.1
N25255291: length 2.9
  BOTTOM w0.178: PU1.19 71.44,57.85 71.93,58.34 72.23,58.34 72.87,58.97 72.87,59.47 PR6.1
N25255306: length 22.8
  IN4 w0.508: v1(71.19,62.18) 71.85,62.18 72.4,61.64 74.67,61.64 75.71,62.68 88.97,62.68 89.86,61.79 v2(90.29,61.79)
  BOTTOM w0.508: PR7.1 70.34,60.25 PC17.1 70.34,61.76 70.77,62.18 v1(71.19,62.18)
  vias: v1(91.08,56.61)
N25255314: length 4.6
  TOP w0.508: PQ1.4 208.69,170.32 208.69,170.39 208.6,170.48 v1(208.6,170.53)
  BOTTOM w0.508: v1(208.6,170.53) 209.06,170.07 PC2.2 208.53,168.94 PC1.2 PR29.1
N25255394: length 2.6
  BOTTOM w0.14: v1(80.25,60.01) PC19.1
  BOTTOM w0.508: PC19.1 PR33.2
N25255413: length 2.8
  BOTTOM w0.14: PC15.2 v1(78.23,54.32)
  BOTTOM w0.508: PR11.1 77.2,55.14 76.99,54.93 PC15.2
N25255465: length 23.6
  IN5 w0.508: v1(72.5,60.87) 73.58,61.96 88.53,61.96 v1(91.76,58.72)
  BOTTOM w0.508: PC17.2 71.7,60.81 PR4.1 71.81,60.18 v1(72.5,60.87)
N25255510: length 4.6
  BOTTOM w0.178: PR19.2 65.91,57.13 66.22,56.82 66.22,56.06 v1(66.24,56.05) 66.54,56.05 67.08,55.52 68.14,55.52 68.31,55.35 PU1.11
N25255512: length 3
  BOTTOM w0.178: PR17.2 67.11,56.69 67.38,56.69 v1(67.81,56.25) 67.94,56.25 68.45,55.75 PU1.12
N25255513: length 3.5
  BOTTOM w0.178: PR32.2 67.92,51.41 68.13,51.61 68.13,52.36 68.26,52.5 68.99,52.5 PU1.7
N25255515: length 3.4
  BOTTOM w0.14: PR25.2 67.14,54.01 v1(66.7,54.45)
  BOTTOM w0.178: PR25.2 67.46,53.53 68.47,54.55 PU1.9
N25255534: length 1.3
  BOTTOM w0.178: PU1.5 70.64,52.51 70.56,52.42 PR30.2
N25255538: length 6.8
  BOTTOM w0.14: PR8.1 68.16,61.5 v1(68.75,62.09)
  BOTTOM w0.178: PR205.1 68.18,59.14 69.31,58 69.74,58 69.84,57.9 PU1.15
  BOTTOM w0.203: PR8.1 67.72,61.31 67.72,60.45 67.47,60.2 67.47,59.63 PR205.1
N25255547: length 2.6
  BOTTOM w0.178: PR26.2 67.18,52.57 v1(67.99,53.38) 68.75,54.15 PU1.8
N25272043: length 2.5
  BOTTOM w0.14: PC9375.1 v1(94.8,82.55)
  BOTTOM w0.508: PC9375.1 93.97,83.05 94.18,83.25 PR66969.2
N25272069: length 1.8
  BOTTOM w0.203: v1(95.04,77.54) 95.02,77.56 PR104.1
  BOTTOM w0.508: v1(95.04,77.54) 95.46,77.11 PC9380.1
  vias: v1(101.34,77.46)
N25275939:
  vias: v1(107.94,71.92)
N25275943:
  vias: v1(100.96,72.2)
N25275965: length 1.8
  TOP w0.14: PU9004.10 104.5,67.42 PC9073.1
N25275966: length 1.9
  TOP w0.14: PC9072.1 105.46,67.96 v1(105.2,68.22)
  TOP w0.178: PU9004.12 105.3,68.31 v1(105.2,68.22)
N25275967: length 3.7
  TOP w0.178: PC9069.1 104.9,72.37 PU9004.4
  TOP w0.203: PC9069.1 104.42,72.6 104.16,72.86 104.16,73.87 PR9223.1
N25275980: length 4.5
  TOP w0.178: PC9071.1 103.89,72.6 104.5,71.99 PU9004.5
  TOP w0.254: PC9071.1 103.53,72.6 103.12,73.02 103.12,74.41 103.47,74.76 PR9057.1
N25275989: length 3.7
  TOP w0.178: PU9004.3 105.3,72.21 PC9070.1
  TOP w0.203: PR9056.2 106.19,73.87 106.19,72.99 105.8,72.6 PC9070.1
N25276006: length 6.6
  TOP w0.14: PR9165.2 v1(149.37,60.52) 149.02,60.52 147.47,58.97 147.47,58.26 147.18,57.97 146.37,57.97 146.07,57.67 PD9003.2
N25276014: length 14.2
  TOP w0.14: PQ9011.3 148.22,56.58 148.74,56.58 v1(149.04,56.89) 149.32,56.89 149.5,56.71 PR9062.1 149.9,57.12 149.99,57.22 PQ9010.2 149.55,58.55 PR9061.2 149.96,59.87 149.96,61.66 149.6,62.02 146.48,62.02 146.2,61.74 PQ9034.2
N25276025:
  vias: v1(164.54,62.53)
N25276027: length 2.4
  TOP w0.14: PU9005.3 157.83,57.94 157.69,58.08 PR9077.1 157.35,58.54 v1(157.7,58.89)
N25276032:
  vias: v1(152.22,60.32)
N25276035: length 22.6
  TOP w0.14: PQ9011.2 146.86,55.77 v1(146.6,55.52)
  TOP w0.254: v1(162.71,57.37) 162.71,57.57 162.34,57.94 PU9005.4
  IN3 w0.079: v1(162.71,57.37) 162.23,57.37 161.37,56.51 147.95,56.51 146.96,55.52 v1(146.6,55.52)
  BOTTOM w0.254: PR9065.2 PC9081.1 163.82,58.46 163.97,58.32 PR67002.2 163.35,57.47 162.81,57.47 v1(162.71,57.37)
N25276054: length 2.5
  BOTTOM w0.14: v1(159.29,57.22) PR67010.2
  BOTTOM w0.508: PR9066.1 160.47,58.06 160.17,58.36 159.59,58.36 PR67010.2
N25276055: length 1.8
  BOTTOM w0.14: PR9064.2 v1(162.3,61.64)
  BOTTOM w0.508: PC9080.1 PR9064.2
N25318217: length 2.1
  BOTTOM w0.14: PC5638.1 269.94,150.07 v1(269.87,150)
  BOTTOM w0.508: PC5638.1 270.71,150.05 PR66917.2
N25320279: length 2.2
  BOTTOM w0.14: v1(262.89,150.01) 262.95,150.07 PC5647.1
  BOTTOM w0.508: PR66922.2 263.7,149 PC5647.1
N25324032: length 2.2
  BOTTOM w0.508: PR66927.2 226.9,143.91 v1(227.3,143.91) 227.62,144.23 PC5660.1
N25329170: length 4.8
  TOP w0.14: v1(142.9,72.41) 142.79,72.51 PQ9001.2
  TOP w0.203: PQ9001.2 143.45,73.42 143.84,73.03 PR9007.1 PR9003.2 145.55,73.37 PQ9000.3
N25329172: length 69.1
  TOP w0.203: PR9009.1 PR9012.2 144.16,99.12 v1(144.38,98.89)
  IN5 w0.203: v1(135.54,69.05) 135.99,69.49 135.99,70.91 135.73,71.16 134.03,71.16 130.91,74.29 130.2,74.29 126.41,78.07 126.41,83.79 127.58,84.95 127.58,88.61 129.36,90.39 129.36,98.28 131,99.93 133.6,99.93 134.58,98.95 137.36,98.95 138.27,99.86 142.95,99.86 143.15,100.07 143.15,100.7 143.35,100.91 143.76,100.91 143.96,100.7 143.96,100.07 144.17,99.86 144.57,99.86 144.77,100.07 144.77,101.4 145.01,101.63 145.41,101.63 145.59,101.46 145.59,100.07 145.79,99.86 146.52,99.86 146.94,99.44 146.94,98.77 146.61,98.43 144.85,98.43 v1(144.38,98.89)
  BOTTOM w0.203: PR9017.1 136.77,67.89 136.73,67.84 PC9006.2 PC9005.1 ; PC9003.1 136.95,69.05 PC9005.1 ; PC9005.1 v1(135.54,69.05)
N25329191: length 2.9
  TOP w0.14: PR9244.1 137.38,66.71 v1(137.38,66.13)
  TOP w0.203: PR9241.1 137.1,66.99 PR9244.1 PR9236.1
N25329192: length 3.1
  TOP w0.203: v1(139.06,68.31) 138.73,68.31 138.43,68.02 138.43,67.68 137.9,67.15 PR9244.2
  BOTTOM w0.203: v1(139.06,68.31) 139.09,68.34 139.14,68.34 139.25,68.45 PU9001.27
N25329193: length 3.8
  TOP w0.14: v1(140,69.21) 139.23,69.21 v1(138.98,68.96)
  TOP w0.203: PR9236.2 137.9,68.02 138.83,68.96 v1(138.98,68.96)
  BOTTOM w0.203: PU9001.28 139.08,68.85 v1(138.98,68.96)
N25329218: length 3
  BOTTOM w0.203: PC9009.2 137.67,65 PC9008.2 PR9028.2 135.95,65.19 PR9027.1
N25329239: length 3
  BOTTOM w0.203: PC9007.1 139.47,73.89 PR9029.1 PR9030.1 141.45,73.81 PR9031.1
N25329279: length 65.5
  TOP w0.203: v1(139.59,98.39) 140.36,99.16 PR9000.1
  IN5 w0.203: v1(150.39,65.04) 149.21,66.22 146.71,66.22 146.33,66.6 141,66.6 139.68,67.92 139.68,71.35 139.31,71.72 136.82,71.72 136.19,72.36 134.39,72.36 131.31,75.43 130.37,75.43 127.31,78.49 127.31,83.42 128.49,84.6 128.49,88.13 130.27,89.91 130.27,97.74 131.42,98.89 133.28,98.89 134.13,98.05 137.84,98.05 138.66,98.87 139.11,98.87 v1(139.59,98.39)
  BOTTOM w0.203: PR9052.2 151.02,65.38 151.02,64.6 PR9045.2 150.39,64.74 v1(150.39,65.04)
N25329280: length 79.7
  TOP w0.203: v1(138.88,98.39) 139.39,97.88 139.86,97.88 140.36,98.38 PR9000.2
  IN5 w0.203: v1(150.62,66.84) 150.29,66.51 146.83,66.51 146.45,66.89 141.12,66.89 139.97,68.04 139.97,71.47 139.43,72.01 136.95,72.01 136.31,72.65 134.51,72.65 131.42,75.74 130.47,75.74 127.6,78.61 127.6,83.29 128.8,84.48 128.8,88 130.56,89.77 130.56,97.62 131.55,98.6 133.16,98.6 134.01,97.76 138.25,97.76 v1(138.88,98.39)
  BOTTOM w0.14: PR9058.1 v1(158.39,64.47)
  BOTTOM w0.203: PC9016.2 PR9240.1 147.57,65.78 147.76,65.58 PC9015.2 ; PC9015.2 148.05,66.01 148.09,66.05 PC9000.1 148.6,66.13 149.37,66.13 150.08,66.84 v1(150.62,66.84) ; PC9015.2 PR9048.2 149.91,65.58 PR9052.1 150.48,66.16 151.05,66.16 152.05,65.15 PR9242.1 152.95,64.52 PR9060.1 154.16,64.15 155.18,64.15 PR9238.1 156.14,64.57 156.27,64.44 156.82,64.44 156.84,64.47 PR9058.1
N25329287: length 5.7
  TOP w0.203: PC9002.1 148.42,72.87 PQ9000.2 147.51,72.56 147.71,72.36 PR9002.1 147.31,71.85 147.11,72.05 v1(146.78,72.05) 146.71,71.97 PR9006.2 146.06,71.22 145.51,71.77 PD9000.2
N25329351: length 2.2
  BOTTOM w0.203: PU9001.5 142.41,72.07 143.2,72.86 PR9039.1
N25329395: length 1
  BOTTOM w0.203: PR9041.2 143.4,63.33 PR9040.2
N25329401: length 3.2
  BOTTOM w0.14: PR9036.1 142.53,74.81 143.12,75.4 v1(143.12,76.34)
  BOTTOM w0.203: PR9037.1 141.58,75.59 PR9036.1
N25329418: length 1.9
  BOTTOM w0.203: PC9010.1 PR9033.1 PR9038.2
N25329440: length 1.9
  BOTTOM w0.14: PC9008.1 v1(136.72,63.39)
  BOTTOM w0.203: PC9008.1 137.16,64.22 137.36,64.02 PR9034.2
N25329447: length 1
  BOTTOM w0.203: PR9020.2 137,67.06 PC9006.1
N25331202: length 2.9
  TOP w0.14: PR9072.2 PR9071.1 PR9070.2 v1(129.86,97.87)
N25331224: length 2.4
  TOP w0.14: v1(128.11,93.69) PR9068.2
  TOP w0.305: PR9068.2 PC9027.1
N25331230: length 2.3
  BOTTOM w0.508: PR9073.1 140.41,91.03 v1(140.41,90.77) 140.01,90.37 PC9030.2
N25331270: length 9.5
  TOP w0.14: v1(147.72,69) 148.41,68.32 148.41,66.84 148.94,66.31 151.96,66.31 152.27,66.62 PR66992.1
  TOP w0.305: PR66998.2 PR66992.1 PR66999.2
N25331273: length 1.8
  TOP w0.305: PR66985.1 154.12,68.41 PU9013.5
N25331274: length 2.6
  TOP w0.14: v1(154.93,65.93) 154.43,66.44 PR66985.2
  TOP w0.508: PR66985.2 PC9486.1
N25331278: length 6.7
  TOP w0.305: PU9013.3 153.12,69.17 153.06,69.1 v1(153.06,69) ; v1(150.54,71.06) 150.49,71.06 150.11,71.44 PC9489.2 ; v1(150.54,71.06) 150.88,71.4 PU9013.29 ; v1(150.54,71.06) 150.26,70.78 PR66988.2
  IN5 w0.305: v1(150.54,71.06) 152.6,69 v1(153.06,69)
N25331279: length 3.6
  TOP w0.14: v1(149.47,68.44) 149.59,68.33 PR66993.2
  TOP w0.305: PU9013.1 151.29,69.75 150.34,68.8 PR66993.2
N25331280: length 1.6
  TOP w0.305: PR66992.2 152.27,69.03 152.62,69.38 PU9013.2
N25331384: length 2.6
  BOTTOM w0.508: PC9483.2 157.21,77.72 v1(156.76,78.17) 156.2,78.17 155.79,77.76 PR66982.1
N25331424: length 3.6
  TOP w0.14: v1(126.46,84.16) 126.58,84.04 PR66990.1
  TOP w0.305: PR66997.2 128.07,84.84 127.85,84.62 127.56,84.62 127.29,84.34 PR66990.1 PR66996.2
N25331427: length 3.8
  TOP w0.14: v1(126.36,82.82) 126.61,82.57 127.11,82.57 PR66984.1
  TOP w0.305: PR66984.1 128.61,81.86 129.18,82.42 PU9012.5
N25331428: length 2.5
  TOP w0.14: PC9485.1 126.62,79.64 v1(126.82,79.44)
  TOP w0.508: PC9485.1 PR66984.2
N25331432: length 7.6
  TOP w0.14: PC9488.2 131.43,87.2 v1(131.31,87.32)
  TOP w0.305: v1(130.93,85.82) 130.37,86.38 PR66987.2 ; v1(130.93,85.82) 131.2,85.55 PU9012.29 ; v1(130.93,85.82) 131.43,86.32 PC9488.2 ; v1(128.73,83.37) 128.78,83.42 PU9012.3
  IN4 w0.305: v1(128.73,83.37) 130.93,85.57 v1(130.93,85.82)
N25331433: length 3.2
  TOP w0.14: PR66991.2 v1(128.07,87.04)
  TOP w0.305: PU9012.1 128.91,85.05 128.91,85.38 PR66991.2
N25331434: length 1.5
  TOP w0.305: PR66990.2 128.12,83.99 129.11,83.99 129.12,83.97 129.12,83.97 129.18,83.92 PU9012.2
N25331454: length 2.3
  BOTTOM w0.508: PR66981.1 138.27,79.33 v1(138.27,79.01) 138.03,78.77 PC9482.2
N25331490: length 7.7
  TOP w0.254: PU9011.29 133.97,97.71 PC9026.2 PR9256.2 133.62,98.26 v1(133.24,97.88)
  TOP w0.305: PU9011.3 131.38,95.51 v1(131.31,95.57)
  IN5 w0.305: v1(131.31,95.57) 131.31,95.95 v1(133.24,97.88)
N25331491: length 3.5
  TOP w0.14: v1(131.16,97.81) 131.19,97.81 131.87,97.12 131.97,97.12
  TOP w0.305: PR9069.2 132.61,97.76 131.97,97.12 131.97,96.85 PU9011.1
N25331493: length 1.9
  TOP w0.305: PR9071.2 130.75,95.9 131.03,96.18 131.62,96.18 131.79,96.01 PU9011.2
N25430953: length 3.1
  TOP w0.14: v1(29.28,72.58) 29.48,72.38 PQ14.3
  TOP w0.254: PQ14.3 28.7,71.59 28.32,71.97 PR111.2
N25430988: length 2.8
  TOP w0.508: PQ12.3 35.63,62.93 36.14,62.42 v1(36.49,62.42) PR106.2
N25430994: length 2.4
  TOP w0.254: PR126.2 32.71,65.57 33.01,65.88 v1(33.01,66.16) 32.46,66.72 PQ19.3
N25431044:
  vias: v1(106.78,54.42)
N25431520: length 14.2
  TOP w0.381: PQ9050.3 110.87,54.8 v1(111.68,55.62) 112.52,56.46 112.52,59.1 112.85,59.43 112.85,62.34 112.03,63.16 110.99,63.16 110.6,63.55 110.6,64.14 110.38,64.35 PR9227.2
N25504610: length 2.4
  BOTTOM w0.14: v1(247.78,152.48) 248.03,152.74 PC5616.1
  BOTTOM w0.508: PC5616.1 248.61,151.57 PR66907.2
N25504615: length 2.3
  BOTTOM w0.14: v1(255.17,152.54) 255.26,152.64 PC5626.1
  BOTTOM w0.508: PR66912.2 256,151.54 PC5626.1
N25504770: length 2.3
  BOTTOM w0.14: v1(240.72,152.56) 240.77,152.61 PC5606.1
  BOTTOM w0.508: PC5606.1 241.55,151.75 PR66902.2
N25504898: length 4.5
  TOP w0.203: 236.67,150.21 235.99,150.89 235.99,152.52 236.27,152.8 236.48,152.8 PC5605.2
  BOTTOM w0.508: PR66902.1 v1(241.17,149.06)
N25504902: length 1.6
  TOP w0.203: PU38.21 236.63,153.73 PC5605.1
N25504904: length 3.1
  TOP w0.203: PC5614.2 243.59,151.98 243.76,151.81 243.76,151.38 244.75,150.38
  BOTTOM w0.508: PR66907.1 v1(248.43,149.17)
N25504908: length 2.6
  TOP w0.14: PC5614.1 244.05,153.23 245.36,153.23 245.62,153.49 PU39.21
N25504978: length 2.7
  TOP w0.203: 251.76,150.66 250.87,151.55 PC5624.2
  BOTTOM w0.508: PR66912.1 v1(255.8,149.14)
N25504982: length 2.5
  TOP w0.14: PC5624.1 250.87,152.85 251.28,153.25 252.55,153.25 252.86,153.56 PU44.21
N25506822: length 10.8
  TOP w0.508: PC222.2 238.02,166.08 v1(237.76,166.34) ; PR264.1 235.51,158.97 235.99,158.5 v1(235.99,158.49)
  IN4 w0.508: v1(237.76,166.34) 235.99,164.56 v1(235.99,158.49)
N25506913: length 2.3
  TOP w0.508: PC81.1 227.11,164.09 v1(226.74,164.45) 226.4,164.45 226.25,164.3 PR112.2
N25506978: length 19.9
  TOP w0.14: PQ8.3 211.25,144.59 211.64,144.98 PR83.1 211.64,146.49 211.22,146.9 PQ9059.2 211.22,150.08 210.48,150.82 210.48,159.15 v1(210.92,159.58) 211.37,160.04 PQ9054.2 212.08,161.33 PR84.2
N25507004: length 2.7
  TOP w0.14: PR86.2 213.12,150.52 213.25,150.38 v1(213.25,149.98) 212.82,149.55 PQ9059.3
N25507051: length 35.2
  TOP w0.203: PR67003.2 244.53,162.75 v1(244.9,162.75) ; PR67007.2 v1(216.53,157.9)
  BOTTOM w0.203: v1(216.53,157.9) 217.77,159.15 217.77,162.37 219.2,163.8 228.49,163.8 229.46,164.76 235.05,164.76 235.94,163.87 243.78,163.87 v1(244.9,162.75)
N25629762: length 10.2
  TOP w0.14: v1(223.79,97.04) 224.76,98.02 224.76,99.03 227.2,101.46 227.2,103.01 228.04,103.85 U41.E1
  BOTTOM w0.14: v1(223.79,97.04) 224.61,97.04 T18.1
N25629765: length 10.4
  TOP w0.14: U41.D1 226.18,103.34 226.18,102.1 223.21,99.13 223.21,98.17 v1(222.11,97.07)
  BOTTOM w0.14: T17.1 222.63,97.07 v1(222.11,97.07)
N25629774: length 12.4
  TOP w0.079: U41.E3 227.45,105.99 226.69,105.99 226.26,105.55 226.26,104.82
  TOP w0.14: 226.26,104.82 225.7,104.26 225.7,102.23 222.63,99.15 222.63,98.29 v1(222.09,97.76)
  BOTTOM w0.14: v1(222.09,97.76) 222.47,97.76 T19.1
N25629777: length 10.1
  TOP w0.14: v1(223.77,97.76) 223.77,98.87 226.64,101.74 226.64,103.14 227.65,104.16 227.65,104.98 U41.E2
  BOTTOM w0.14: T20.1 224.33,98.31 v1(223.77,97.76)
N25629792: length 9.9
  TOP w0.14: v1(267.78,103.89) 265.83,103.89 U41.BR1
  BOTTOM w0.14: v1(267.78,103.89) 266.01,103.89 264.82,102.69 264.82,99.03 T21.1
N25629798: length 8
  TOP w0.14: U41.BT2 266.47,104.39 v1(267.37,104.39)
  BOTTOM w0.14: T22.1 264.54,100.42 264.54,102.81 266.12,104.39 v1(267.37,104.39)
N27902963: length 2.1
  BOTTOM w0.508: R21409.1 240.93,51.8 v1(240.38,51.25) 239.83,51.8 C94889.2
N27904651: length 2.1
  TOP w0.14: v1(235.12,63.08) 235.18,63.02 CN2063.165
  BOTTOM w0.14: v1(235.12,63.08) T62.1
N27904653: length 3.1
  TOP w0.14: v1(235.35,55.59) 235.48,55.59 235.94,55.14 CN2063.162
  BOTTOM w0.14: T61.1 235.3,55.54 v1(235.35,55.59)
N28625551: length 8
  IN1 w0.089: CN2069.10 58.3,16.73 56.79,16.73 56.46,17.06 56.46,18.69 55.14,20.01 v1(55.14,20.79)
  BOTTOM w0.14: v1(55.14,20.79) 54.88,20.54 TP13118.1
N28683412: length 4.8
  TOP w0.14: v1(136.06,59.3) 136.05,59.31 CN2076.8
  BOTTOM w0.14: v1(136.32,62.02) 136.17,61.87 R67340.2 R67339.2 136.17,59.42 v1(136.06,59.3)
N28683473: length 5.7
  TOP w0.14: R67275.2 121.31,66.77 121.94,66.77 122.32,67.15 123.08,67.15 123.35,66.89 R67258.1 123.35,66.13 123.38,66.1 Q7892.3 122.84,65.62 v1(122.7,65.75)
  BOTTOM w0.14: R67274.2 122.04,65.09 v1(122.7,65.75)
N28683495: length 4
  TOP w0.14: R67277.2 121.95,63.75 122.82,63.75 R67259.1 122.95,64.24 v1(122.7,64.48) 122.57,64.62 Q7892.6
  BOTTOM w0.14: v1(122.7,64.48) 122.3,64.08 R67276.2
N30107216: length 1
  BOTTOM w0.254: R67138.1 365.81,27.55 365.53,27.83 v1(365.53,27.96)
N30638362: length 5.2
  TOP w0.14: R21106.1 312.46,47.09 R21109.1 R21110.1 310.31,46.31 310.19,46.19 v1(309.65,46.19) R21111.1 308.86,46.86 R21107.1
N30638583: length 6.9
  TOP w0.102: U13113.AT2 309.29,53.33 309.57,53.61 309.57,53.79 309.77,53.99 309.88,53.99 310.23,54.34 v2(310.23,54.83)
  BOTTOM w0.14: v2(310.23,54.83) 309.42,55.64 309.01,55.64 308.78,55.87 308.78,55.97 308.33,56.43 307.74,56.43 v1(307.36,56.81) 306.85,57.32 R21133.1
N30641967: length 4.7
  TOP w0.102: 305.56,50.23 306.07,50.75 306.07,51.56 306.19,51.68 306.19,52.67 306.06,52.8 306.06,52.9 305.83,53.13 U13113.AK2
  TOP w0.14: R21191.1 304.81,49.75 305.07,49.75 305.56,50.23
N30677152: length 7.7
  TOP w0.254: v2(311,59.03) 311,59.08 U13113.BA15
  BOTTOM w0.254: v2(311,59.03) 311,59.03 311.55,59.58 C94846.1 313.43,59.58 313.75,59.9 316.06,59.9 v1(316.33,60.16) 316.83,60.67 R21359.2
N30677370:
  vias: v1(316.43,49.5) v1(318.43,49.47)
N30680491: length 7.8
  TOP w0.102: U13113.BB13 312.04,58.67 312.85,58.67 312.85,58.67 315.85,58.67 316.12,58.94 v1(316.12,59.07)
  BOTTOM w0.14: v1(316.12,59.07) 316.12,59.2 315.76,59.56 313.95,59.56 313.41,59.02 TP13078.1
N30710926: length 4.9
  TOP w0.102: U13113.AV44 309.9,74.11 309.87,74.13 309.87,74.54 309.98,74.64 309.98,75.33 309.77,75.53
  TOP w0.14: TP13090.1 310.92,77.99 309.65,76.72 309.65,75.66 309.77,75.53
N30773854: length 1.5
  TOP w0.102: v2(312.34,64.48) 312.4,64.54 U13113.BC26
  BOTTOM w0.14: v2(312.34,64.48) 312.72,64.86 TP13141.1
N30774062: length 1.3
  TOP w0.127: v2(307.94,59) 307.94,59.02 308.37,59.45 U13113.AR15
  BOTTOM w0.14: v2(307.94,59) 307.94,59.02 308.37,59.45 U13113.AR15
N30774076: length 1.6
  TOP w0.127: U13113.AV13 309.69,58.48 v2(309.22,58.01)
  BOTTOM w0.14: v2(309.22,58.01) 309.22,58 TP13076.1
N30774179: length 5.1
  TOP w0.102: 308.92,75.4 308.92,74.42 309.19,74.15 309.19,73.53 U13113.AU43
  TOP w0.14: 308.92,75.4 308.92,77.49 309.06,77.64 TP13091.1
N30809865: length 2.7
  TOP w0.14: v1(263.61,127) 263.28,127.32 U41.BM33
  BOTTOM w0.14: T7.1 262.55,126.58 263.2,126.58 v1(263.61,127)
N30809866: length 18.8
  TOP w0.14: U41.BL33 262.44,127.78 v1(262.11,128.1)
  BOTTOM w0.14: T8.1 272.97,141.62 266.85,135.5 266.85,132.68 263.86,129.7 263.68,129.7 262.11,128.13 v1(262.11,128.1)
N30809890: length 1.4
  TOP w0.14: v1(260.89,113.59) 261.23,113.26 U41.BJ14
  BOTTOM w0.14: T9.1 260.42,114.06 v1(260.89,113.59)
N30809892: length 2.8
  TOP w0.14: U41.BJ13 261.47,112.57 261.72,112.82 v1(262.96,112.82)
  BOTTOM w0.14: v1(262.96,112.82) 262.2,113.58 T10.1
N30809922: length 1.7
  TOP w0.14: v1(260.79,115.45) 260.79,115.4 261.33,114.85 U41.BJ16
  BOTTOM w0.14: T11.1 261.3,115.45 v1(260.79,115.45)
N30809924: length 2
  TOP w0.14: U41.BK16 262.38,115.18 v1(262.96,115.18)
  BOTTOM w0.14: T12.1 263.41,115.64 v1(262.96,115.18)
N30809960: length 1.8
  TOP w0.14: v1(262.96,121.48) 262.38,121.48 U41.BK24
  BOTTOM w0.14: v1(262.96,121.48) 262.88,121.41 T13.1
N30809962: length 1.2
  TOP w0.14: v1(260.78,121.09) U41.BJ24
  BOTTOM w0.14: v1(260.78,121.09) T14.1
N30809992: length 2.7
  TOP w0.14: v1(261.32,128.76) 261.65,128.43 U41.BJ34
  BOTTOM w0.14: T15.1 260.37,128.02 261.11,128.76 v1(261.32,128.76)
N30809994: length 3.3
  TOP w0.14: v1(261.32,128.1) 261.65,127.78 U41.BJ33
  BOTTOM w0.14: v1(261.32,128.1) 261.23,128.1 260.85,127.73 260.85,126.23 T16.1
N30861449: length 8.5
  TOP w0.127: U13113.BC36 312.11,70.42 312.11,71.06 312.25,71.2 312.66,71.2 312.68,71.18 313.46,71.18 313.66,71.38 314.25,71.38 314.52,71.64 314.52,72.72 315.7,73.9 315.7,74.4 316.4,75.1 TP13088.1
N30861493: length 10.8
  TOP w0.102: U13113.BB36 312.03,70.02 312.9,70.02 313.02,70.14 313.02,70.53 313.45,70.95 313.54,70.95 313.75,71.16 314.42,71.16 314.77,71.52
  TOP w0.127: 317.7,74.69 317.6,74.59 316.21,74.59 315.93,74.31 315.93,73.81 314.77,72.65 314.77,71.52
  TOP w0.14: 317.7,74.69 317.81,74.79 318.61,74.79 318.84,75.02 TP13089.1
N30861840: length 3.3
  TOP w0.102: U13113.BD17 313.05,60.83 314.41,60.83 314.93,61.35 v1(314.98,61.35)
  BOTTOM w0.14: v1(314.98,61.35) 315.11,61.47 TP13087.1
N30878679: length 7.6
  TOP w0.127: U13113.BE6 313.71,54.72 313.71,54.32
  TOP w0.14: 313.71,54.32 314.88,53.15 314.88,51.43 315.67,50.64 316.25,50.64 316.58,50.97 316.58,51.32 317.09,51.83 TP13094.1
N31204434: length 6.4
  TOP w0.14: U13114.BA1 141.48,121.21 140.63,122.06 TP13116.1
N31204443: length 7
  TOP w0.14: U13114.BA2 143.46,121.71 141.66,121.71 140.59,122.77 138.32,122.77 TP13115.1
N31204854: length 4.7
  TOP w0.14: v1(125.12,113.96) 125.44,114.29 125.44,114.31 125.8,114.67 126.24,114.67 126.4,114.83 Q7859.2 126.75,115.3 127.07,114.98 v1(127.17,114.98)
  BOTTOM w0.14: v1(125.12,113.96) R67321.2 124.45,113.49 124.49,113.46 R67320.2
N31226995: length 40.6
  TOP w0.14: R21602.1 136.02,113.41 136.54,112.89 v1(136.54,112.56) 136.59,112.52 136.59,111.88 Q7861.3 136.43,110.72 136.3,110.58 R21603.2
  IN4 w0.089: v1(124.99,116.15) 123.72,114.88 123.72,112.39 122.24,110.91 v1(121.76,110.91)
  IN5 w0.089: v1(136.54,112.56) 136.54,113.25 134.56,115.23 134.56,116.5 134.01,117.06 132.6,117.06 132.06,116.53 129.61,116.53 128.75,117.39 128.24,117.39 127.68,117.95 126.11,117.95 125.34,117.19 125.34,116.5 v1(124.99,116.15)
  BOTTOM w0.14: D13088.2 R67323.1 126.76,109.26 126.65,109.37 Q7943.1 122.59,110.08 v1(121.76,110.91) ; v1(124.99,116.15) 124.47,115.62 Q7863.3 123.59,115.54 123.34,115.79 120.92,115.79 120.63,116.08 D8591.1
N31226999: length 6.7
  BOTTOM w0.14: D8594.1 118.93,119.14 119.39,119.6 R21613.1 R21611.1 ; D8594.1 v1(117.67,118.58) D8592.2 ; D8594.1 D8591.2
N31267415: length 3.5
  TOP w0.14: v1(121.9,118.49) D8595.3
  BOTTOM w0.14: Q7867.2 121.82,116.56 122.6,117.34 R21616.2 121.9,118.27 v1(121.9,118.49)
N31267438: length 4.6
  BOTTOM w0.14: Q7867.3 122.32,114.77 122.04,114.49 C95158.2 122.04,113.88 121.75,113.6 Q7866.2 122.59,113.37 v1(122.75,113.53) 122.98,113.3 122.98,112.64 122.83,112.49 R21618.2
N31399389:
  vias: v1(173.76,71.34)
N31399406: length 3.7
  TOP w0.14: R251.2 175.03,70.2 174.65,70.58 R20897.2 174.54,71.21 174.57,71.24 R20898.2 173.68,72.47 v1(173.68,72.86)
N31579849: length 1.1
  BOTTOM w0.14: R20817.2 232.51,114.44 233.04,113.91 R20818.1
N31579856: length 1.9
  BOTTOM w0.14: R145.2 230.12,113.71 230.14,113.69 R20816.2 v1(230.14,112.28)
N31583921: length 2.2
  TOP w0.14: U13113.R7 298.17,55.42 v2(297.91,55.15)
  BOTTOM w0.14: TP13086.1 298.85,56.1 v2(297.91,55.15)
N31583923: length 2.7
  TOP w0.14: U13113.R8 298.1,55.86 v2(297.91,55.86)
  BOTTOM w0.14: v2(297.91,55.86) 298.37,56.33 298.37,57.27 TP13085.1
N31810763:
  vias: v1(338.2,85.74)
N31810778: length 3.6
  BOTTOM w0.508: Q7823.3 353.62,92.69 352.97,93.34 352.55,93.34 352.1,93.79 Q7822.2
  vias: v1(351.07,93.69)
N31853816: length 3.6
  TOP w0.14: v1(48.69,71.7) 48.44,71.95 R67246.2
  TOP w0.254: R67246.2 R67247.2 47.5,73.11 47.14,73.47 D8568.2
N31870197: length 24.8
  TOP w0.203: R20987.2 v1(241.32,166.46)
  TOP w0.254: v1(244.37,166.46) 244.65,166.46 244.83,166.64 Q7831.3 ; Q7904.5 Q7904.2 246.88,164.89 247.09,165.1 C94739.1 247.09,166.03 v1(247.04,166.08) ; v1(249.96,166.08) 249.96,166.07 C94741.1 249.83,165.18 Q7903.2 Q7903.5 ; v1(244.09,164.61) 244.36,164.88 Q7827.3
  BOTTOM w0.508: v1(249.96,166.08) 249.96,165.7 249.68,165.42 248.71,165.42 248.05,166.08 v1(247.04,166.08) 246.88,165.92 246.88,164.89 246.02,164.02 244.67,164.02 v1(244.09,164.61) 244.09,166.18 v1(244.37,166.46) 244.88,166.97 244.88,167.58 244.32,168.14 243.25,168.14 v1(242.16,167.05) 241.57,166.46 v1(241.32,166.46)
N31870208: length 5
  TOP w0.14: v1(249.45,162.27) 249.33,162.39 Q7903.4 ; v1(250.59,165.07) 250.33,164.8 Q7903.1
  BOTTOM w0.14: v1(250.59,165.07) 249.33,163.8 249.33,162.39 v1(249.45,162.27)
N31870227: length 5.4
  TOP w0.14: v1(246.83,162.32) 246.69,162.32 246.38,162.63 Q7904.4 ; Q7904.1 247.38,164.83 247.75,165.19 v1(247.75,165.32)
  BOTTOM w0.14: v1(247.75,165.32) 247.54,165.12 247.54,163.03 v1(246.83,162.32)
N31870285: length 7.2
  TOP w0.14: v1(243.35,164.63) 243.35,165.02 244.07,165.74 Q7831.2 ; R20994.2 v1(241.32,165.32) 241.45,165.32 241.8,165.68 241.8,166.66 242.21,167.06 Q7832.3
  BOTTOM w0.14: v1(241.32,165.32) 242.01,164.63 v1(243.35,164.63)
N31870300: length 4.7
  TOP w0.14: Q7827.2 243.91,163.53 243.34,164.1 242.84,164.1 242.59,164.35 Q7828.3 241.98,164.85 241.31,164.18 R20988.2
N31931077: length 1.3
  TOP w0.14: U13093.30 265.81,48.98 R21057.1
N31931449: length 3.5
  TOP w0.14: v1(335.91,51.78) 335.91,51.83 335.35,52.39 335.16,52.39 335.03,52.53 U13025.27
  BOTTOM w0.14: T33.1 335.59,50.86 335.59,51.46 v1(335.91,51.78)
N31931452: length 3.1
  TOP w0.14: U13025.26 334.63,52.48 v1(335.25,51.86)
  BOTTOM w0.14: T29.1 335.22,50.81 335.22,51.83 v1(335.25,51.86)
N31931461: length 4.2
  TOP w0.14: U13025.29 336.28,53.9 v1(336.87,53.31) 337.74,52.44 R67382.1 v1(337.77,51.76)
  BOTTOM w0.14: R67397.1 337.7,51.83 v1(337.77,51.76)
N31931505: length 1.8
  TOP w0.178: U13025.35 v1(336.93,56.3)
  BOTTOM w0.14: v1(336.93,56.3) 336.85,56.23 T31.1
N31931507: length 1.6
  TOP w0.14: U13025.3 334.63,59.83 334.03,60.45 T32.1
N31931509: length 1.9
  TOP w0.178: v1(336.87,57.5) 336.87,57.5 U13025.38
  BOTTOM w0.14: v1(336.87,57.5) 336.87,57.55 336.82,57.5 T30.1
N31995423: length 8.3
  TOP w0.203: U13108.20 29.14,35.14 29.08,35.21 29.08,35.98 28.67,36.39 27.35,36.39 v1(26.94,35.98)
  BOTTOM w0.203: v1(26.94,35.98) 26.56,35.6 C94932.1 26.56,35.01 25.73,35.01 C94931.1 25.66,35.48 25.33,35.81 24.27,35.81 L4273.1
N31995611: length 4.8
  TOP w0.14: v1(33.32,35.02) 33.32,35.45 32.95,35.82 31.43,35.82 30.74,35.13 U13108.16
  BOTTOM w0.14: R21453.1 33.65,35.35 v1(33.32,35.02)
N31996495:
  vias: v1(43.58,48.56)
N32024602: length 3.7
  TOP w0.102: v4(201.54,135) U13135.H13
  BOTTOM w0.14: v4(201.54,135) 201.06,134.52 201.06,133.72 201.44,133.34 201.44,132.93 201.68,132.7 R21861.2
N32027102: length 19.8
  TOP w0.14: v1(356.71,73.5) 356.71,73.5 U13112.4
  TOP w0.508: U13112.1 359.99,76.5 360.45,76.04 360.45,74.01 359.94,73.5 ; U13112.4 359.94,73.5 ; 359.94,73.5 360.45,72.99 360.45,71.01 359.94,70.5 ; 359.94,70.5 U13112.7 ; 359.94,70.5 360.4,70.04 360.4,68.04 v1(360.09,67.73) 359.86,67.5 U13112.10
  BOTTOM w0.508: v1(360.09,67.73) 359.77,67.41 C94992.1
N32050492: length 1.4
  TOP w0.14: v4(198.29,123.75) U13136.H13
  BOTTOM w0.14: R21863.2 198.62,123.75 v4(198.29,123.75)
N32068560: length 2.1
  TOP w0.14: v4(180.2,172.53) U13137.H13
  BOTTOM w0.14: v4(180.2,172.53) 180.41,172.75 181.15,172.75 R21865.2
N32077141: length 3.6
  TOP w0.14: v4(198.29,158.81) U13138.H13
  BOTTOM w0.14: R21868.2 199.34,160.55 198.89,160.1 198.89,159.4 v4(198.29,158.81)
N32082063: length 3
  TOP w0.14: v4(136.76,172.53) U13139.H13
  BOTTOM w0.14: v4(136.76,172.53) 137.26,172.03 139.05,172.03 R67200.2
N32088630: length 2.1
  TOP w0.14: U13140.H13 147.25,169.28 v4(147.25,169.28)
  BOTTOM w0.14: R21873.2 146.52,170.02 v4(147.25,169.28)
N32090895: length 4.9
  TOP w0.14: U13113.L2 297.07,52.92 297.07,52.8 297.23,52.65 297.23,49.93 297.57,49.58 297.57,49.12 TP13142.1
N32090898: length 4.7
  TOP w0.14: TP13143.1 297.05,48.86 297.31,49.11 297.31,49.47 296.96,49.82 296.96,52.54 296.81,52.69 296.81,52.72 296.78,52.75 U13113.L1
N32092703: length 3.1
  TOP w0.14: v4(120.82,132.9) U13141.H13
  BOTTOM w0.14: v4(120.82,132.9) 120.39,133.33 120.39,134.77 R21875.2
N32098420: length 3.7
  TOP w0.254: U13142.H13 v4(124.07,144.15)
  BOTTOM w0.254: R67201.2 122.96,142.53 123.31,142.89 123.31,143.77 123.69,144.15 v4(124.07,144.15)
N32113508: length 2
  BOTTOM w0.14: TP13119.1 70.49,19.41 CN2069.56
N32113521: length 2.8
  BOTTOM w0.14: TP13120.1 71.42,17.83 CN2069.58
N32125182: length 5.9
  TOP w0.127: U13113.AW17 310.43,60.61 309.9,60.08 v2(309.82,60.08)
  BOTTOM w0.14: T9023.1 311.81,58.51 309.27,58.51 308.96,58.82 308.96,59.22 v2(309.82,60.08)
N32178168: length 5.2
  TOP w0.081: 368.27,29.83 368.27,29.81 368.37,29.71 368.37,29.3 368.62,29.05 U13155.F10
  TOP w0.14: 368.27,29.83 368.27,30.38 367.85,30.8 v1(367.85,30.91)
  BOTTOM w0.14: v1(367.85,30.91) 367.85,31.12 366.42,32.55 v1(366.42,32.59) R67179.1
N32328076: length 2
  TOP w0.102: v2(308.05,60.04) 308.05,59.98 307.61,59.55 U13113.AN15
  BOTTOM w0.14: v2(308.05,60.04) 308.81,60.8 TP13126.1
N32337959: length 3.2
  BOTTOM w0.14: TP13123.1 45.87,19.98 45.87,18.28 CN2070.58
N32345066: length 10.7
  IN1 w0.089: CN2070.10 32.21,16.65 30.91,16.65 30.47,17.09 30.47,18.15 33.73,21.4 v1(33.73,21.86)
  BOTTOM w0.14: TP13121.1 v1(33.73,21.86)
N32372225: length 2.1
  BOTTOM w0.14: CN2070.56 44.49,19.05 44.22,19.32 TP13122.1
N32522422: length 3.5
  TOP w0.14: U13147.15 70.94,45.74 71.39,46.19 71.39,47.21 71.65,47.46 R21915.1
N32522507: length 4.2
  TOP w0.14: U13147.22 67.57,43.64 67,44.21 66.98,44.21 v1(66.3,44.89)
  BOTTOM w0.14: v1(66.3,44.89) 66.3,45.06 65.28,46.08 R21900.1
N32522548: length 4
  TOP w0.14: v1(66.29,44.19) 66.59,43.89 66.92,43.89 67.57,43.24 U13147.23
  BOTTOM w0.14: v1(66.29,44.19) 66.29,44.24 65.84,44.69 65.84,45.02 65.58,45.28 R21901.1
N32522591: length 3.9
  TOP w0.14: U13147.27 67.36,41.64 67.22,41.78 66.83,41.78 66.47,41.42 v1(65.93,41.42) v1(65.45,40.94)
  BOTTOM w0.14: R21902.1 65.73,41.22 v1(65.93,41.42)
N32522606: length 3.1
  TOP w0.178: v1(71.9,46.7) 71.89,46.69 71.89,46.18 71.34,45.63 U13147.14
  BOTTOM w0.254: C96202.2 71.52,46.32 v1(71.9,46.7)
N32522766: length 4.9
  TOP w0.14: U13147.7 74.77,43.64 74.96,43.44 75.38,43.44 75.74,43.81 75.74,44.16 76.27,44.7 v1(76.27,45.84)
  BOTTOM w0.14: v1(76.27,45.84) 76.42,45.69 R21908.1
N32522794: length 2.1
  TOP w0.14: U13147.1 74.45,41.24 75.16,40.53 R21916.1
N32532892: length 3.5
  TOP w0.14: U13149.15 45.54,40.15 45.99,40.6 45.99,41.26 46.5,41.77 R21972.1
N32533102: length 3.3
  TOP w0.14: R21952.1 56.28,50.66 55.7,50.08 55.7,48.91 55.32,48.53 U13148.15
N32533214: length 4.5
  TOP w0.14: U13148.22 51.85,46.94 51.71,47.08 51.71,47.82 50.87,48.66 v1(50.59,48.66)
  BOTTOM w0.14: R21936.1 50.59,48.76 v1(50.59,48.66)
N32533261: length 4.2
  TOP w0.14: U13148.23 51.69,46.54 51.39,46.84 51.39,47.69 51.07,48.01 v1(50.52,48.01)
  BOTTOM w0.14: v1(50.52,48.01) 50,48.53 R21937.1
N32533302: length 3.3
  TOP w0.14: v1(50.59,44.49) 51.29,45.19 51.66,45.19 51.91,44.94 U13148.27
  BOTTOM w0.14: R21938.1 50.31,44.21 v1(50.59,44.49)
N32533309: length 3.1
  TOP w0.178: v1(56.27,49.94) 56.03,49.7 56.03,48.73 55.72,48.43 U13148.14
  BOTTOM w0.254: C96204.2 55.83,50.38 v1(56.27,49.94)
N32533452: length 2.9
  TOP w0.14: v1(41.19,39.13) 41.19,39.03 42.3,37.92 U13149.22
  BOTTOM w0.14: v1(41.19,39.13) 41.65,38.68 R21947.1
N32533494: length 3.8
  TOP w0.14: U13148.7 59.08,46.94 59.29,46.73 59.72,46.73 60.01,47.02 60.01,47.29 v1(60.19,47.46) 60.19,47.79 v1(59.89,48.1)
  BOTTOM w0.14: R21944.1 60.74,48.01 v1(60.19,47.46)
N32533537: length 4.3
  TOP w0.14: U13148.1 59.01,44.03 59.01,42.42 v1(59.46,41.98) 59.5,41.93 60.72,41.93 R21953.1
N32533642: length 4.4
  TOP w0.14: v1(40.14,39.9) R21957.1 40.14,38.64 40.61,38.17 41.63,38.17 42.27,37.52 U13149.23
N32533766: length 3.4
  TOP w0.14: U13149.27 42.21,35.92 42.15,35.98 41.52,35.98 40.99,35.45 v1(40.99,35.04) 40.69,34.74 R21958.1
N32533781: length 3.3
  TOP w0.178: v1(46.5,41.06) 46.49,41.05 46.49,40.67 45.94,40.12 U13149.14
  BOTTOM w0.254: v1(46.5,41.06) 46.55,41.11 C96203.2
N32534005: length 5.1
  TOP w0.14: v1(52.62,38.4) 52.37,38.65 51.52,38.65 R21964.1 50.24,38.48 50.24,38.09 49.94,37.8 49.55,37.8 49.43,37.92 U13149.7
N32534049: length 3.9
  TOP w0.14: R21973.1 50.54,33.01 v1(49.98,33.57) 49.42,34.13 49.42,35.14 49.05,35.52 U13149.1
N32686297: length 6.3
  TOP w0.14: U49.20 179.21,58 179.41,58.2 181.03,58.2 181.58,57.65 v1(181.58,57.6)
  BOTTOM w0.14: v1(183.61,58.63) R67039.2 182.16,58.63 R67264.1 181.79,57.81 v1(181.58,57.6)
N32869672: length 3
  TOP w0.254: R21995.2 51.08,64.86 v1(51.09,64.87) 51.72,65.5 CN2068.36
N33146604: length 7.7
  TOP w0.14: v2(311.32,54.37) 310.95,54.37 U13113.AW4
  BOTTOM w0.14: v2(311.32,54.37) 311.14,54.37 310.76,53.99 310.76,53.66 v1(310.2,53.1) 310.2,52.24 310.64,51.8 310.64,51.03 310.2,50.59 310.2,50.03 310.41,49.83 R22050.2 R67072.2
N33266779: length 4
  TOP w0.14: U49.87 194.96,62 v1(195.24,61.71)
  BOTTOM w0.14: R67294.2 R67295.2 193.6,61.72 193.77,61.89 195.07,61.89 v1(195.24,61.71)
N33277676: length 1.4
  TOP w0.14: U13113.AJ35 305.15,69.77 v2(304.97,69.77)
  BOTTOM w0.14: v2(304.97,69.77) 304.92,69.77 304.74,69.94 T77.1
N33277677: length 6.7
  TOP w0.102: 304.92,75.25 305.1,75.08 305.1,74.46 304.88,74.01 U13113.AH44
  TOP w0.14: 304.92,75.25 304.61,75.57 304.61,77.4 304.23,77.77 304.23,78.83 304.28,78.88 304.28,79.77 304.44,79.93 T76.1
N33341392: length 2.1
  TOP w0.14: v2(309.44,72.08) 309.6,72.23 U13113.AU41
  BOTTOM w0.14: v2(309.44,72.08) 309.54,72.18 309.54,72.79 TP13127.1
N33341397: length 7.8
  TOP w0.102: 308.27,76.27 308.4,76.14 308.4,74.74 308.51,74.64 308.51,73.83 U13113.AT43
  TOP w0.14: TP13128.1 308,79.72 308.27,79.44 308.27,76.27
N33341415: length 6.1
  TOP w0.102: U13113.AT44 308.71,74.22 308.71,74.81 308.63,74.9 308.63,75.98
  TOP w0.14: TP13129.1 308.55,79.57 308.55,77.12 308.63,77.04 308.63,75.98
N33354874: length 9.1
  TOP w0.14: R21587.2 129.43,116.14 129.66,116.37 Q7856.3 129.19,116.66 128.7,117.16 128.7,118.8 128.85,118.95 Q7855.2 129.32,118.95 129.81,118.46 130.45,118.46 v1(131.01,119.02)
  BOTTOM w0.14: v1(131.01,119.02) 130.54,119.02 130.35,119.21 Q7945.2 129.83,119.89 v1(129.64,120.08)
N33487842: length 1.7
  TOP w0.102: U13113.AR24 308.4,63.79 v2(308.07,63.47)
  BOTTOM w0.14: TP13137.1 308.07,63.69 v2(308.07,63.47)
N33567226: length 1.8
  TOP w0.14: v1(337.13,75.92) U13079.38
  BOTTOM w0.14: T58.1 336.55,76.45 v1(337.13,75.92)
N33567227: length 2
  TOP w0.14: v1(337.38,74.71) U13079.35
  BOTTOM w0.14: v1(337.38,74.71) 337.25,74.71 T59.1
N33567228: length 1.3
  TOP w0.14: T60.1 334.88,78.85 U13079.3
N33625973: length 2.1
  TOP w0.14: U13079.27 335.28,70.88 335.34,70.82 335.34,70.78 335.44,70.68 v1(335.81,70.68)
  BOTTOM w0.14: v1(335.81,70.68) 335.81,70.02 T56.1
N33625978: length 1.8
  TOP w0.14: T57.1 335.1,70.52 335.1,70.72 334.88,70.94 U13079.26
N33701634:
  vias: v1(256.92,170.17)
N33701636:
  vias: v1(253.92,165.42)
N33701676: length 1.1
  TOP w0.14: U13081.3 254.88,169.01 v1(254.88,170.07)
N33739416: length 3.5
  TOP w0.14: R21740.1 61.16,38.67 61.16,37.81 60.78,37.43 U13146.15
N33739501: length 3.9
  TOP w0.14: R21984.1 v1(56.56,37.2) 56.56,37.02 56.34,36.81 56.34,36.35 57.57,35.13 U13146.22
N33739542: length 4.8
  TOP w0.14: v1(54.09,35.87) 54.34,35.87 54.63,35.58 55.22,35.58 R21979.1 56.21,36.08 57.57,34.73 U13146.23
N33739589: length 2.9
  TOP w0.14: R21986.1 56.32,32.49 56.32,32.67 v1(56.76,33.11) 56.78,33.13 U13146.27
N33739604: length 3
  TOP w0.178: U13146.14 61.18,37.38 61.73,37.93 v1(61.73,38.16)
  BOTTOM w0.203: v1(61.73,38.16) 62.02,38.45 C96201.2
N33739796: length 2.3
  TOP w0.14: R21988.1 65.32,36.34 64.79,35.81 64.79,35.45 64.47,35.13 U13146.7
N33739832: length 3.5
  TOP w0.14: U13146.1 63.75,32.52 63.75,31.77 v1(64.64,30.88) 65.44,30.07 R21981.1
N33795012: length 6
  TOP w0.14: R22083.2 34.92,34.86 34.92,33.09 34.75,32.92 34.75,32.62 v1(34.56,32.43) 34.75,32.24 34.75,31.66 34.03,30.93 33.58,30.93 33.51,30.86 U13108.5
N33796046: length 4.8
  TOP w0.14: U13108.4 34.4,30.46 v1(34.49,30.55) 34.55,30.61 34.55,31.12 35,31.56 35,32.76 35.38,33.14 R22084.1
N33796156: length 4.6
  TOP w0.14: v1(32.46,34.76) 32.46,34.92 32.13,35.25 31.69,35.25 31.54,35.09 U13108.14
  BOTTOM w0.14: C94947.1 32.35,34.66 v1(32.46,34.76) 32,35.22 R21454.1 31.63,35.36 31.16,35.83 v1(31.16,36.14)
N33856405: length 6.9
  TOP w0.203: v1(24.02,29.56) 24.91,29.56 25.76,30.41 26.04,30.41 26.1,30.46 U13108.33
  BOTTOM w0.203: R22090.2 23.26,32.66 23.35,32.57 R22091.2 23.35,30.82 24.02,30.14 v1(24.02,29.56)
N33857317: length 2.6
  TOP w0.203: TP13149.1 25.21,28.66 25.21,28.92 25.96,29.66 U13108.35
N33860479: length 2.3
  TOP w0.14: U13108.1 32.9,29.26 33.75,28.41 34.44,28.41 TP13100.1
N34193347: length 11.8
  BOTTOM w0.203: PR188.1 80.28,67.53 80.03,67.28
  BOTTOM w0.254: PR67004.2 71.16,64.51 74.11,64.51 76.57,66.97 v1(76.83,66.97) 79.2,66.97 79.51,67.28 80.03,67.28
N34193617: length 19.9
  BOTTOM w0.203: PR184.2 82.82,67.66 83.21,67.28 84.04,67.28 v1(84.74,66.58) 85.64,65.68 92.55,65.68 94.46,63.77 99.13,63.77 99.49,63.42 100.6,63.42 PR67006.2
